.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_128ck40 FIND v(dout0_128) AT=25.025n

.meas tran vdout0_129ck40 FIND v(dout0_129) AT=25.025n

.meas tran vdout0_130ck40 FIND v(dout0_130) AT=25.025n

.meas tran vdout0_131ck40 FIND v(dout0_131) AT=25.025n

.meas tran vdout0_132ck40 FIND v(dout0_132) AT=25.025n

.meas tran vdout0_133ck40 FIND v(dout0_133) AT=25.025n

.meas tran vdout0_134ck40 FIND v(dout0_134) AT=25.025n

.meas tran vdout0_135ck40 FIND v(dout0_135) AT=25.025n

.meas tran vdout0_136ck40 FIND v(dout0_136) AT=25.025n

.meas tran vdout0_137ck40 FIND v(dout0_137) AT=25.025n

.meas tran vdout0_138ck40 FIND v(dout0_138) AT=25.025n

.meas tran vdout0_139ck40 FIND v(dout0_139) AT=25.025n

.meas tran vdout0_140ck40 FIND v(dout0_140) AT=25.025n

.meas tran vdout0_141ck40 FIND v(dout0_141) AT=25.025n

.meas tran vdout0_142ck40 FIND v(dout0_142) AT=25.025n

.meas tran vdout0_143ck40 FIND v(dout0_143) AT=25.025n

.meas tran vdout0_144ck40 FIND v(dout0_144) AT=25.025n

.meas tran vdout0_145ck40 FIND v(dout0_145) AT=25.025n

.meas tran vdout0_146ck40 FIND v(dout0_146) AT=25.025n

.meas tran vdout0_147ck40 FIND v(dout0_147) AT=25.025n

.meas tran vdout0_148ck40 FIND v(dout0_148) AT=25.025n

.meas tran vdout0_149ck40 FIND v(dout0_149) AT=25.025n

.meas tran vdout0_0ck50 FIND v(dout0_0) AT=30.025n

.meas tran vdout0_1ck50 FIND v(dout0_1) AT=30.025n

.meas tran vdout0_2ck50 FIND v(dout0_2) AT=30.025n

.meas tran vdout0_3ck50 FIND v(dout0_3) AT=30.025n

.meas tran vdout0_4ck50 FIND v(dout0_4) AT=30.025n

.meas tran vdout0_5ck50 FIND v(dout0_5) AT=30.025n

.meas tran vdout0_6ck50 FIND v(dout0_6) AT=30.025n

.meas tran vdout0_7ck50 FIND v(dout0_7) AT=30.025n

.meas tran vdout0_8ck50 FIND v(dout0_8) AT=30.025n

.meas tran vdout0_9ck50 FIND v(dout0_9) AT=30.025n

.meas tran vdout0_10ck50 FIND v(dout0_10) AT=30.025n

.meas tran vdout0_11ck50 FIND v(dout0_11) AT=30.025n

.meas tran vdout0_12ck50 FIND v(dout0_12) AT=30.025n

.meas tran vdout0_13ck50 FIND v(dout0_13) AT=30.025n

.meas tran vdout0_14ck50 FIND v(dout0_14) AT=30.025n

.meas tran vdout0_15ck50 FIND v(dout0_15) AT=30.025n

.meas tran vdout0_16ck50 FIND v(dout0_16) AT=30.025n

.meas tran vdout0_17ck50 FIND v(dout0_17) AT=30.025n

.meas tran vdout0_18ck50 FIND v(dout0_18) AT=30.025n

.meas tran vdout0_19ck50 FIND v(dout0_19) AT=30.025n

.meas tran vdout0_20ck50 FIND v(dout0_20) AT=30.025n

.meas tran vdout0_21ck50 FIND v(dout0_21) AT=30.025n

.meas tran vdout0_22ck50 FIND v(dout0_22) AT=30.025n

.meas tran vdout0_23ck50 FIND v(dout0_23) AT=30.025n

.meas tran vdout0_24ck50 FIND v(dout0_24) AT=30.025n

.meas tran vdout0_25ck50 FIND v(dout0_25) AT=30.025n

.meas tran vdout0_26ck50 FIND v(dout0_26) AT=30.025n

.meas tran vdout0_27ck50 FIND v(dout0_27) AT=30.025n

.meas tran vdout0_28ck50 FIND v(dout0_28) AT=30.025n

.meas tran vdout0_29ck50 FIND v(dout0_29) AT=30.025n

.meas tran vdout0_30ck50 FIND v(dout0_30) AT=30.025n

.meas tran vdout0_31ck50 FIND v(dout0_31) AT=30.025n

.meas tran vdout0_32ck50 FIND v(dout0_32) AT=30.025n

.meas tran vdout0_33ck50 FIND v(dout0_33) AT=30.025n

.meas tran vdout0_34ck50 FIND v(dout0_34) AT=30.025n

.meas tran vdout0_35ck50 FIND v(dout0_35) AT=30.025n

.meas tran vdout0_36ck50 FIND v(dout0_36) AT=30.025n

.meas tran vdout0_37ck50 FIND v(dout0_37) AT=30.025n

.meas tran vdout0_38ck50 FIND v(dout0_38) AT=30.025n

.meas tran vdout0_39ck50 FIND v(dout0_39) AT=30.025n

.meas tran vdout0_40ck50 FIND v(dout0_40) AT=30.025n

.meas tran vdout0_41ck50 FIND v(dout0_41) AT=30.025n

.meas tran vdout0_42ck50 FIND v(dout0_42) AT=30.025n

.meas tran vdout0_43ck50 FIND v(dout0_43) AT=30.025n

.meas tran vdout0_44ck50 FIND v(dout0_44) AT=30.025n

.meas tran vdout0_45ck50 FIND v(dout0_45) AT=30.025n

.meas tran vdout0_46ck50 FIND v(dout0_46) AT=30.025n

.meas tran vdout0_47ck50 FIND v(dout0_47) AT=30.025n

.meas tran vdout0_48ck50 FIND v(dout0_48) AT=30.025n

.meas tran vdout0_49ck50 FIND v(dout0_49) AT=30.025n

.meas tran vdout0_50ck50 FIND v(dout0_50) AT=30.025n

.meas tran vdout0_51ck50 FIND v(dout0_51) AT=30.025n

.meas tran vdout0_52ck50 FIND v(dout0_52) AT=30.025n

.meas tran vdout0_53ck50 FIND v(dout0_53) AT=30.025n

.meas tran vdout0_54ck50 FIND v(dout0_54) AT=30.025n

.meas tran vdout0_55ck50 FIND v(dout0_55) AT=30.025n

.meas tran vdout0_56ck50 FIND v(dout0_56) AT=30.025n

.meas tran vdout0_57ck50 FIND v(dout0_57) AT=30.025n

.meas tran vdout0_58ck50 FIND v(dout0_58) AT=30.025n

.meas tran vdout0_59ck50 FIND v(dout0_59) AT=30.025n

.meas tran vdout0_60ck50 FIND v(dout0_60) AT=30.025n

.meas tran vdout0_61ck50 FIND v(dout0_61) AT=30.025n

.meas tran vdout0_62ck50 FIND v(dout0_62) AT=30.025n

.meas tran vdout0_63ck50 FIND v(dout0_63) AT=30.025n

.meas tran vdout0_64ck50 FIND v(dout0_64) AT=30.025n

.meas tran vdout0_65ck50 FIND v(dout0_65) AT=30.025n

.meas tran vdout0_66ck50 FIND v(dout0_66) AT=30.025n

.meas tran vdout0_67ck50 FIND v(dout0_67) AT=30.025n

.meas tran vdout0_68ck50 FIND v(dout0_68) AT=30.025n

.meas tran vdout0_69ck50 FIND v(dout0_69) AT=30.025n

.meas tran vdout0_70ck50 FIND v(dout0_70) AT=30.025n

.meas tran vdout0_71ck50 FIND v(dout0_71) AT=30.025n

.meas tran vdout0_72ck50 FIND v(dout0_72) AT=30.025n

.meas tran vdout0_73ck50 FIND v(dout0_73) AT=30.025n

.meas tran vdout0_74ck50 FIND v(dout0_74) AT=30.025n

.meas tran vdout0_75ck50 FIND v(dout0_75) AT=30.025n

.meas tran vdout0_76ck50 FIND v(dout0_76) AT=30.025n

.meas tran vdout0_77ck50 FIND v(dout0_77) AT=30.025n

.meas tran vdout0_78ck50 FIND v(dout0_78) AT=30.025n

.meas tran vdout0_79ck50 FIND v(dout0_79) AT=30.025n

.meas tran vdout0_80ck50 FIND v(dout0_80) AT=30.025n

.meas tran vdout0_81ck50 FIND v(dout0_81) AT=30.025n

.meas tran vdout0_82ck50 FIND v(dout0_82) AT=30.025n

.meas tran vdout0_83ck50 FIND v(dout0_83) AT=30.025n

.meas tran vdout0_84ck50 FIND v(dout0_84) AT=30.025n

.meas tran vdout0_85ck50 FIND v(dout0_85) AT=30.025n

.meas tran vdout0_86ck50 FIND v(dout0_86) AT=30.025n

.meas tran vdout0_87ck50 FIND v(dout0_87) AT=30.025n

.meas tran vdout0_88ck50 FIND v(dout0_88) AT=30.025n

.meas tran vdout0_89ck50 FIND v(dout0_89) AT=30.025n

.meas tran vdout0_90ck50 FIND v(dout0_90) AT=30.025n

.meas tran vdout0_91ck50 FIND v(dout0_91) AT=30.025n

.meas tran vdout0_92ck50 FIND v(dout0_92) AT=30.025n

.meas tran vdout0_93ck50 FIND v(dout0_93) AT=30.025n

.meas tran vdout0_94ck50 FIND v(dout0_94) AT=30.025n

.meas tran vdout0_95ck50 FIND v(dout0_95) AT=30.025n

.meas tran vdout0_96ck50 FIND v(dout0_96) AT=30.025n

.meas tran vdout0_97ck50 FIND v(dout0_97) AT=30.025n

.meas tran vdout0_98ck50 FIND v(dout0_98) AT=30.025n

.meas tran vdout0_99ck50 FIND v(dout0_99) AT=30.025n

.meas tran vdout0_100ck50 FIND v(dout0_100) AT=30.025n

.meas tran vdout0_101ck50 FIND v(dout0_101) AT=30.025n

.meas tran vdout0_102ck50 FIND v(dout0_102) AT=30.025n

.meas tran vdout0_103ck50 FIND v(dout0_103) AT=30.025n

.meas tran vdout0_104ck50 FIND v(dout0_104) AT=30.025n

.meas tran vdout0_105ck50 FIND v(dout0_105) AT=30.025n

.meas tran vdout0_106ck50 FIND v(dout0_106) AT=30.025n

.meas tran vdout0_107ck50 FIND v(dout0_107) AT=30.025n

.meas tran vdout0_108ck50 FIND v(dout0_108) AT=30.025n

.meas tran vdout0_109ck50 FIND v(dout0_109) AT=30.025n

.meas tran vdout0_110ck50 FIND v(dout0_110) AT=30.025n

.meas tran vdout0_111ck50 FIND v(dout0_111) AT=30.025n

.meas tran vdout0_112ck50 FIND v(dout0_112) AT=30.025n

.meas tran vdout0_113ck50 FIND v(dout0_113) AT=30.025n

.meas tran vdout0_114ck50 FIND v(dout0_114) AT=30.025n

.meas tran vdout0_115ck50 FIND v(dout0_115) AT=30.025n

.meas tran vdout0_116ck50 FIND v(dout0_116) AT=30.025n

.meas tran vdout0_117ck50 FIND v(dout0_117) AT=30.025n

.meas tran vdout0_118ck50 FIND v(dout0_118) AT=30.025n

.meas tran vdout0_119ck50 FIND v(dout0_119) AT=30.025n

.meas tran vdout0_120ck50 FIND v(dout0_120) AT=30.025n

.meas tran vdout0_121ck50 FIND v(dout0_121) AT=30.025n

.meas tran vdout0_122ck50 FIND v(dout0_122) AT=30.025n

.meas tran vdout0_123ck50 FIND v(dout0_123) AT=30.025n

.meas tran vdout0_124ck50 FIND v(dout0_124) AT=30.025n

.meas tran vdout0_125ck50 FIND v(dout0_125) AT=30.025n

.meas tran vdout0_126ck50 FIND v(dout0_126) AT=30.025n

.meas tran vdout0_127ck50 FIND v(dout0_127) AT=30.025n

.meas tran vdout0_128ck50 FIND v(dout0_128) AT=30.025n

.meas tran vdout0_129ck50 FIND v(dout0_129) AT=30.025n

.meas tran vdout0_130ck50 FIND v(dout0_130) AT=30.025n

.meas tran vdout0_131ck50 FIND v(dout0_131) AT=30.025n

.meas tran vdout0_132ck50 FIND v(dout0_132) AT=30.025n

.meas tran vdout0_133ck50 FIND v(dout0_133) AT=30.025n

.meas tran vdout0_134ck50 FIND v(dout0_134) AT=30.025n

.meas tran vdout0_135ck50 FIND v(dout0_135) AT=30.025n

.meas tran vdout0_136ck50 FIND v(dout0_136) AT=30.025n

.meas tran vdout0_137ck50 FIND v(dout0_137) AT=30.025n

.meas tran vdout0_138ck50 FIND v(dout0_138) AT=30.025n

.meas tran vdout0_139ck50 FIND v(dout0_139) AT=30.025n

.meas tran vdout0_140ck50 FIND v(dout0_140) AT=30.025n

.meas tran vdout0_141ck50 FIND v(dout0_141) AT=30.025n

.meas tran vdout0_142ck50 FIND v(dout0_142) AT=30.025n

.meas tran vdout0_143ck50 FIND v(dout0_143) AT=30.025n

.meas tran vdout0_144ck50 FIND v(dout0_144) AT=30.025n

.meas tran vdout0_145ck50 FIND v(dout0_145) AT=30.025n

.meas tran vdout0_146ck50 FIND v(dout0_146) AT=30.025n

.meas tran vdout0_147ck50 FIND v(dout0_147) AT=30.025n

.meas tran vdout0_148ck50 FIND v(dout0_148) AT=30.025n

.meas tran vdout0_149ck50 FIND v(dout0_149) AT=30.025n

.meas tran vdout0_0ck60 FIND v(dout0_0) AT=35.025n

.meas tran vdout0_1ck60 FIND v(dout0_1) AT=35.025n

.meas tran vdout0_2ck60 FIND v(dout0_2) AT=35.025n

.meas tran vdout0_3ck60 FIND v(dout0_3) AT=35.025n

.meas tran vdout0_4ck60 FIND v(dout0_4) AT=35.025n

.meas tran vdout0_5ck60 FIND v(dout0_5) AT=35.025n

.meas tran vdout0_6ck60 FIND v(dout0_6) AT=35.025n

.meas tran vdout0_7ck60 FIND v(dout0_7) AT=35.025n

.meas tran vdout0_8ck60 FIND v(dout0_8) AT=35.025n

.meas tran vdout0_9ck60 FIND v(dout0_9) AT=35.025n

.meas tran vdout0_10ck60 FIND v(dout0_10) AT=35.025n

.meas tran vdout0_11ck60 FIND v(dout0_11) AT=35.025n

.meas tran vdout0_12ck60 FIND v(dout0_12) AT=35.025n

.meas tran vdout0_13ck60 FIND v(dout0_13) AT=35.025n

.meas tran vdout0_14ck60 FIND v(dout0_14) AT=35.025n

.meas tran vdout0_15ck60 FIND v(dout0_15) AT=35.025n

.meas tran vdout0_16ck60 FIND v(dout0_16) AT=35.025n

.meas tran vdout0_17ck60 FIND v(dout0_17) AT=35.025n

.meas tran vdout0_18ck60 FIND v(dout0_18) AT=35.025n

.meas tran vdout0_19ck60 FIND v(dout0_19) AT=35.025n

.meas tran vdout0_20ck60 FIND v(dout0_20) AT=35.025n

.meas tran vdout0_21ck60 FIND v(dout0_21) AT=35.025n

.meas tran vdout0_22ck60 FIND v(dout0_22) AT=35.025n

.meas tran vdout0_23ck60 FIND v(dout0_23) AT=35.025n

.meas tran vdout0_24ck60 FIND v(dout0_24) AT=35.025n

.meas tran vdout0_25ck60 FIND v(dout0_25) AT=35.025n

.meas tran vdout0_26ck60 FIND v(dout0_26) AT=35.025n

.meas tran vdout0_27ck60 FIND v(dout0_27) AT=35.025n

.meas tran vdout0_28ck60 FIND v(dout0_28) AT=35.025n

.meas tran vdout0_29ck60 FIND v(dout0_29) AT=35.025n

.meas tran vdout0_30ck60 FIND v(dout0_30) AT=35.025n

.meas tran vdout0_31ck60 FIND v(dout0_31) AT=35.025n

.meas tran vdout0_32ck60 FIND v(dout0_32) AT=35.025n

.meas tran vdout0_33ck60 FIND v(dout0_33) AT=35.025n

.meas tran vdout0_34ck60 FIND v(dout0_34) AT=35.025n

.meas tran vdout0_35ck60 FIND v(dout0_35) AT=35.025n

.meas tran vdout0_36ck60 FIND v(dout0_36) AT=35.025n

.meas tran vdout0_37ck60 FIND v(dout0_37) AT=35.025n

.meas tran vdout0_38ck60 FIND v(dout0_38) AT=35.025n

.meas tran vdout0_39ck60 FIND v(dout0_39) AT=35.025n

.meas tran vdout0_40ck60 FIND v(dout0_40) AT=35.025n

.meas tran vdout0_41ck60 FIND v(dout0_41) AT=35.025n

.meas tran vdout0_42ck60 FIND v(dout0_42) AT=35.025n

.meas tran vdout0_43ck60 FIND v(dout0_43) AT=35.025n

.meas tran vdout0_44ck60 FIND v(dout0_44) AT=35.025n

.meas tran vdout0_45ck60 FIND v(dout0_45) AT=35.025n

.meas tran vdout0_46ck60 FIND v(dout0_46) AT=35.025n

.meas tran vdout0_47ck60 FIND v(dout0_47) AT=35.025n

.meas tran vdout0_48ck60 FIND v(dout0_48) AT=35.025n

.meas tran vdout0_49ck60 FIND v(dout0_49) AT=35.025n

.meas tran vdout0_50ck60 FIND v(dout0_50) AT=35.025n

.meas tran vdout0_51ck60 FIND v(dout0_51) AT=35.025n

.meas tran vdout0_52ck60 FIND v(dout0_52) AT=35.025n

.meas tran vdout0_53ck60 FIND v(dout0_53) AT=35.025n

.meas tran vdout0_54ck60 FIND v(dout0_54) AT=35.025n

.meas tran vdout0_55ck60 FIND v(dout0_55) AT=35.025n

.meas tran vdout0_56ck60 FIND v(dout0_56) AT=35.025n

.meas tran vdout0_57ck60 FIND v(dout0_57) AT=35.025n

.meas tran vdout0_58ck60 FIND v(dout0_58) AT=35.025n

.meas tran vdout0_59ck60 FIND v(dout0_59) AT=35.025n

.meas tran vdout0_60ck60 FIND v(dout0_60) AT=35.025n

.meas tran vdout0_61ck60 FIND v(dout0_61) AT=35.025n

.meas tran vdout0_62ck60 FIND v(dout0_62) AT=35.025n

.meas tran vdout0_63ck60 FIND v(dout0_63) AT=35.025n

.meas tran vdout0_64ck60 FIND v(dout0_64) AT=35.025n

.meas tran vdout0_65ck60 FIND v(dout0_65) AT=35.025n

.meas tran vdout0_66ck60 FIND v(dout0_66) AT=35.025n

.meas tran vdout0_67ck60 FIND v(dout0_67) AT=35.025n

.meas tran vdout0_68ck60 FIND v(dout0_68) AT=35.025n

.meas tran vdout0_69ck60 FIND v(dout0_69) AT=35.025n

.meas tran vdout0_70ck60 FIND v(dout0_70) AT=35.025n

.meas tran vdout0_71ck60 FIND v(dout0_71) AT=35.025n

.meas tran vdout0_72ck60 FIND v(dout0_72) AT=35.025n

.meas tran vdout0_73ck60 FIND v(dout0_73) AT=35.025n

.meas tran vdout0_74ck60 FIND v(dout0_74) AT=35.025n

.meas tran vdout0_75ck60 FIND v(dout0_75) AT=35.025n

.meas tran vdout0_76ck60 FIND v(dout0_76) AT=35.025n

.meas tran vdout0_77ck60 FIND v(dout0_77) AT=35.025n

.meas tran vdout0_78ck60 FIND v(dout0_78) AT=35.025n

.meas tran vdout0_79ck60 FIND v(dout0_79) AT=35.025n

.meas tran vdout0_80ck60 FIND v(dout0_80) AT=35.025n

.meas tran vdout0_81ck60 FIND v(dout0_81) AT=35.025n

.meas tran vdout0_82ck60 FIND v(dout0_82) AT=35.025n

.meas tran vdout0_83ck60 FIND v(dout0_83) AT=35.025n

.meas tran vdout0_84ck60 FIND v(dout0_84) AT=35.025n

.meas tran vdout0_85ck60 FIND v(dout0_85) AT=35.025n

.meas tran vdout0_86ck60 FIND v(dout0_86) AT=35.025n

.meas tran vdout0_87ck60 FIND v(dout0_87) AT=35.025n

.meas tran vdout0_88ck60 FIND v(dout0_88) AT=35.025n

.meas tran vdout0_89ck60 FIND v(dout0_89) AT=35.025n

.meas tran vdout0_90ck60 FIND v(dout0_90) AT=35.025n

.meas tran vdout0_91ck60 FIND v(dout0_91) AT=35.025n

.meas tran vdout0_92ck60 FIND v(dout0_92) AT=35.025n

.meas tran vdout0_93ck60 FIND v(dout0_93) AT=35.025n

.meas tran vdout0_94ck60 FIND v(dout0_94) AT=35.025n

.meas tran vdout0_95ck60 FIND v(dout0_95) AT=35.025n

.meas tran vdout0_96ck60 FIND v(dout0_96) AT=35.025n

.meas tran vdout0_97ck60 FIND v(dout0_97) AT=35.025n

.meas tran vdout0_98ck60 FIND v(dout0_98) AT=35.025n

.meas tran vdout0_99ck60 FIND v(dout0_99) AT=35.025n

.meas tran vdout0_100ck60 FIND v(dout0_100) AT=35.025n

.meas tran vdout0_101ck60 FIND v(dout0_101) AT=35.025n

.meas tran vdout0_102ck60 FIND v(dout0_102) AT=35.025n

.meas tran vdout0_103ck60 FIND v(dout0_103) AT=35.025n

.meas tran vdout0_104ck60 FIND v(dout0_104) AT=35.025n

.meas tran vdout0_105ck60 FIND v(dout0_105) AT=35.025n

.meas tran vdout0_106ck60 FIND v(dout0_106) AT=35.025n

.meas tran vdout0_107ck60 FIND v(dout0_107) AT=35.025n

.meas tran vdout0_108ck60 FIND v(dout0_108) AT=35.025n

.meas tran vdout0_109ck60 FIND v(dout0_109) AT=35.025n

.meas tran vdout0_110ck60 FIND v(dout0_110) AT=35.025n

.meas tran vdout0_111ck60 FIND v(dout0_111) AT=35.025n

.meas tran vdout0_112ck60 FIND v(dout0_112) AT=35.025n

.meas tran vdout0_113ck60 FIND v(dout0_113) AT=35.025n

.meas tran vdout0_114ck60 FIND v(dout0_114) AT=35.025n

.meas tran vdout0_115ck60 FIND v(dout0_115) AT=35.025n

.meas tran vdout0_116ck60 FIND v(dout0_116) AT=35.025n

.meas tran vdout0_117ck60 FIND v(dout0_117) AT=35.025n

.meas tran vdout0_118ck60 FIND v(dout0_118) AT=35.025n

.meas tran vdout0_119ck60 FIND v(dout0_119) AT=35.025n

.meas tran vdout0_120ck60 FIND v(dout0_120) AT=35.025n

.meas tran vdout0_121ck60 FIND v(dout0_121) AT=35.025n

.meas tran vdout0_122ck60 FIND v(dout0_122) AT=35.025n

.meas tran vdout0_123ck60 FIND v(dout0_123) AT=35.025n

.meas tran vdout0_124ck60 FIND v(dout0_124) AT=35.025n

.meas tran vdout0_125ck60 FIND v(dout0_125) AT=35.025n

.meas tran vdout0_126ck60 FIND v(dout0_126) AT=35.025n

.meas tran vdout0_127ck60 FIND v(dout0_127) AT=35.025n

.meas tran vdout0_128ck60 FIND v(dout0_128) AT=35.025n

.meas tran vdout0_129ck60 FIND v(dout0_129) AT=35.025n

.meas tran vdout0_130ck60 FIND v(dout0_130) AT=35.025n

.meas tran vdout0_131ck60 FIND v(dout0_131) AT=35.025n

.meas tran vdout0_132ck60 FIND v(dout0_132) AT=35.025n

.meas tran vdout0_133ck60 FIND v(dout0_133) AT=35.025n

.meas tran vdout0_134ck60 FIND v(dout0_134) AT=35.025n

.meas tran vdout0_135ck60 FIND v(dout0_135) AT=35.025n

.meas tran vdout0_136ck60 FIND v(dout0_136) AT=35.025n

.meas tran vdout0_137ck60 FIND v(dout0_137) AT=35.025n

.meas tran vdout0_138ck60 FIND v(dout0_138) AT=35.025n

.meas tran vdout0_139ck60 FIND v(dout0_139) AT=35.025n

.meas tran vdout0_140ck60 FIND v(dout0_140) AT=35.025n

.meas tran vdout0_141ck60 FIND v(dout0_141) AT=35.025n

.meas tran vdout0_142ck60 FIND v(dout0_142) AT=35.025n

.meas tran vdout0_143ck60 FIND v(dout0_143) AT=35.025n

.meas tran vdout0_144ck60 FIND v(dout0_144) AT=35.025n

.meas tran vdout0_145ck60 FIND v(dout0_145) AT=35.025n

.meas tran vdout0_146ck60 FIND v(dout0_146) AT=35.025n

.meas tran vdout0_147ck60 FIND v(dout0_147) AT=35.025n

.meas tran vdout0_148ck60 FIND v(dout0_148) AT=35.025n

.meas tran vdout0_149ck60 FIND v(dout0_149) AT=35.025n

.meas tran vdout0_0ck70 FIND v(dout0_0) AT=40.025n

.meas tran vdout0_1ck70 FIND v(dout0_1) AT=40.025n

.meas tran vdout0_2ck70 FIND v(dout0_2) AT=40.025n

.meas tran vdout0_3ck70 FIND v(dout0_3) AT=40.025n

.meas tran vdout0_4ck70 FIND v(dout0_4) AT=40.025n

.meas tran vdout0_5ck70 FIND v(dout0_5) AT=40.025n

.meas tran vdout0_6ck70 FIND v(dout0_6) AT=40.025n

.meas tran vdout0_7ck70 FIND v(dout0_7) AT=40.025n

.meas tran vdout0_8ck70 FIND v(dout0_8) AT=40.025n

.meas tran vdout0_9ck70 FIND v(dout0_9) AT=40.025n

.meas tran vdout0_10ck70 FIND v(dout0_10) AT=40.025n

.meas tran vdout0_11ck70 FIND v(dout0_11) AT=40.025n

.meas tran vdout0_12ck70 FIND v(dout0_12) AT=40.025n

.meas tran vdout0_13ck70 FIND v(dout0_13) AT=40.025n

.meas tran vdout0_14ck70 FIND v(dout0_14) AT=40.025n

.meas tran vdout0_15ck70 FIND v(dout0_15) AT=40.025n

.meas tran vdout0_16ck70 FIND v(dout0_16) AT=40.025n

.meas tran vdout0_17ck70 FIND v(dout0_17) AT=40.025n

.meas tran vdout0_18ck70 FIND v(dout0_18) AT=40.025n

.meas tran vdout0_19ck70 FIND v(dout0_19) AT=40.025n

.meas tran vdout0_20ck70 FIND v(dout0_20) AT=40.025n

.meas tran vdout0_21ck70 FIND v(dout0_21) AT=40.025n

.meas tran vdout0_22ck70 FIND v(dout0_22) AT=40.025n

.meas tran vdout0_23ck70 FIND v(dout0_23) AT=40.025n

.meas tran vdout0_24ck70 FIND v(dout0_24) AT=40.025n

.meas tran vdout0_25ck70 FIND v(dout0_25) AT=40.025n

.meas tran vdout0_26ck70 FIND v(dout0_26) AT=40.025n

.meas tran vdout0_27ck70 FIND v(dout0_27) AT=40.025n

.meas tran vdout0_28ck70 FIND v(dout0_28) AT=40.025n

.meas tran vdout0_29ck70 FIND v(dout0_29) AT=40.025n

.meas tran vdout0_30ck70 FIND v(dout0_30) AT=40.025n

.meas tran vdout0_31ck70 FIND v(dout0_31) AT=40.025n

.meas tran vdout0_32ck70 FIND v(dout0_32) AT=40.025n

.meas tran vdout0_33ck70 FIND v(dout0_33) AT=40.025n

.meas tran vdout0_34ck70 FIND v(dout0_34) AT=40.025n

.meas tran vdout0_35ck70 FIND v(dout0_35) AT=40.025n

.meas tran vdout0_36ck70 FIND v(dout0_36) AT=40.025n

.meas tran vdout0_37ck70 FIND v(dout0_37) AT=40.025n

.meas tran vdout0_38ck70 FIND v(dout0_38) AT=40.025n

.meas tran vdout0_39ck70 FIND v(dout0_39) AT=40.025n

.meas tran vdout0_40ck70 FIND v(dout0_40) AT=40.025n

.meas tran vdout0_41ck70 FIND v(dout0_41) AT=40.025n

.meas tran vdout0_42ck70 FIND v(dout0_42) AT=40.025n

.meas tran vdout0_43ck70 FIND v(dout0_43) AT=40.025n

.meas tran vdout0_44ck70 FIND v(dout0_44) AT=40.025n

.meas tran vdout0_45ck70 FIND v(dout0_45) AT=40.025n

.meas tran vdout0_46ck70 FIND v(dout0_46) AT=40.025n

.meas tran vdout0_47ck70 FIND v(dout0_47) AT=40.025n

.meas tran vdout0_48ck70 FIND v(dout0_48) AT=40.025n

.meas tran vdout0_49ck70 FIND v(dout0_49) AT=40.025n

.meas tran vdout0_50ck70 FIND v(dout0_50) AT=40.025n

.meas tran vdout0_51ck70 FIND v(dout0_51) AT=40.025n

.meas tran vdout0_52ck70 FIND v(dout0_52) AT=40.025n

.meas tran vdout0_53ck70 FIND v(dout0_53) AT=40.025n

.meas tran vdout0_54ck70 FIND v(dout0_54) AT=40.025n

.meas tran vdout0_55ck70 FIND v(dout0_55) AT=40.025n

.meas tran vdout0_56ck70 FIND v(dout0_56) AT=40.025n

.meas tran vdout0_57ck70 FIND v(dout0_57) AT=40.025n

.meas tran vdout0_58ck70 FIND v(dout0_58) AT=40.025n

.meas tran vdout0_59ck70 FIND v(dout0_59) AT=40.025n

.meas tran vdout0_60ck70 FIND v(dout0_60) AT=40.025n

.meas tran vdout0_61ck70 FIND v(dout0_61) AT=40.025n

.meas tran vdout0_62ck70 FIND v(dout0_62) AT=40.025n

.meas tran vdout0_63ck70 FIND v(dout0_63) AT=40.025n

.meas tran vdout0_64ck70 FIND v(dout0_64) AT=40.025n

.meas tran vdout0_65ck70 FIND v(dout0_65) AT=40.025n

.meas tran vdout0_66ck70 FIND v(dout0_66) AT=40.025n

.meas tran vdout0_67ck70 FIND v(dout0_67) AT=40.025n

.meas tran vdout0_68ck70 FIND v(dout0_68) AT=40.025n

.meas tran vdout0_69ck70 FIND v(dout0_69) AT=40.025n

.meas tran vdout0_70ck70 FIND v(dout0_70) AT=40.025n

.meas tran vdout0_71ck70 FIND v(dout0_71) AT=40.025n

.meas tran vdout0_72ck70 FIND v(dout0_72) AT=40.025n

.meas tran vdout0_73ck70 FIND v(dout0_73) AT=40.025n

.meas tran vdout0_74ck70 FIND v(dout0_74) AT=40.025n

.meas tran vdout0_75ck70 FIND v(dout0_75) AT=40.025n

.meas tran vdout0_76ck70 FIND v(dout0_76) AT=40.025n

.meas tran vdout0_77ck70 FIND v(dout0_77) AT=40.025n

.meas tran vdout0_78ck70 FIND v(dout0_78) AT=40.025n

.meas tran vdout0_79ck70 FIND v(dout0_79) AT=40.025n

.meas tran vdout0_80ck70 FIND v(dout0_80) AT=40.025n

.meas tran vdout0_81ck70 FIND v(dout0_81) AT=40.025n

.meas tran vdout0_82ck70 FIND v(dout0_82) AT=40.025n

.meas tran vdout0_83ck70 FIND v(dout0_83) AT=40.025n

.meas tran vdout0_84ck70 FIND v(dout0_84) AT=40.025n

.meas tran vdout0_85ck70 FIND v(dout0_85) AT=40.025n

.meas tran vdout0_86ck70 FIND v(dout0_86) AT=40.025n

.meas tran vdout0_87ck70 FIND v(dout0_87) AT=40.025n

.meas tran vdout0_88ck70 FIND v(dout0_88) AT=40.025n

.meas tran vdout0_89ck70 FIND v(dout0_89) AT=40.025n

.meas tran vdout0_90ck70 FIND v(dout0_90) AT=40.025n

.meas tran vdout0_91ck70 FIND v(dout0_91) AT=40.025n

.meas tran vdout0_92ck70 FIND v(dout0_92) AT=40.025n

.meas tran vdout0_93ck70 FIND v(dout0_93) AT=40.025n

.meas tran vdout0_94ck70 FIND v(dout0_94) AT=40.025n

.meas tran vdout0_95ck70 FIND v(dout0_95) AT=40.025n

.meas tran vdout0_96ck70 FIND v(dout0_96) AT=40.025n

.meas tran vdout0_97ck70 FIND v(dout0_97) AT=40.025n

.meas tran vdout0_98ck70 FIND v(dout0_98) AT=40.025n

.meas tran vdout0_99ck70 FIND v(dout0_99) AT=40.025n

.meas tran vdout0_100ck70 FIND v(dout0_100) AT=40.025n

.meas tran vdout0_101ck70 FIND v(dout0_101) AT=40.025n

.meas tran vdout0_102ck70 FIND v(dout0_102) AT=40.025n

.meas tran vdout0_103ck70 FIND v(dout0_103) AT=40.025n

.meas tran vdout0_104ck70 FIND v(dout0_104) AT=40.025n

.meas tran vdout0_105ck70 FIND v(dout0_105) AT=40.025n

.meas tran vdout0_106ck70 FIND v(dout0_106) AT=40.025n

.meas tran vdout0_107ck70 FIND v(dout0_107) AT=40.025n

.meas tran vdout0_108ck70 FIND v(dout0_108) AT=40.025n

.meas tran vdout0_109ck70 FIND v(dout0_109) AT=40.025n

.meas tran vdout0_110ck70 FIND v(dout0_110) AT=40.025n

.meas tran vdout0_111ck70 FIND v(dout0_111) AT=40.025n

.meas tran vdout0_112ck70 FIND v(dout0_112) AT=40.025n

.meas tran vdout0_113ck70 FIND v(dout0_113) AT=40.025n

.meas tran vdout0_114ck70 FIND v(dout0_114) AT=40.025n

.meas tran vdout0_115ck70 FIND v(dout0_115) AT=40.025n

.meas tran vdout0_116ck70 FIND v(dout0_116) AT=40.025n

.meas tran vdout0_117ck70 FIND v(dout0_117) AT=40.025n

.meas tran vdout0_118ck70 FIND v(dout0_118) AT=40.025n

.meas tran vdout0_119ck70 FIND v(dout0_119) AT=40.025n

.meas tran vdout0_120ck70 FIND v(dout0_120) AT=40.025n

.meas tran vdout0_121ck70 FIND v(dout0_121) AT=40.025n

.meas tran vdout0_122ck70 FIND v(dout0_122) AT=40.025n

.meas tran vdout0_123ck70 FIND v(dout0_123) AT=40.025n

.meas tran vdout0_124ck70 FIND v(dout0_124) AT=40.025n

.meas tran vdout0_125ck70 FIND v(dout0_125) AT=40.025n

.meas tran vdout0_126ck70 FIND v(dout0_126) AT=40.025n

.meas tran vdout0_127ck70 FIND v(dout0_127) AT=40.025n

.meas tran vdout0_128ck70 FIND v(dout0_128) AT=40.025n

.meas tran vdout0_129ck70 FIND v(dout0_129) AT=40.025n

.meas tran vdout0_130ck70 FIND v(dout0_130) AT=40.025n

.meas tran vdout0_131ck70 FIND v(dout0_131) AT=40.025n

.meas tran vdout0_132ck70 FIND v(dout0_132) AT=40.025n

.meas tran vdout0_133ck70 FIND v(dout0_133) AT=40.025n

.meas tran vdout0_134ck70 FIND v(dout0_134) AT=40.025n

.meas tran vdout0_135ck70 FIND v(dout0_135) AT=40.025n

.meas tran vdout0_136ck70 FIND v(dout0_136) AT=40.025n

.meas tran vdout0_137ck70 FIND v(dout0_137) AT=40.025n

.meas tran vdout0_138ck70 FIND v(dout0_138) AT=40.025n

.meas tran vdout0_139ck70 FIND v(dout0_139) AT=40.025n

.meas tran vdout0_140ck70 FIND v(dout0_140) AT=40.025n

.meas tran vdout0_141ck70 FIND v(dout0_141) AT=40.025n

.meas tran vdout0_142ck70 FIND v(dout0_142) AT=40.025n

.meas tran vdout0_143ck70 FIND v(dout0_143) AT=40.025n

.meas tran vdout0_144ck70 FIND v(dout0_144) AT=40.025n

.meas tran vdout0_145ck70 FIND v(dout0_145) AT=40.025n

.meas tran vdout0_146ck70 FIND v(dout0_146) AT=40.025n

.meas tran vdout0_147ck70 FIND v(dout0_147) AT=40.025n

.meas tran vdout0_148ck70 FIND v(dout0_148) AT=40.025n

.meas tran vdout0_149ck70 FIND v(dout0_149) AT=40.025n

.meas tran vdout0_0ck90 FIND v(dout0_0) AT=50.025n

.meas tran vdout0_1ck90 FIND v(dout0_1) AT=50.025n

.meas tran vdout0_2ck90 FIND v(dout0_2) AT=50.025n

.meas tran vdout0_3ck90 FIND v(dout0_3) AT=50.025n

.meas tran vdout0_4ck90 FIND v(dout0_4) AT=50.025n

.meas tran vdout0_5ck90 FIND v(dout0_5) AT=50.025n

.meas tran vdout0_6ck90 FIND v(dout0_6) AT=50.025n

.meas tran vdout0_7ck90 FIND v(dout0_7) AT=50.025n

.meas tran vdout0_8ck90 FIND v(dout0_8) AT=50.025n

.meas tran vdout0_9ck90 FIND v(dout0_9) AT=50.025n

.meas tran vdout0_10ck90 FIND v(dout0_10) AT=50.025n

.meas tran vdout0_11ck90 FIND v(dout0_11) AT=50.025n

.meas tran vdout0_12ck90 FIND v(dout0_12) AT=50.025n

.meas tran vdout0_13ck90 FIND v(dout0_13) AT=50.025n

.meas tran vdout0_14ck90 FIND v(dout0_14) AT=50.025n

.meas tran vdout0_15ck90 FIND v(dout0_15) AT=50.025n

.meas tran vdout0_16ck90 FIND v(dout0_16) AT=50.025n

.meas tran vdout0_17ck90 FIND v(dout0_17) AT=50.025n

.meas tran vdout0_18ck90 FIND v(dout0_18) AT=50.025n

.meas tran vdout0_19ck90 FIND v(dout0_19) AT=50.025n

.meas tran vdout0_20ck90 FIND v(dout0_20) AT=50.025n

.meas tran vdout0_21ck90 FIND v(dout0_21) AT=50.025n

.meas tran vdout0_22ck90 FIND v(dout0_22) AT=50.025n

.meas tran vdout0_23ck90 FIND v(dout0_23) AT=50.025n

.meas tran vdout0_24ck90 FIND v(dout0_24) AT=50.025n

.meas tran vdout0_25ck90 FIND v(dout0_25) AT=50.025n

.meas tran vdout0_26ck90 FIND v(dout0_26) AT=50.025n

.meas tran vdout0_27ck90 FIND v(dout0_27) AT=50.025n

.meas tran vdout0_28ck90 FIND v(dout0_28) AT=50.025n

.meas tran vdout0_29ck90 FIND v(dout0_29) AT=50.025n

.meas tran vdout0_30ck90 FIND v(dout0_30) AT=50.025n

.meas tran vdout0_31ck90 FIND v(dout0_31) AT=50.025n

.meas tran vdout0_32ck90 FIND v(dout0_32) AT=50.025n

.meas tran vdout0_33ck90 FIND v(dout0_33) AT=50.025n

.meas tran vdout0_34ck90 FIND v(dout0_34) AT=50.025n

.meas tran vdout0_35ck90 FIND v(dout0_35) AT=50.025n

.meas tran vdout0_36ck90 FIND v(dout0_36) AT=50.025n

.meas tran vdout0_37ck90 FIND v(dout0_37) AT=50.025n

.meas tran vdout0_38ck90 FIND v(dout0_38) AT=50.025n

.meas tran vdout0_39ck90 FIND v(dout0_39) AT=50.025n

.meas tran vdout0_40ck90 FIND v(dout0_40) AT=50.025n

.meas tran vdout0_41ck90 FIND v(dout0_41) AT=50.025n

.meas tran vdout0_42ck90 FIND v(dout0_42) AT=50.025n

.meas tran vdout0_43ck90 FIND v(dout0_43) AT=50.025n

.meas tran vdout0_44ck90 FIND v(dout0_44) AT=50.025n

.meas tran vdout0_45ck90 FIND v(dout0_45) AT=50.025n

.meas tran vdout0_46ck90 FIND v(dout0_46) AT=50.025n

.meas tran vdout0_47ck90 FIND v(dout0_47) AT=50.025n

.meas tran vdout0_48ck90 FIND v(dout0_48) AT=50.025n

.meas tran vdout0_49ck90 FIND v(dout0_49) AT=50.025n

.meas tran vdout0_50ck90 FIND v(dout0_50) AT=50.025n

.meas tran vdout0_51ck90 FIND v(dout0_51) AT=50.025n

.meas tran vdout0_52ck90 FIND v(dout0_52) AT=50.025n

.meas tran vdout0_53ck90 FIND v(dout0_53) AT=50.025n

.meas tran vdout0_54ck90 FIND v(dout0_54) AT=50.025n

.meas tran vdout0_55ck90 FIND v(dout0_55) AT=50.025n

.meas tran vdout0_56ck90 FIND v(dout0_56) AT=50.025n

.meas tran vdout0_57ck90 FIND v(dout0_57) AT=50.025n

.meas tran vdout0_58ck90 FIND v(dout0_58) AT=50.025n

.meas tran vdout0_59ck90 FIND v(dout0_59) AT=50.025n

.meas tran vdout0_60ck90 FIND v(dout0_60) AT=50.025n

.meas tran vdout0_61ck90 FIND v(dout0_61) AT=50.025n

.meas tran vdout0_62ck90 FIND v(dout0_62) AT=50.025n

.meas tran vdout0_63ck90 FIND v(dout0_63) AT=50.025n

.meas tran vdout0_64ck90 FIND v(dout0_64) AT=50.025n

.meas tran vdout0_65ck90 FIND v(dout0_65) AT=50.025n

.meas tran vdout0_66ck90 FIND v(dout0_66) AT=50.025n

.meas tran vdout0_67ck90 FIND v(dout0_67) AT=50.025n

.meas tran vdout0_68ck90 FIND v(dout0_68) AT=50.025n

.meas tran vdout0_69ck90 FIND v(dout0_69) AT=50.025n

.meas tran vdout0_70ck90 FIND v(dout0_70) AT=50.025n

.meas tran vdout0_71ck90 FIND v(dout0_71) AT=50.025n

.meas tran vdout0_72ck90 FIND v(dout0_72) AT=50.025n

.meas tran vdout0_73ck90 FIND v(dout0_73) AT=50.025n

.meas tran vdout0_74ck90 FIND v(dout0_74) AT=50.025n

.meas tran vdout0_75ck90 FIND v(dout0_75) AT=50.025n

.meas tran vdout0_76ck90 FIND v(dout0_76) AT=50.025n

.meas tran vdout0_77ck90 FIND v(dout0_77) AT=50.025n

.meas tran vdout0_78ck90 FIND v(dout0_78) AT=50.025n

.meas tran vdout0_79ck90 FIND v(dout0_79) AT=50.025n

.meas tran vdout0_80ck90 FIND v(dout0_80) AT=50.025n

.meas tran vdout0_81ck90 FIND v(dout0_81) AT=50.025n

.meas tran vdout0_82ck90 FIND v(dout0_82) AT=50.025n

.meas tran vdout0_83ck90 FIND v(dout0_83) AT=50.025n

.meas tran vdout0_84ck90 FIND v(dout0_84) AT=50.025n

.meas tran vdout0_85ck90 FIND v(dout0_85) AT=50.025n

.meas tran vdout0_86ck90 FIND v(dout0_86) AT=50.025n

.meas tran vdout0_87ck90 FIND v(dout0_87) AT=50.025n

.meas tran vdout0_88ck90 FIND v(dout0_88) AT=50.025n

.meas tran vdout0_89ck90 FIND v(dout0_89) AT=50.025n

.meas tran vdout0_90ck90 FIND v(dout0_90) AT=50.025n

.meas tran vdout0_91ck90 FIND v(dout0_91) AT=50.025n

.meas tran vdout0_92ck90 FIND v(dout0_92) AT=50.025n

.meas tran vdout0_93ck90 FIND v(dout0_93) AT=50.025n

.meas tran vdout0_94ck90 FIND v(dout0_94) AT=50.025n

.meas tran vdout0_95ck90 FIND v(dout0_95) AT=50.025n

.meas tran vdout0_96ck90 FIND v(dout0_96) AT=50.025n

.meas tran vdout0_97ck90 FIND v(dout0_97) AT=50.025n

.meas tran vdout0_98ck90 FIND v(dout0_98) AT=50.025n

.meas tran vdout0_99ck90 FIND v(dout0_99) AT=50.025n

.meas tran vdout0_100ck90 FIND v(dout0_100) AT=50.025n

.meas tran vdout0_101ck90 FIND v(dout0_101) AT=50.025n

.meas tran vdout0_102ck90 FIND v(dout0_102) AT=50.025n

.meas tran vdout0_103ck90 FIND v(dout0_103) AT=50.025n

.meas tran vdout0_104ck90 FIND v(dout0_104) AT=50.025n

.meas tran vdout0_105ck90 FIND v(dout0_105) AT=50.025n

.meas tran vdout0_106ck90 FIND v(dout0_106) AT=50.025n

.meas tran vdout0_107ck90 FIND v(dout0_107) AT=50.025n

.meas tran vdout0_108ck90 FIND v(dout0_108) AT=50.025n

.meas tran vdout0_109ck90 FIND v(dout0_109) AT=50.025n

.meas tran vdout0_110ck90 FIND v(dout0_110) AT=50.025n

.meas tran vdout0_111ck90 FIND v(dout0_111) AT=50.025n

.meas tran vdout0_112ck90 FIND v(dout0_112) AT=50.025n

.meas tran vdout0_113ck90 FIND v(dout0_113) AT=50.025n

.meas tran vdout0_114ck90 FIND v(dout0_114) AT=50.025n

.meas tran vdout0_115ck90 FIND v(dout0_115) AT=50.025n

.meas tran vdout0_116ck90 FIND v(dout0_116) AT=50.025n

.meas tran vdout0_117ck90 FIND v(dout0_117) AT=50.025n

.meas tran vdout0_118ck90 FIND v(dout0_118) AT=50.025n

.meas tran vdout0_119ck90 FIND v(dout0_119) AT=50.025n

.meas tran vdout0_120ck90 FIND v(dout0_120) AT=50.025n

.meas tran vdout0_121ck90 FIND v(dout0_121) AT=50.025n

.meas tran vdout0_122ck90 FIND v(dout0_122) AT=50.025n

.meas tran vdout0_123ck90 FIND v(dout0_123) AT=50.025n

.meas tran vdout0_124ck90 FIND v(dout0_124) AT=50.025n

.meas tran vdout0_125ck90 FIND v(dout0_125) AT=50.025n

.meas tran vdout0_126ck90 FIND v(dout0_126) AT=50.025n

.meas tran vdout0_127ck90 FIND v(dout0_127) AT=50.025n

.meas tran vdout0_128ck90 FIND v(dout0_128) AT=50.025n

.meas tran vdout0_129ck90 FIND v(dout0_129) AT=50.025n

.meas tran vdout0_130ck90 FIND v(dout0_130) AT=50.025n

.meas tran vdout0_131ck90 FIND v(dout0_131) AT=50.025n

.meas tran vdout0_132ck90 FIND v(dout0_132) AT=50.025n

.meas tran vdout0_133ck90 FIND v(dout0_133) AT=50.025n

.meas tran vdout0_134ck90 FIND v(dout0_134) AT=50.025n

.meas tran vdout0_135ck90 FIND v(dout0_135) AT=50.025n

.meas tran vdout0_136ck90 FIND v(dout0_136) AT=50.025n

.meas tran vdout0_137ck90 FIND v(dout0_137) AT=50.025n

.meas tran vdout0_138ck90 FIND v(dout0_138) AT=50.025n

.meas tran vdout0_139ck90 FIND v(dout0_139) AT=50.025n

.meas tran vdout0_140ck90 FIND v(dout0_140) AT=50.025n

.meas tran vdout0_141ck90 FIND v(dout0_141) AT=50.025n

.meas tran vdout0_142ck90 FIND v(dout0_142) AT=50.025n

.meas tran vdout0_143ck90 FIND v(dout0_143) AT=50.025n

.meas tran vdout0_144ck90 FIND v(dout0_144) AT=50.025n

.meas tran vdout0_145ck90 FIND v(dout0_145) AT=50.025n

.meas tran vdout0_146ck90 FIND v(dout0_146) AT=50.025n

.meas tran vdout0_147ck90 FIND v(dout0_147) AT=50.025n

.meas tran vdout0_148ck90 FIND v(dout0_148) AT=50.025n

.meas tran vdout0_149ck90 FIND v(dout0_149) AT=50.025n

.meas tran vdout0_0ck100 FIND v(dout0_0) AT=55.025n

.meas tran vdout0_1ck100 FIND v(dout0_1) AT=55.025n

.meas tran vdout0_2ck100 FIND v(dout0_2) AT=55.025n

.meas tran vdout0_3ck100 FIND v(dout0_3) AT=55.025n

.meas tran vdout0_4ck100 FIND v(dout0_4) AT=55.025n

.meas tran vdout0_5ck100 FIND v(dout0_5) AT=55.025n

.meas tran vdout0_6ck100 FIND v(dout0_6) AT=55.025n

.meas tran vdout0_7ck100 FIND v(dout0_7) AT=55.025n

.meas tran vdout0_8ck100 FIND v(dout0_8) AT=55.025n

.meas tran vdout0_9ck100 FIND v(dout0_9) AT=55.025n

.meas tran vdout0_10ck100 FIND v(dout0_10) AT=55.025n

.meas tran vdout0_11ck100 FIND v(dout0_11) AT=55.025n

.meas tran vdout0_12ck100 FIND v(dout0_12) AT=55.025n

.meas tran vdout0_13ck100 FIND v(dout0_13) AT=55.025n

.meas tran vdout0_14ck100 FIND v(dout0_14) AT=55.025n

.meas tran vdout0_15ck100 FIND v(dout0_15) AT=55.025n

.meas tran vdout0_16ck100 FIND v(dout0_16) AT=55.025n

.meas tran vdout0_17ck100 FIND v(dout0_17) AT=55.025n

.meas tran vdout0_18ck100 FIND v(dout0_18) AT=55.025n

.meas tran vdout0_19ck100 FIND v(dout0_19) AT=55.025n

.meas tran vdout0_20ck100 FIND v(dout0_20) AT=55.025n

.meas tran vdout0_21ck100 FIND v(dout0_21) AT=55.025n

.meas tran vdout0_22ck100 FIND v(dout0_22) AT=55.025n

.meas tran vdout0_23ck100 FIND v(dout0_23) AT=55.025n

.meas tran vdout0_24ck100 FIND v(dout0_24) AT=55.025n

.meas tran vdout0_25ck100 FIND v(dout0_25) AT=55.025n

.meas tran vdout0_26ck100 FIND v(dout0_26) AT=55.025n

.meas tran vdout0_27ck100 FIND v(dout0_27) AT=55.025n

.meas tran vdout0_28ck100 FIND v(dout0_28) AT=55.025n

.meas tran vdout0_29ck100 FIND v(dout0_29) AT=55.025n

.meas tran vdout0_30ck100 FIND v(dout0_30) AT=55.025n

.meas tran vdout0_31ck100 FIND v(dout0_31) AT=55.025n

.meas tran vdout0_32ck100 FIND v(dout0_32) AT=55.025n

.meas tran vdout0_33ck100 FIND v(dout0_33) AT=55.025n

.meas tran vdout0_34ck100 FIND v(dout0_34) AT=55.025n

.meas tran vdout0_35ck100 FIND v(dout0_35) AT=55.025n

.meas tran vdout0_36ck100 FIND v(dout0_36) AT=55.025n

.meas tran vdout0_37ck100 FIND v(dout0_37) AT=55.025n

.meas tran vdout0_38ck100 FIND v(dout0_38) AT=55.025n

.meas tran vdout0_39ck100 FIND v(dout0_39) AT=55.025n

.meas tran vdout0_40ck100 FIND v(dout0_40) AT=55.025n

.meas tran vdout0_41ck100 FIND v(dout0_41) AT=55.025n

.meas tran vdout0_42ck100 FIND v(dout0_42) AT=55.025n

.meas tran vdout0_43ck100 FIND v(dout0_43) AT=55.025n

.meas tran vdout0_44ck100 FIND v(dout0_44) AT=55.025n

.meas tran vdout0_45ck100 FIND v(dout0_45) AT=55.025n

.meas tran vdout0_46ck100 FIND v(dout0_46) AT=55.025n

.meas tran vdout0_47ck100 FIND v(dout0_47) AT=55.025n

.meas tran vdout0_48ck100 FIND v(dout0_48) AT=55.025n

.meas tran vdout0_49ck100 FIND v(dout0_49) AT=55.025n

.meas tran vdout0_50ck100 FIND v(dout0_50) AT=55.025n

.meas tran vdout0_51ck100 FIND v(dout0_51) AT=55.025n

.meas tran vdout0_52ck100 FIND v(dout0_52) AT=55.025n

.meas tran vdout0_53ck100 FIND v(dout0_53) AT=55.025n

.meas tran vdout0_54ck100 FIND v(dout0_54) AT=55.025n

.meas tran vdout0_55ck100 FIND v(dout0_55) AT=55.025n

.meas tran vdout0_56ck100 FIND v(dout0_56) AT=55.025n

.meas tran vdout0_57ck100 FIND v(dout0_57) AT=55.025n

.meas tran vdout0_58ck100 FIND v(dout0_58) AT=55.025n

.meas tran vdout0_59ck100 FIND v(dout0_59) AT=55.025n

.meas tran vdout0_60ck100 FIND v(dout0_60) AT=55.025n

.meas tran vdout0_61ck100 FIND v(dout0_61) AT=55.025n

.meas tran vdout0_62ck100 FIND v(dout0_62) AT=55.025n

.meas tran vdout0_63ck100 FIND v(dout0_63) AT=55.025n

.meas tran vdout0_64ck100 FIND v(dout0_64) AT=55.025n

.meas tran vdout0_65ck100 FIND v(dout0_65) AT=55.025n

.meas tran vdout0_66ck100 FIND v(dout0_66) AT=55.025n

.meas tran vdout0_67ck100 FIND v(dout0_67) AT=55.025n

.meas tran vdout0_68ck100 FIND v(dout0_68) AT=55.025n

.meas tran vdout0_69ck100 FIND v(dout0_69) AT=55.025n

.meas tran vdout0_70ck100 FIND v(dout0_70) AT=55.025n

.meas tran vdout0_71ck100 FIND v(dout0_71) AT=55.025n

.meas tran vdout0_72ck100 FIND v(dout0_72) AT=55.025n

.meas tran vdout0_73ck100 FIND v(dout0_73) AT=55.025n

.meas tran vdout0_74ck100 FIND v(dout0_74) AT=55.025n

.meas tran vdout0_75ck100 FIND v(dout0_75) AT=55.025n

.meas tran vdout0_76ck100 FIND v(dout0_76) AT=55.025n

.meas tran vdout0_77ck100 FIND v(dout0_77) AT=55.025n

.meas tran vdout0_78ck100 FIND v(dout0_78) AT=55.025n

.meas tran vdout0_79ck100 FIND v(dout0_79) AT=55.025n

.meas tran vdout0_80ck100 FIND v(dout0_80) AT=55.025n

.meas tran vdout0_81ck100 FIND v(dout0_81) AT=55.025n

.meas tran vdout0_82ck100 FIND v(dout0_82) AT=55.025n

.meas tran vdout0_83ck100 FIND v(dout0_83) AT=55.025n

.meas tran vdout0_84ck100 FIND v(dout0_84) AT=55.025n

.meas tran vdout0_85ck100 FIND v(dout0_85) AT=55.025n

.meas tran vdout0_86ck100 FIND v(dout0_86) AT=55.025n

.meas tran vdout0_87ck100 FIND v(dout0_87) AT=55.025n

.meas tran vdout0_88ck100 FIND v(dout0_88) AT=55.025n

.meas tran vdout0_89ck100 FIND v(dout0_89) AT=55.025n

.meas tran vdout0_90ck100 FIND v(dout0_90) AT=55.025n

.meas tran vdout0_91ck100 FIND v(dout0_91) AT=55.025n

.meas tran vdout0_92ck100 FIND v(dout0_92) AT=55.025n

.meas tran vdout0_93ck100 FIND v(dout0_93) AT=55.025n

.meas tran vdout0_94ck100 FIND v(dout0_94) AT=55.025n

.meas tran vdout0_95ck100 FIND v(dout0_95) AT=55.025n

.meas tran vdout0_96ck100 FIND v(dout0_96) AT=55.025n

.meas tran vdout0_97ck100 FIND v(dout0_97) AT=55.025n

.meas tran vdout0_98ck100 FIND v(dout0_98) AT=55.025n

.meas tran vdout0_99ck100 FIND v(dout0_99) AT=55.025n

.meas tran vdout0_100ck100 FIND v(dout0_100) AT=55.025n

.meas tran vdout0_101ck100 FIND v(dout0_101) AT=55.025n

.meas tran vdout0_102ck100 FIND v(dout0_102) AT=55.025n

.meas tran vdout0_103ck100 FIND v(dout0_103) AT=55.025n

.meas tran vdout0_104ck100 FIND v(dout0_104) AT=55.025n

.meas tran vdout0_105ck100 FIND v(dout0_105) AT=55.025n

.meas tran vdout0_106ck100 FIND v(dout0_106) AT=55.025n

.meas tran vdout0_107ck100 FIND v(dout0_107) AT=55.025n

.meas tran vdout0_108ck100 FIND v(dout0_108) AT=55.025n

.meas tran vdout0_109ck100 FIND v(dout0_109) AT=55.025n

.meas tran vdout0_110ck100 FIND v(dout0_110) AT=55.025n

.meas tran vdout0_111ck100 FIND v(dout0_111) AT=55.025n

.meas tran vdout0_112ck100 FIND v(dout0_112) AT=55.025n

.meas tran vdout0_113ck100 FIND v(dout0_113) AT=55.025n

.meas tran vdout0_114ck100 FIND v(dout0_114) AT=55.025n

.meas tran vdout0_115ck100 FIND v(dout0_115) AT=55.025n

.meas tran vdout0_116ck100 FIND v(dout0_116) AT=55.025n

.meas tran vdout0_117ck100 FIND v(dout0_117) AT=55.025n

.meas tran vdout0_118ck100 FIND v(dout0_118) AT=55.025n

.meas tran vdout0_119ck100 FIND v(dout0_119) AT=55.025n

.meas tran vdout0_120ck100 FIND v(dout0_120) AT=55.025n

.meas tran vdout0_121ck100 FIND v(dout0_121) AT=55.025n

.meas tran vdout0_122ck100 FIND v(dout0_122) AT=55.025n

.meas tran vdout0_123ck100 FIND v(dout0_123) AT=55.025n

.meas tran vdout0_124ck100 FIND v(dout0_124) AT=55.025n

.meas tran vdout0_125ck100 FIND v(dout0_125) AT=55.025n

.meas tran vdout0_126ck100 FIND v(dout0_126) AT=55.025n

.meas tran vdout0_127ck100 FIND v(dout0_127) AT=55.025n

.meas tran vdout0_128ck100 FIND v(dout0_128) AT=55.025n

.meas tran vdout0_129ck100 FIND v(dout0_129) AT=55.025n

.meas tran vdout0_130ck100 FIND v(dout0_130) AT=55.025n

.meas tran vdout0_131ck100 FIND v(dout0_131) AT=55.025n

.meas tran vdout0_132ck100 FIND v(dout0_132) AT=55.025n

.meas tran vdout0_133ck100 FIND v(dout0_133) AT=55.025n

.meas tran vdout0_134ck100 FIND v(dout0_134) AT=55.025n

.meas tran vdout0_135ck100 FIND v(dout0_135) AT=55.025n

.meas tran vdout0_136ck100 FIND v(dout0_136) AT=55.025n

.meas tran vdout0_137ck100 FIND v(dout0_137) AT=55.025n

.meas tran vdout0_138ck100 FIND v(dout0_138) AT=55.025n

.meas tran vdout0_139ck100 FIND v(dout0_139) AT=55.025n

.meas tran vdout0_140ck100 FIND v(dout0_140) AT=55.025n

.meas tran vdout0_141ck100 FIND v(dout0_141) AT=55.025n

.meas tran vdout0_142ck100 FIND v(dout0_142) AT=55.025n

.meas tran vdout0_143ck100 FIND v(dout0_143) AT=55.025n

.meas tran vdout0_144ck100 FIND v(dout0_144) AT=55.025n

.meas tran vdout0_145ck100 FIND v(dout0_145) AT=55.025n

.meas tran vdout0_146ck100 FIND v(dout0_146) AT=55.025n

.meas tran vdout0_147ck100 FIND v(dout0_147) AT=55.025n

.meas tran vdout0_148ck100 FIND v(dout0_148) AT=55.025n

.meas tran vdout0_149ck100 FIND v(dout0_149) AT=55.025n

.meas tran vdout0_0ck110 FIND v(dout0_0) AT=60.025n

.meas tran vdout0_1ck110 FIND v(dout0_1) AT=60.025n

.meas tran vdout0_2ck110 FIND v(dout0_2) AT=60.025n

.meas tran vdout0_3ck110 FIND v(dout0_3) AT=60.025n

.meas tran vdout0_4ck110 FIND v(dout0_4) AT=60.025n

.meas tran vdout0_5ck110 FIND v(dout0_5) AT=60.025n

.meas tran vdout0_6ck110 FIND v(dout0_6) AT=60.025n

.meas tran vdout0_7ck110 FIND v(dout0_7) AT=60.025n

.meas tran vdout0_8ck110 FIND v(dout0_8) AT=60.025n

.meas tran vdout0_9ck110 FIND v(dout0_9) AT=60.025n

.meas tran vdout0_10ck110 FIND v(dout0_10) AT=60.025n

.meas tran vdout0_11ck110 FIND v(dout0_11) AT=60.025n

.meas tran vdout0_12ck110 FIND v(dout0_12) AT=60.025n

.meas tran vdout0_13ck110 FIND v(dout0_13) AT=60.025n

.meas tran vdout0_14ck110 FIND v(dout0_14) AT=60.025n

.meas tran vdout0_15ck110 FIND v(dout0_15) AT=60.025n

.meas tran vdout0_16ck110 FIND v(dout0_16) AT=60.025n

.meas tran vdout0_17ck110 FIND v(dout0_17) AT=60.025n

.meas tran vdout0_18ck110 FIND v(dout0_18) AT=60.025n

.meas tran vdout0_19ck110 FIND v(dout0_19) AT=60.025n

.meas tran vdout0_20ck110 FIND v(dout0_20) AT=60.025n

.meas tran vdout0_21ck110 FIND v(dout0_21) AT=60.025n

.meas tran vdout0_22ck110 FIND v(dout0_22) AT=60.025n

.meas tran vdout0_23ck110 FIND v(dout0_23) AT=60.025n

.meas tran vdout0_24ck110 FIND v(dout0_24) AT=60.025n

.meas tran vdout0_25ck110 FIND v(dout0_25) AT=60.025n

.meas tran vdout0_26ck110 FIND v(dout0_26) AT=60.025n

.meas tran vdout0_27ck110 FIND v(dout0_27) AT=60.025n

.meas tran vdout0_28ck110 FIND v(dout0_28) AT=60.025n

.meas tran vdout0_29ck110 FIND v(dout0_29) AT=60.025n

.meas tran vdout0_30ck110 FIND v(dout0_30) AT=60.025n

.meas tran vdout0_31ck110 FIND v(dout0_31) AT=60.025n

.meas tran vdout0_32ck110 FIND v(dout0_32) AT=60.025n

.meas tran vdout0_33ck110 FIND v(dout0_33) AT=60.025n

.meas tran vdout0_34ck110 FIND v(dout0_34) AT=60.025n

.meas tran vdout0_35ck110 FIND v(dout0_35) AT=60.025n

.meas tran vdout0_36ck110 FIND v(dout0_36) AT=60.025n

.meas tran vdout0_37ck110 FIND v(dout0_37) AT=60.025n

.meas tran vdout0_38ck110 FIND v(dout0_38) AT=60.025n

.meas tran vdout0_39ck110 FIND v(dout0_39) AT=60.025n

.meas tran vdout0_40ck110 FIND v(dout0_40) AT=60.025n

.meas tran vdout0_41ck110 FIND v(dout0_41) AT=60.025n

.meas tran vdout0_42ck110 FIND v(dout0_42) AT=60.025n

.meas tran vdout0_43ck110 FIND v(dout0_43) AT=60.025n

.meas tran vdout0_44ck110 FIND v(dout0_44) AT=60.025n

.meas tran vdout0_45ck110 FIND v(dout0_45) AT=60.025n

.meas tran vdout0_46ck110 FIND v(dout0_46) AT=60.025n

.meas tran vdout0_47ck110 FIND v(dout0_47) AT=60.025n

.meas tran vdout0_48ck110 FIND v(dout0_48) AT=60.025n

.meas tran vdout0_49ck110 FIND v(dout0_49) AT=60.025n

.meas tran vdout0_50ck110 FIND v(dout0_50) AT=60.025n

.meas tran vdout0_51ck110 FIND v(dout0_51) AT=60.025n

.meas tran vdout0_52ck110 FIND v(dout0_52) AT=60.025n

.meas tran vdout0_53ck110 FIND v(dout0_53) AT=60.025n

.meas tran vdout0_54ck110 FIND v(dout0_54) AT=60.025n

.meas tran vdout0_55ck110 FIND v(dout0_55) AT=60.025n

.meas tran vdout0_56ck110 FIND v(dout0_56) AT=60.025n

.meas tran vdout0_57ck110 FIND v(dout0_57) AT=60.025n

.meas tran vdout0_58ck110 FIND v(dout0_58) AT=60.025n

.meas tran vdout0_59ck110 FIND v(dout0_59) AT=60.025n

.meas tran vdout0_60ck110 FIND v(dout0_60) AT=60.025n

.meas tran vdout0_61ck110 FIND v(dout0_61) AT=60.025n

.meas tran vdout0_62ck110 FIND v(dout0_62) AT=60.025n

.meas tran vdout0_63ck110 FIND v(dout0_63) AT=60.025n

.meas tran vdout0_64ck110 FIND v(dout0_64) AT=60.025n

.meas tran vdout0_65ck110 FIND v(dout0_65) AT=60.025n

.meas tran vdout0_66ck110 FIND v(dout0_66) AT=60.025n

.meas tran vdout0_67ck110 FIND v(dout0_67) AT=60.025n

.meas tran vdout0_68ck110 FIND v(dout0_68) AT=60.025n

.meas tran vdout0_69ck110 FIND v(dout0_69) AT=60.025n

.meas tran vdout0_70ck110 FIND v(dout0_70) AT=60.025n

.meas tran vdout0_71ck110 FIND v(dout0_71) AT=60.025n

.meas tran vdout0_72ck110 FIND v(dout0_72) AT=60.025n

.meas tran vdout0_73ck110 FIND v(dout0_73) AT=60.025n

.meas tran vdout0_74ck110 FIND v(dout0_74) AT=60.025n

.meas tran vdout0_75ck110 FIND v(dout0_75) AT=60.025n

.meas tran vdout0_76ck110 FIND v(dout0_76) AT=60.025n

.meas tran vdout0_77ck110 FIND v(dout0_77) AT=60.025n

.meas tran vdout0_78ck110 FIND v(dout0_78) AT=60.025n

.meas tran vdout0_79ck110 FIND v(dout0_79) AT=60.025n

.meas tran vdout0_80ck110 FIND v(dout0_80) AT=60.025n

.meas tran vdout0_81ck110 FIND v(dout0_81) AT=60.025n

.meas tran vdout0_82ck110 FIND v(dout0_82) AT=60.025n

.meas tran vdout0_83ck110 FIND v(dout0_83) AT=60.025n

.meas tran vdout0_84ck110 FIND v(dout0_84) AT=60.025n

.meas tran vdout0_85ck110 FIND v(dout0_85) AT=60.025n

.meas tran vdout0_86ck110 FIND v(dout0_86) AT=60.025n

.meas tran vdout0_87ck110 FIND v(dout0_87) AT=60.025n

.meas tran vdout0_88ck110 FIND v(dout0_88) AT=60.025n

.meas tran vdout0_89ck110 FIND v(dout0_89) AT=60.025n

.meas tran vdout0_90ck110 FIND v(dout0_90) AT=60.025n

.meas tran vdout0_91ck110 FIND v(dout0_91) AT=60.025n

.meas tran vdout0_92ck110 FIND v(dout0_92) AT=60.025n

.meas tran vdout0_93ck110 FIND v(dout0_93) AT=60.025n

.meas tran vdout0_94ck110 FIND v(dout0_94) AT=60.025n

.meas tran vdout0_95ck110 FIND v(dout0_95) AT=60.025n

.meas tran vdout0_96ck110 FIND v(dout0_96) AT=60.025n

.meas tran vdout0_97ck110 FIND v(dout0_97) AT=60.025n

.meas tran vdout0_98ck110 FIND v(dout0_98) AT=60.025n

.meas tran vdout0_99ck110 FIND v(dout0_99) AT=60.025n

.meas tran vdout0_100ck110 FIND v(dout0_100) AT=60.025n

.meas tran vdout0_101ck110 FIND v(dout0_101) AT=60.025n

.meas tran vdout0_102ck110 FIND v(dout0_102) AT=60.025n

.meas tran vdout0_103ck110 FIND v(dout0_103) AT=60.025n

.meas tran vdout0_104ck110 FIND v(dout0_104) AT=60.025n

.meas tran vdout0_105ck110 FIND v(dout0_105) AT=60.025n

.meas tran vdout0_106ck110 FIND v(dout0_106) AT=60.025n

.meas tran vdout0_107ck110 FIND v(dout0_107) AT=60.025n

.meas tran vdout0_108ck110 FIND v(dout0_108) AT=60.025n

.meas tran vdout0_109ck110 FIND v(dout0_109) AT=60.025n

.meas tran vdout0_110ck110 FIND v(dout0_110) AT=60.025n

.meas tran vdout0_111ck110 FIND v(dout0_111) AT=60.025n

.meas tran vdout0_112ck110 FIND v(dout0_112) AT=60.025n

.meas tran vdout0_113ck110 FIND v(dout0_113) AT=60.025n

.meas tran vdout0_114ck110 FIND v(dout0_114) AT=60.025n

.meas tran vdout0_115ck110 FIND v(dout0_115) AT=60.025n

.meas tran vdout0_116ck110 FIND v(dout0_116) AT=60.025n

.meas tran vdout0_117ck110 FIND v(dout0_117) AT=60.025n

.meas tran vdout0_118ck110 FIND v(dout0_118) AT=60.025n

.meas tran vdout0_119ck110 FIND v(dout0_119) AT=60.025n

.meas tran vdout0_120ck110 FIND v(dout0_120) AT=60.025n

.meas tran vdout0_121ck110 FIND v(dout0_121) AT=60.025n

.meas tran vdout0_122ck110 FIND v(dout0_122) AT=60.025n

.meas tran vdout0_123ck110 FIND v(dout0_123) AT=60.025n

.meas tran vdout0_124ck110 FIND v(dout0_124) AT=60.025n

.meas tran vdout0_125ck110 FIND v(dout0_125) AT=60.025n

.meas tran vdout0_126ck110 FIND v(dout0_126) AT=60.025n

.meas tran vdout0_127ck110 FIND v(dout0_127) AT=60.025n

.meas tran vdout0_128ck110 FIND v(dout0_128) AT=60.025n

.meas tran vdout0_129ck110 FIND v(dout0_129) AT=60.025n

.meas tran vdout0_130ck110 FIND v(dout0_130) AT=60.025n

.meas tran vdout0_131ck110 FIND v(dout0_131) AT=60.025n

.meas tran vdout0_132ck110 FIND v(dout0_132) AT=60.025n

.meas tran vdout0_133ck110 FIND v(dout0_133) AT=60.025n

.meas tran vdout0_134ck110 FIND v(dout0_134) AT=60.025n

.meas tran vdout0_135ck110 FIND v(dout0_135) AT=60.025n

.meas tran vdout0_136ck110 FIND v(dout0_136) AT=60.025n

.meas tran vdout0_137ck110 FIND v(dout0_137) AT=60.025n

.meas tran vdout0_138ck110 FIND v(dout0_138) AT=60.025n

.meas tran vdout0_139ck110 FIND v(dout0_139) AT=60.025n

.meas tran vdout0_140ck110 FIND v(dout0_140) AT=60.025n

.meas tran vdout0_141ck110 FIND v(dout0_141) AT=60.025n

.meas tran vdout0_142ck110 FIND v(dout0_142) AT=60.025n

.meas tran vdout0_143ck110 FIND v(dout0_143) AT=60.025n

.meas tran vdout0_144ck110 FIND v(dout0_144) AT=60.025n

.meas tran vdout0_145ck110 FIND v(dout0_145) AT=60.025n

.meas tran vdout0_146ck110 FIND v(dout0_146) AT=60.025n

.meas tran vdout0_147ck110 FIND v(dout0_147) AT=60.025n

.meas tran vdout0_148ck110 FIND v(dout0_148) AT=60.025n

.meas tran vdout0_149ck110 FIND v(dout0_149) AT=60.025n

.meas tran vdout0_0ck140 FIND v(dout0_0) AT=75.025n

.meas tran vdout0_1ck140 FIND v(dout0_1) AT=75.025n

.meas tran vdout0_2ck140 FIND v(dout0_2) AT=75.025n

.meas tran vdout0_3ck140 FIND v(dout0_3) AT=75.025n

.meas tran vdout0_4ck140 FIND v(dout0_4) AT=75.025n

.meas tran vdout0_5ck140 FIND v(dout0_5) AT=75.025n

.meas tran vdout0_6ck140 FIND v(dout0_6) AT=75.025n

.meas tran vdout0_7ck140 FIND v(dout0_7) AT=75.025n

.meas tran vdout0_8ck140 FIND v(dout0_8) AT=75.025n

.meas tran vdout0_9ck140 FIND v(dout0_9) AT=75.025n

.meas tran vdout0_10ck140 FIND v(dout0_10) AT=75.025n

.meas tran vdout0_11ck140 FIND v(dout0_11) AT=75.025n

.meas tran vdout0_12ck140 FIND v(dout0_12) AT=75.025n

.meas tran vdout0_13ck140 FIND v(dout0_13) AT=75.025n

.meas tran vdout0_14ck140 FIND v(dout0_14) AT=75.025n

.meas tran vdout0_15ck140 FIND v(dout0_15) AT=75.025n

.meas tran vdout0_16ck140 FIND v(dout0_16) AT=75.025n

.meas tran vdout0_17ck140 FIND v(dout0_17) AT=75.025n

.meas tran vdout0_18ck140 FIND v(dout0_18) AT=75.025n

.meas tran vdout0_19ck140 FIND v(dout0_19) AT=75.025n

.meas tran vdout0_20ck140 FIND v(dout0_20) AT=75.025n

.meas tran vdout0_21ck140 FIND v(dout0_21) AT=75.025n

.meas tran vdout0_22ck140 FIND v(dout0_22) AT=75.025n

.meas tran vdout0_23ck140 FIND v(dout0_23) AT=75.025n

.meas tran vdout0_24ck140 FIND v(dout0_24) AT=75.025n

.meas tran vdout0_25ck140 FIND v(dout0_25) AT=75.025n

.meas tran vdout0_26ck140 FIND v(dout0_26) AT=75.025n

.meas tran vdout0_27ck140 FIND v(dout0_27) AT=75.025n

.meas tran vdout0_28ck140 FIND v(dout0_28) AT=75.025n

.meas tran vdout0_29ck140 FIND v(dout0_29) AT=75.025n

.meas tran vdout0_30ck140 FIND v(dout0_30) AT=75.025n

.meas tran vdout0_31ck140 FIND v(dout0_31) AT=75.025n

.meas tran vdout0_32ck140 FIND v(dout0_32) AT=75.025n

.meas tran vdout0_33ck140 FIND v(dout0_33) AT=75.025n

.meas tran vdout0_34ck140 FIND v(dout0_34) AT=75.025n

.meas tran vdout0_35ck140 FIND v(dout0_35) AT=75.025n

.meas tran vdout0_36ck140 FIND v(dout0_36) AT=75.025n

.meas tran vdout0_37ck140 FIND v(dout0_37) AT=75.025n

.meas tran vdout0_38ck140 FIND v(dout0_38) AT=75.025n

.meas tran vdout0_39ck140 FIND v(dout0_39) AT=75.025n

.meas tran vdout0_40ck140 FIND v(dout0_40) AT=75.025n

.meas tran vdout0_41ck140 FIND v(dout0_41) AT=75.025n

.meas tran vdout0_42ck140 FIND v(dout0_42) AT=75.025n

.meas tran vdout0_43ck140 FIND v(dout0_43) AT=75.025n

.meas tran vdout0_44ck140 FIND v(dout0_44) AT=75.025n

.meas tran vdout0_45ck140 FIND v(dout0_45) AT=75.025n

.meas tran vdout0_46ck140 FIND v(dout0_46) AT=75.025n

.meas tran vdout0_47ck140 FIND v(dout0_47) AT=75.025n

.meas tran vdout0_48ck140 FIND v(dout0_48) AT=75.025n

.meas tran vdout0_49ck140 FIND v(dout0_49) AT=75.025n

.meas tran vdout0_50ck140 FIND v(dout0_50) AT=75.025n

.meas tran vdout0_51ck140 FIND v(dout0_51) AT=75.025n

.meas tran vdout0_52ck140 FIND v(dout0_52) AT=75.025n

.meas tran vdout0_53ck140 FIND v(dout0_53) AT=75.025n

.meas tran vdout0_54ck140 FIND v(dout0_54) AT=75.025n

.meas tran vdout0_55ck140 FIND v(dout0_55) AT=75.025n

.meas tran vdout0_56ck140 FIND v(dout0_56) AT=75.025n

.meas tran vdout0_57ck140 FIND v(dout0_57) AT=75.025n

.meas tran vdout0_58ck140 FIND v(dout0_58) AT=75.025n

.meas tran vdout0_59ck140 FIND v(dout0_59) AT=75.025n

.meas tran vdout0_60ck140 FIND v(dout0_60) AT=75.025n

.meas tran vdout0_61ck140 FIND v(dout0_61) AT=75.025n

.meas tran vdout0_62ck140 FIND v(dout0_62) AT=75.025n

.meas tran vdout0_63ck140 FIND v(dout0_63) AT=75.025n

.meas tran vdout0_64ck140 FIND v(dout0_64) AT=75.025n

.meas tran vdout0_65ck140 FIND v(dout0_65) AT=75.025n

.meas tran vdout0_66ck140 FIND v(dout0_66) AT=75.025n

.meas tran vdout0_67ck140 FIND v(dout0_67) AT=75.025n

.meas tran vdout0_68ck140 FIND v(dout0_68) AT=75.025n

.meas tran vdout0_69ck140 FIND v(dout0_69) AT=75.025n

.meas tran vdout0_70ck140 FIND v(dout0_70) AT=75.025n

.meas tran vdout0_71ck140 FIND v(dout0_71) AT=75.025n

.meas tran vdout0_72ck140 FIND v(dout0_72) AT=75.025n

.meas tran vdout0_73ck140 FIND v(dout0_73) AT=75.025n

.meas tran vdout0_74ck140 FIND v(dout0_74) AT=75.025n

.meas tran vdout0_75ck140 FIND v(dout0_75) AT=75.025n

.meas tran vdout0_76ck140 FIND v(dout0_76) AT=75.025n

.meas tran vdout0_77ck140 FIND v(dout0_77) AT=75.025n

.meas tran vdout0_78ck140 FIND v(dout0_78) AT=75.025n

.meas tran vdout0_79ck140 FIND v(dout0_79) AT=75.025n

.meas tran vdout0_80ck140 FIND v(dout0_80) AT=75.025n

.meas tran vdout0_81ck140 FIND v(dout0_81) AT=75.025n

.meas tran vdout0_82ck140 FIND v(dout0_82) AT=75.025n

.meas tran vdout0_83ck140 FIND v(dout0_83) AT=75.025n

.meas tran vdout0_84ck140 FIND v(dout0_84) AT=75.025n

.meas tran vdout0_85ck140 FIND v(dout0_85) AT=75.025n

.meas tran vdout0_86ck140 FIND v(dout0_86) AT=75.025n

.meas tran vdout0_87ck140 FIND v(dout0_87) AT=75.025n

.meas tran vdout0_88ck140 FIND v(dout0_88) AT=75.025n

.meas tran vdout0_89ck140 FIND v(dout0_89) AT=75.025n

.meas tran vdout0_90ck140 FIND v(dout0_90) AT=75.025n

.meas tran vdout0_91ck140 FIND v(dout0_91) AT=75.025n

.meas tran vdout0_92ck140 FIND v(dout0_92) AT=75.025n

.meas tran vdout0_93ck140 FIND v(dout0_93) AT=75.025n

.meas tran vdout0_94ck140 FIND v(dout0_94) AT=75.025n

.meas tran vdout0_95ck140 FIND v(dout0_95) AT=75.025n

.meas tran vdout0_96ck140 FIND v(dout0_96) AT=75.025n

.meas tran vdout0_97ck140 FIND v(dout0_97) AT=75.025n

.meas tran vdout0_98ck140 FIND v(dout0_98) AT=75.025n

.meas tran vdout0_99ck140 FIND v(dout0_99) AT=75.025n

.meas tran vdout0_100ck140 FIND v(dout0_100) AT=75.025n

.meas tran vdout0_101ck140 FIND v(dout0_101) AT=75.025n

.meas tran vdout0_102ck140 FIND v(dout0_102) AT=75.025n

.meas tran vdout0_103ck140 FIND v(dout0_103) AT=75.025n

.meas tran vdout0_104ck140 FIND v(dout0_104) AT=75.025n

.meas tran vdout0_105ck140 FIND v(dout0_105) AT=75.025n

.meas tran vdout0_106ck140 FIND v(dout0_106) AT=75.025n

.meas tran vdout0_107ck140 FIND v(dout0_107) AT=75.025n

.meas tran vdout0_108ck140 FIND v(dout0_108) AT=75.025n

.meas tran vdout0_109ck140 FIND v(dout0_109) AT=75.025n

.meas tran vdout0_110ck140 FIND v(dout0_110) AT=75.025n

.meas tran vdout0_111ck140 FIND v(dout0_111) AT=75.025n

.meas tran vdout0_112ck140 FIND v(dout0_112) AT=75.025n

.meas tran vdout0_113ck140 FIND v(dout0_113) AT=75.025n

.meas tran vdout0_114ck140 FIND v(dout0_114) AT=75.025n

.meas tran vdout0_115ck140 FIND v(dout0_115) AT=75.025n

.meas tran vdout0_116ck140 FIND v(dout0_116) AT=75.025n

.meas tran vdout0_117ck140 FIND v(dout0_117) AT=75.025n

.meas tran vdout0_118ck140 FIND v(dout0_118) AT=75.025n

.meas tran vdout0_119ck140 FIND v(dout0_119) AT=75.025n

.meas tran vdout0_120ck140 FIND v(dout0_120) AT=75.025n

.meas tran vdout0_121ck140 FIND v(dout0_121) AT=75.025n

.meas tran vdout0_122ck140 FIND v(dout0_122) AT=75.025n

.meas tran vdout0_123ck140 FIND v(dout0_123) AT=75.025n

.meas tran vdout0_124ck140 FIND v(dout0_124) AT=75.025n

.meas tran vdout0_125ck140 FIND v(dout0_125) AT=75.025n

.meas tran vdout0_126ck140 FIND v(dout0_126) AT=75.025n

.meas tran vdout0_127ck140 FIND v(dout0_127) AT=75.025n

.meas tran vdout0_128ck140 FIND v(dout0_128) AT=75.025n

.meas tran vdout0_129ck140 FIND v(dout0_129) AT=75.025n

.meas tran vdout0_130ck140 FIND v(dout0_130) AT=75.025n

.meas tran vdout0_131ck140 FIND v(dout0_131) AT=75.025n

.meas tran vdout0_132ck140 FIND v(dout0_132) AT=75.025n

.meas tran vdout0_133ck140 FIND v(dout0_133) AT=75.025n

.meas tran vdout0_134ck140 FIND v(dout0_134) AT=75.025n

.meas tran vdout0_135ck140 FIND v(dout0_135) AT=75.025n

.meas tran vdout0_136ck140 FIND v(dout0_136) AT=75.025n

.meas tran vdout0_137ck140 FIND v(dout0_137) AT=75.025n

.meas tran vdout0_138ck140 FIND v(dout0_138) AT=75.025n

.meas tran vdout0_139ck140 FIND v(dout0_139) AT=75.025n

.meas tran vdout0_140ck140 FIND v(dout0_140) AT=75.025n

.meas tran vdout0_141ck140 FIND v(dout0_141) AT=75.025n

.meas tran vdout0_142ck140 FIND v(dout0_142) AT=75.025n

.meas tran vdout0_143ck140 FIND v(dout0_143) AT=75.025n

.meas tran vdout0_144ck140 FIND v(dout0_144) AT=75.025n

.meas tran vdout0_145ck140 FIND v(dout0_145) AT=75.025n

.meas tran vdout0_146ck140 FIND v(dout0_146) AT=75.025n

.meas tran vdout0_147ck140 FIND v(dout0_147) AT=75.025n

.meas tran vdout0_148ck140 FIND v(dout0_148) AT=75.025n

.meas tran vdout0_149ck140 FIND v(dout0_149) AT=75.025n

.meas tran vdout0_0ck150 FIND v(dout0_0) AT=80.025n

.meas tran vdout0_1ck150 FIND v(dout0_1) AT=80.025n

.meas tran vdout0_2ck150 FIND v(dout0_2) AT=80.025n

.meas tran vdout0_3ck150 FIND v(dout0_3) AT=80.025n

.meas tran vdout0_4ck150 FIND v(dout0_4) AT=80.025n

.meas tran vdout0_5ck150 FIND v(dout0_5) AT=80.025n

.meas tran vdout0_6ck150 FIND v(dout0_6) AT=80.025n

.meas tran vdout0_7ck150 FIND v(dout0_7) AT=80.025n

.meas tran vdout0_8ck150 FIND v(dout0_8) AT=80.025n

.meas tran vdout0_9ck150 FIND v(dout0_9) AT=80.025n

.meas tran vdout0_10ck150 FIND v(dout0_10) AT=80.025n

.meas tran vdout0_11ck150 FIND v(dout0_11) AT=80.025n

.meas tran vdout0_12ck150 FIND v(dout0_12) AT=80.025n

.meas tran vdout0_13ck150 FIND v(dout0_13) AT=80.025n

.meas tran vdout0_14ck150 FIND v(dout0_14) AT=80.025n

.meas tran vdout0_15ck150 FIND v(dout0_15) AT=80.025n

.meas tran vdout0_16ck150 FIND v(dout0_16) AT=80.025n

.meas tran vdout0_17ck150 FIND v(dout0_17) AT=80.025n

.meas tran vdout0_18ck150 FIND v(dout0_18) AT=80.025n

.meas tran vdout0_19ck150 FIND v(dout0_19) AT=80.025n

.meas tran vdout0_20ck150 FIND v(dout0_20) AT=80.025n

.meas tran vdout0_21ck150 FIND v(dout0_21) AT=80.025n

.meas tran vdout0_22ck150 FIND v(dout0_22) AT=80.025n

.meas tran vdout0_23ck150 FIND v(dout0_23) AT=80.025n

.meas tran vdout0_24ck150 FIND v(dout0_24) AT=80.025n

.meas tran vdout0_25ck150 FIND v(dout0_25) AT=80.025n

.meas tran vdout0_26ck150 FIND v(dout0_26) AT=80.025n

.meas tran vdout0_27ck150 FIND v(dout0_27) AT=80.025n

.meas tran vdout0_28ck150 FIND v(dout0_28) AT=80.025n

.meas tran vdout0_29ck150 FIND v(dout0_29) AT=80.025n

.meas tran vdout0_30ck150 FIND v(dout0_30) AT=80.025n

.meas tran vdout0_31ck150 FIND v(dout0_31) AT=80.025n

.meas tran vdout0_32ck150 FIND v(dout0_32) AT=80.025n

.meas tran vdout0_33ck150 FIND v(dout0_33) AT=80.025n

.meas tran vdout0_34ck150 FIND v(dout0_34) AT=80.025n

.meas tran vdout0_35ck150 FIND v(dout0_35) AT=80.025n

.meas tran vdout0_36ck150 FIND v(dout0_36) AT=80.025n

.meas tran vdout0_37ck150 FIND v(dout0_37) AT=80.025n

.meas tran vdout0_38ck150 FIND v(dout0_38) AT=80.025n

.meas tran vdout0_39ck150 FIND v(dout0_39) AT=80.025n

.meas tran vdout0_40ck150 FIND v(dout0_40) AT=80.025n

.meas tran vdout0_41ck150 FIND v(dout0_41) AT=80.025n

.meas tran vdout0_42ck150 FIND v(dout0_42) AT=80.025n

.meas tran vdout0_43ck150 FIND v(dout0_43) AT=80.025n

.meas tran vdout0_44ck150 FIND v(dout0_44) AT=80.025n

.meas tran vdout0_45ck150 FIND v(dout0_45) AT=80.025n

.meas tran vdout0_46ck150 FIND v(dout0_46) AT=80.025n

.meas tran vdout0_47ck150 FIND v(dout0_47) AT=80.025n

.meas tran vdout0_48ck150 FIND v(dout0_48) AT=80.025n

.meas tran vdout0_49ck150 FIND v(dout0_49) AT=80.025n

.meas tran vdout0_50ck150 FIND v(dout0_50) AT=80.025n

.meas tran vdout0_51ck150 FIND v(dout0_51) AT=80.025n

.meas tran vdout0_52ck150 FIND v(dout0_52) AT=80.025n

.meas tran vdout0_53ck150 FIND v(dout0_53) AT=80.025n

.meas tran vdout0_54ck150 FIND v(dout0_54) AT=80.025n

.meas tran vdout0_55ck150 FIND v(dout0_55) AT=80.025n

.meas tran vdout0_56ck150 FIND v(dout0_56) AT=80.025n

.meas tran vdout0_57ck150 FIND v(dout0_57) AT=80.025n

.meas tran vdout0_58ck150 FIND v(dout0_58) AT=80.025n

.meas tran vdout0_59ck150 FIND v(dout0_59) AT=80.025n

.meas tran vdout0_60ck150 FIND v(dout0_60) AT=80.025n

.meas tran vdout0_61ck150 FIND v(dout0_61) AT=80.025n

.meas tran vdout0_62ck150 FIND v(dout0_62) AT=80.025n

.meas tran vdout0_63ck150 FIND v(dout0_63) AT=80.025n

.meas tran vdout0_64ck150 FIND v(dout0_64) AT=80.025n

.meas tran vdout0_65ck150 FIND v(dout0_65) AT=80.025n

.meas tran vdout0_66ck150 FIND v(dout0_66) AT=80.025n

.meas tran vdout0_67ck150 FIND v(dout0_67) AT=80.025n

.meas tran vdout0_68ck150 FIND v(dout0_68) AT=80.025n

.meas tran vdout0_69ck150 FIND v(dout0_69) AT=80.025n

.meas tran vdout0_70ck150 FIND v(dout0_70) AT=80.025n

.meas tran vdout0_71ck150 FIND v(dout0_71) AT=80.025n

.meas tran vdout0_72ck150 FIND v(dout0_72) AT=80.025n

.meas tran vdout0_73ck150 FIND v(dout0_73) AT=80.025n

.meas tran vdout0_74ck150 FIND v(dout0_74) AT=80.025n

.meas tran vdout0_75ck150 FIND v(dout0_75) AT=80.025n

.meas tran vdout0_76ck150 FIND v(dout0_76) AT=80.025n

.meas tran vdout0_77ck150 FIND v(dout0_77) AT=80.025n

.meas tran vdout0_78ck150 FIND v(dout0_78) AT=80.025n

.meas tran vdout0_79ck150 FIND v(dout0_79) AT=80.025n

.meas tran vdout0_80ck150 FIND v(dout0_80) AT=80.025n

.meas tran vdout0_81ck150 FIND v(dout0_81) AT=80.025n

.meas tran vdout0_82ck150 FIND v(dout0_82) AT=80.025n

.meas tran vdout0_83ck150 FIND v(dout0_83) AT=80.025n

.meas tran vdout0_84ck150 FIND v(dout0_84) AT=80.025n

.meas tran vdout0_85ck150 FIND v(dout0_85) AT=80.025n

.meas tran vdout0_86ck150 FIND v(dout0_86) AT=80.025n

.meas tran vdout0_87ck150 FIND v(dout0_87) AT=80.025n

.meas tran vdout0_88ck150 FIND v(dout0_88) AT=80.025n

.meas tran vdout0_89ck150 FIND v(dout0_89) AT=80.025n

.meas tran vdout0_90ck150 FIND v(dout0_90) AT=80.025n

.meas tran vdout0_91ck150 FIND v(dout0_91) AT=80.025n

.meas tran vdout0_92ck150 FIND v(dout0_92) AT=80.025n

.meas tran vdout0_93ck150 FIND v(dout0_93) AT=80.025n

.meas tran vdout0_94ck150 FIND v(dout0_94) AT=80.025n

.meas tran vdout0_95ck150 FIND v(dout0_95) AT=80.025n

.meas tran vdout0_96ck150 FIND v(dout0_96) AT=80.025n

.meas tran vdout0_97ck150 FIND v(dout0_97) AT=80.025n

.meas tran vdout0_98ck150 FIND v(dout0_98) AT=80.025n

.meas tran vdout0_99ck150 FIND v(dout0_99) AT=80.025n

.meas tran vdout0_100ck150 FIND v(dout0_100) AT=80.025n

.meas tran vdout0_101ck150 FIND v(dout0_101) AT=80.025n

.meas tran vdout0_102ck150 FIND v(dout0_102) AT=80.025n

.meas tran vdout0_103ck150 FIND v(dout0_103) AT=80.025n

.meas tran vdout0_104ck150 FIND v(dout0_104) AT=80.025n

.meas tran vdout0_105ck150 FIND v(dout0_105) AT=80.025n

.meas tran vdout0_106ck150 FIND v(dout0_106) AT=80.025n

.meas tran vdout0_107ck150 FIND v(dout0_107) AT=80.025n

.meas tran vdout0_108ck150 FIND v(dout0_108) AT=80.025n

.meas tran vdout0_109ck150 FIND v(dout0_109) AT=80.025n

.meas tran vdout0_110ck150 FIND v(dout0_110) AT=80.025n

.meas tran vdout0_111ck150 FIND v(dout0_111) AT=80.025n

.meas tran vdout0_112ck150 FIND v(dout0_112) AT=80.025n

.meas tran vdout0_113ck150 FIND v(dout0_113) AT=80.025n

.meas tran vdout0_114ck150 FIND v(dout0_114) AT=80.025n

.meas tran vdout0_115ck150 FIND v(dout0_115) AT=80.025n

.meas tran vdout0_116ck150 FIND v(dout0_116) AT=80.025n

.meas tran vdout0_117ck150 FIND v(dout0_117) AT=80.025n

.meas tran vdout0_118ck150 FIND v(dout0_118) AT=80.025n

.meas tran vdout0_119ck150 FIND v(dout0_119) AT=80.025n

.meas tran vdout0_120ck150 FIND v(dout0_120) AT=80.025n

.meas tran vdout0_121ck150 FIND v(dout0_121) AT=80.025n

.meas tran vdout0_122ck150 FIND v(dout0_122) AT=80.025n

.meas tran vdout0_123ck150 FIND v(dout0_123) AT=80.025n

.meas tran vdout0_124ck150 FIND v(dout0_124) AT=80.025n

.meas tran vdout0_125ck150 FIND v(dout0_125) AT=80.025n

.meas tran vdout0_126ck150 FIND v(dout0_126) AT=80.025n

.meas tran vdout0_127ck150 FIND v(dout0_127) AT=80.025n

.meas tran vdout0_128ck150 FIND v(dout0_128) AT=80.025n

.meas tran vdout0_129ck150 FIND v(dout0_129) AT=80.025n

.meas tran vdout0_130ck150 FIND v(dout0_130) AT=80.025n

.meas tran vdout0_131ck150 FIND v(dout0_131) AT=80.025n

.meas tran vdout0_132ck150 FIND v(dout0_132) AT=80.025n

.meas tran vdout0_133ck150 FIND v(dout0_133) AT=80.025n

.meas tran vdout0_134ck150 FIND v(dout0_134) AT=80.025n

.meas tran vdout0_135ck150 FIND v(dout0_135) AT=80.025n

.meas tran vdout0_136ck150 FIND v(dout0_136) AT=80.025n

.meas tran vdout0_137ck150 FIND v(dout0_137) AT=80.025n

.meas tran vdout0_138ck150 FIND v(dout0_138) AT=80.025n

.meas tran vdout0_139ck150 FIND v(dout0_139) AT=80.025n

.meas tran vdout0_140ck150 FIND v(dout0_140) AT=80.025n

.meas tran vdout0_141ck150 FIND v(dout0_141) AT=80.025n

.meas tran vdout0_142ck150 FIND v(dout0_142) AT=80.025n

.meas tran vdout0_143ck150 FIND v(dout0_143) AT=80.025n

.meas tran vdout0_144ck150 FIND v(dout0_144) AT=80.025n

.meas tran vdout0_145ck150 FIND v(dout0_145) AT=80.025n

.meas tran vdout0_146ck150 FIND v(dout0_146) AT=80.025n

.meas tran vdout0_147ck150 FIND v(dout0_147) AT=80.025n

.meas tran vdout0_148ck150 FIND v(dout0_148) AT=80.025n

.meas tran vdout0_149ck150 FIND v(dout0_149) AT=80.025n

.meas tran vdout0_0ck160 FIND v(dout0_0) AT=85.025n

.meas tran vdout0_1ck160 FIND v(dout0_1) AT=85.025n

.meas tran vdout0_2ck160 FIND v(dout0_2) AT=85.025n

.meas tran vdout0_3ck160 FIND v(dout0_3) AT=85.025n

.meas tran vdout0_4ck160 FIND v(dout0_4) AT=85.025n

.meas tran vdout0_5ck160 FIND v(dout0_5) AT=85.025n

.meas tran vdout0_6ck160 FIND v(dout0_6) AT=85.025n

.meas tran vdout0_7ck160 FIND v(dout0_7) AT=85.025n

.meas tran vdout0_8ck160 FIND v(dout0_8) AT=85.025n

.meas tran vdout0_9ck160 FIND v(dout0_9) AT=85.025n

.meas tran vdout0_10ck160 FIND v(dout0_10) AT=85.025n

.meas tran vdout0_11ck160 FIND v(dout0_11) AT=85.025n

.meas tran vdout0_12ck160 FIND v(dout0_12) AT=85.025n

.meas tran vdout0_13ck160 FIND v(dout0_13) AT=85.025n

.meas tran vdout0_14ck160 FIND v(dout0_14) AT=85.025n

.meas tran vdout0_15ck160 FIND v(dout0_15) AT=85.025n

.meas tran vdout0_16ck160 FIND v(dout0_16) AT=85.025n

.meas tran vdout0_17ck160 FIND v(dout0_17) AT=85.025n

.meas tran vdout0_18ck160 FIND v(dout0_18) AT=85.025n

.meas tran vdout0_19ck160 FIND v(dout0_19) AT=85.025n

.meas tran vdout0_20ck160 FIND v(dout0_20) AT=85.025n

.meas tran vdout0_21ck160 FIND v(dout0_21) AT=85.025n

.meas tran vdout0_22ck160 FIND v(dout0_22) AT=85.025n

.meas tran vdout0_23ck160 FIND v(dout0_23) AT=85.025n

.meas tran vdout0_24ck160 FIND v(dout0_24) AT=85.025n

.meas tran vdout0_25ck160 FIND v(dout0_25) AT=85.025n

.meas tran vdout0_26ck160 FIND v(dout0_26) AT=85.025n

.meas tran vdout0_27ck160 FIND v(dout0_27) AT=85.025n

.meas tran vdout0_28ck160 FIND v(dout0_28) AT=85.025n

.meas tran vdout0_29ck160 FIND v(dout0_29) AT=85.025n

.meas tran vdout0_30ck160 FIND v(dout0_30) AT=85.025n

.meas tran vdout0_31ck160 FIND v(dout0_31) AT=85.025n

.meas tran vdout0_32ck160 FIND v(dout0_32) AT=85.025n

.meas tran vdout0_33ck160 FIND v(dout0_33) AT=85.025n

.meas tran vdout0_34ck160 FIND v(dout0_34) AT=85.025n

.meas tran vdout0_35ck160 FIND v(dout0_35) AT=85.025n

.meas tran vdout0_36ck160 FIND v(dout0_36) AT=85.025n

.meas tran vdout0_37ck160 FIND v(dout0_37) AT=85.025n

.meas tran vdout0_38ck160 FIND v(dout0_38) AT=85.025n

.meas tran vdout0_39ck160 FIND v(dout0_39) AT=85.025n

.meas tran vdout0_40ck160 FIND v(dout0_40) AT=85.025n

.meas tran vdout0_41ck160 FIND v(dout0_41) AT=85.025n

.meas tran vdout0_42ck160 FIND v(dout0_42) AT=85.025n

.meas tran vdout0_43ck160 FIND v(dout0_43) AT=85.025n

.meas tran vdout0_44ck160 FIND v(dout0_44) AT=85.025n

.meas tran vdout0_45ck160 FIND v(dout0_45) AT=85.025n

.meas tran vdout0_46ck160 FIND v(dout0_46) AT=85.025n

.meas tran vdout0_47ck160 FIND v(dout0_47) AT=85.025n

.meas tran vdout0_48ck160 FIND v(dout0_48) AT=85.025n

.meas tran vdout0_49ck160 FIND v(dout0_49) AT=85.025n

.meas tran vdout0_50ck160 FIND v(dout0_50) AT=85.025n

.meas tran vdout0_51ck160 FIND v(dout0_51) AT=85.025n

.meas tran vdout0_52ck160 FIND v(dout0_52) AT=85.025n

.meas tran vdout0_53ck160 FIND v(dout0_53) AT=85.025n

.meas tran vdout0_54ck160 FIND v(dout0_54) AT=85.025n

.meas tran vdout0_55ck160 FIND v(dout0_55) AT=85.025n

.meas tran vdout0_56ck160 FIND v(dout0_56) AT=85.025n

.meas tran vdout0_57ck160 FIND v(dout0_57) AT=85.025n

.meas tran vdout0_58ck160 FIND v(dout0_58) AT=85.025n

.meas tran vdout0_59ck160 FIND v(dout0_59) AT=85.025n

.meas tran vdout0_60ck160 FIND v(dout0_60) AT=85.025n

.meas tran vdout0_61ck160 FIND v(dout0_61) AT=85.025n

.meas tran vdout0_62ck160 FIND v(dout0_62) AT=85.025n

.meas tran vdout0_63ck160 FIND v(dout0_63) AT=85.025n

.meas tran vdout0_64ck160 FIND v(dout0_64) AT=85.025n

.meas tran vdout0_65ck160 FIND v(dout0_65) AT=85.025n

.meas tran vdout0_66ck160 FIND v(dout0_66) AT=85.025n

.meas tran vdout0_67ck160 FIND v(dout0_67) AT=85.025n

.meas tran vdout0_68ck160 FIND v(dout0_68) AT=85.025n

.meas tran vdout0_69ck160 FIND v(dout0_69) AT=85.025n

.meas tran vdout0_70ck160 FIND v(dout0_70) AT=85.025n

.meas tran vdout0_71ck160 FIND v(dout0_71) AT=85.025n

.meas tran vdout0_72ck160 FIND v(dout0_72) AT=85.025n

.meas tran vdout0_73ck160 FIND v(dout0_73) AT=85.025n

.meas tran vdout0_74ck160 FIND v(dout0_74) AT=85.025n

.meas tran vdout0_75ck160 FIND v(dout0_75) AT=85.025n

.meas tran vdout0_76ck160 FIND v(dout0_76) AT=85.025n

.meas tran vdout0_77ck160 FIND v(dout0_77) AT=85.025n

.meas tran vdout0_78ck160 FIND v(dout0_78) AT=85.025n

.meas tran vdout0_79ck160 FIND v(dout0_79) AT=85.025n

.meas tran vdout0_80ck160 FIND v(dout0_80) AT=85.025n

.meas tran vdout0_81ck160 FIND v(dout0_81) AT=85.025n

.meas tran vdout0_82ck160 FIND v(dout0_82) AT=85.025n

.meas tran vdout0_83ck160 FIND v(dout0_83) AT=85.025n

.meas tran vdout0_84ck160 FIND v(dout0_84) AT=85.025n

.meas tran vdout0_85ck160 FIND v(dout0_85) AT=85.025n

.meas tran vdout0_86ck160 FIND v(dout0_86) AT=85.025n

.meas tran vdout0_87ck160 FIND v(dout0_87) AT=85.025n

.meas tran vdout0_88ck160 FIND v(dout0_88) AT=85.025n

.meas tran vdout0_89ck160 FIND v(dout0_89) AT=85.025n

.meas tran vdout0_90ck160 FIND v(dout0_90) AT=85.025n

.meas tran vdout0_91ck160 FIND v(dout0_91) AT=85.025n

.meas tran vdout0_92ck160 FIND v(dout0_92) AT=85.025n

.meas tran vdout0_93ck160 FIND v(dout0_93) AT=85.025n

.meas tran vdout0_94ck160 FIND v(dout0_94) AT=85.025n

.meas tran vdout0_95ck160 FIND v(dout0_95) AT=85.025n

.meas tran vdout0_96ck160 FIND v(dout0_96) AT=85.025n

.meas tran vdout0_97ck160 FIND v(dout0_97) AT=85.025n

.meas tran vdout0_98ck160 FIND v(dout0_98) AT=85.025n

.meas tran vdout0_99ck160 FIND v(dout0_99) AT=85.025n

.meas tran vdout0_100ck160 FIND v(dout0_100) AT=85.025n

.meas tran vdout0_101ck160 FIND v(dout0_101) AT=85.025n

.meas tran vdout0_102ck160 FIND v(dout0_102) AT=85.025n

.meas tran vdout0_103ck160 FIND v(dout0_103) AT=85.025n

.meas tran vdout0_104ck160 FIND v(dout0_104) AT=85.025n

.meas tran vdout0_105ck160 FIND v(dout0_105) AT=85.025n

.meas tran vdout0_106ck160 FIND v(dout0_106) AT=85.025n

.meas tran vdout0_107ck160 FIND v(dout0_107) AT=85.025n

.meas tran vdout0_108ck160 FIND v(dout0_108) AT=85.025n

.meas tran vdout0_109ck160 FIND v(dout0_109) AT=85.025n

.meas tran vdout0_110ck160 FIND v(dout0_110) AT=85.025n

.meas tran vdout0_111ck160 FIND v(dout0_111) AT=85.025n

.meas tran vdout0_112ck160 FIND v(dout0_112) AT=85.025n

.meas tran vdout0_113ck160 FIND v(dout0_113) AT=85.025n

.meas tran vdout0_114ck160 FIND v(dout0_114) AT=85.025n

.meas tran vdout0_115ck160 FIND v(dout0_115) AT=85.025n

.meas tran vdout0_116ck160 FIND v(dout0_116) AT=85.025n

.meas tran vdout0_117ck160 FIND v(dout0_117) AT=85.025n

.meas tran vdout0_118ck160 FIND v(dout0_118) AT=85.025n

.meas tran vdout0_119ck160 FIND v(dout0_119) AT=85.025n

.meas tran vdout0_120ck160 FIND v(dout0_120) AT=85.025n

.meas tran vdout0_121ck160 FIND v(dout0_121) AT=85.025n

.meas tran vdout0_122ck160 FIND v(dout0_122) AT=85.025n

.meas tran vdout0_123ck160 FIND v(dout0_123) AT=85.025n

.meas tran vdout0_124ck160 FIND v(dout0_124) AT=85.025n

.meas tran vdout0_125ck160 FIND v(dout0_125) AT=85.025n

.meas tran vdout0_126ck160 FIND v(dout0_126) AT=85.025n

.meas tran vdout0_127ck160 FIND v(dout0_127) AT=85.025n

.meas tran vdout0_128ck160 FIND v(dout0_128) AT=85.025n

.meas tran vdout0_129ck160 FIND v(dout0_129) AT=85.025n

.meas tran vdout0_130ck160 FIND v(dout0_130) AT=85.025n

.meas tran vdout0_131ck160 FIND v(dout0_131) AT=85.025n

.meas tran vdout0_132ck160 FIND v(dout0_132) AT=85.025n

.meas tran vdout0_133ck160 FIND v(dout0_133) AT=85.025n

.meas tran vdout0_134ck160 FIND v(dout0_134) AT=85.025n

.meas tran vdout0_135ck160 FIND v(dout0_135) AT=85.025n

.meas tran vdout0_136ck160 FIND v(dout0_136) AT=85.025n

.meas tran vdout0_137ck160 FIND v(dout0_137) AT=85.025n

.meas tran vdout0_138ck160 FIND v(dout0_138) AT=85.025n

.meas tran vdout0_139ck160 FIND v(dout0_139) AT=85.025n

.meas tran vdout0_140ck160 FIND v(dout0_140) AT=85.025n

.meas tran vdout0_141ck160 FIND v(dout0_141) AT=85.025n

.meas tran vdout0_142ck160 FIND v(dout0_142) AT=85.025n

.meas tran vdout0_143ck160 FIND v(dout0_143) AT=85.025n

.meas tran vdout0_144ck160 FIND v(dout0_144) AT=85.025n

.meas tran vdout0_145ck160 FIND v(dout0_145) AT=85.025n

.meas tran vdout0_146ck160 FIND v(dout0_146) AT=85.025n

.meas tran vdout0_147ck160 FIND v(dout0_147) AT=85.025n

.meas tran vdout0_148ck160 FIND v(dout0_148) AT=85.025n

.meas tran vdout0_149ck160 FIND v(dout0_149) AT=85.025n

.meas tran vdout0_0ck200 FIND v(dout0_0) AT=105.025n

.meas tran vdout0_1ck200 FIND v(dout0_1) AT=105.025n

.meas tran vdout0_2ck200 FIND v(dout0_2) AT=105.025n

.meas tran vdout0_3ck200 FIND v(dout0_3) AT=105.025n

.meas tran vdout0_4ck200 FIND v(dout0_4) AT=105.025n

.meas tran vdout0_5ck200 FIND v(dout0_5) AT=105.025n

.meas tran vdout0_6ck200 FIND v(dout0_6) AT=105.025n

.meas tran vdout0_7ck200 FIND v(dout0_7) AT=105.025n

.meas tran vdout0_8ck200 FIND v(dout0_8) AT=105.025n

.meas tran vdout0_9ck200 FIND v(dout0_9) AT=105.025n

.meas tran vdout0_10ck200 FIND v(dout0_10) AT=105.025n

.meas tran vdout0_11ck200 FIND v(dout0_11) AT=105.025n

.meas tran vdout0_12ck200 FIND v(dout0_12) AT=105.025n

.meas tran vdout0_13ck200 FIND v(dout0_13) AT=105.025n

.meas tran vdout0_14ck200 FIND v(dout0_14) AT=105.025n

.meas tran vdout0_15ck200 FIND v(dout0_15) AT=105.025n

.meas tran vdout0_16ck200 FIND v(dout0_16) AT=105.025n

.meas tran vdout0_17ck200 FIND v(dout0_17) AT=105.025n

.meas tran vdout0_18ck200 FIND v(dout0_18) AT=105.025n

.meas tran vdout0_19ck200 FIND v(dout0_19) AT=105.025n

.meas tran vdout0_20ck200 FIND v(dout0_20) AT=105.025n

.meas tran vdout0_21ck200 FIND v(dout0_21) AT=105.025n

.meas tran vdout0_22ck200 FIND v(dout0_22) AT=105.025n

.meas tran vdout0_23ck200 FIND v(dout0_23) AT=105.025n

.meas tran vdout0_24ck200 FIND v(dout0_24) AT=105.025n

.meas tran vdout0_25ck200 FIND v(dout0_25) AT=105.025n

.meas tran vdout0_26ck200 FIND v(dout0_26) AT=105.025n

.meas tran vdout0_27ck200 FIND v(dout0_27) AT=105.025n

.meas tran vdout0_28ck200 FIND v(dout0_28) AT=105.025n

.meas tran vdout0_29ck200 FIND v(dout0_29) AT=105.025n

.meas tran vdout0_30ck200 FIND v(dout0_30) AT=105.025n

.meas tran vdout0_31ck200 FIND v(dout0_31) AT=105.025n

.meas tran vdout0_32ck200 FIND v(dout0_32) AT=105.025n

.meas tran vdout0_33ck200 FIND v(dout0_33) AT=105.025n

.meas tran vdout0_34ck200 FIND v(dout0_34) AT=105.025n

.meas tran vdout0_35ck200 FIND v(dout0_35) AT=105.025n

.meas tran vdout0_36ck200 FIND v(dout0_36) AT=105.025n

.meas tran vdout0_37ck200 FIND v(dout0_37) AT=105.025n

.meas tran vdout0_38ck200 FIND v(dout0_38) AT=105.025n

.meas tran vdout0_39ck200 FIND v(dout0_39) AT=105.025n

.meas tran vdout0_40ck200 FIND v(dout0_40) AT=105.025n

.meas tran vdout0_41ck200 FIND v(dout0_41) AT=105.025n

.meas tran vdout0_42ck200 FIND v(dout0_42) AT=105.025n

.meas tran vdout0_43ck200 FIND v(dout0_43) AT=105.025n

.meas tran vdout0_44ck200 FIND v(dout0_44) AT=105.025n

.meas tran vdout0_45ck200 FIND v(dout0_45) AT=105.025n

.meas tran vdout0_46ck200 FIND v(dout0_46) AT=105.025n

.meas tran vdout0_47ck200 FIND v(dout0_47) AT=105.025n

.meas tran vdout0_48ck200 FIND v(dout0_48) AT=105.025n

.meas tran vdout0_49ck200 FIND v(dout0_49) AT=105.025n

.meas tran vdout0_50ck200 FIND v(dout0_50) AT=105.025n

.meas tran vdout0_51ck200 FIND v(dout0_51) AT=105.025n

.meas tran vdout0_52ck200 FIND v(dout0_52) AT=105.025n

.meas tran vdout0_53ck200 FIND v(dout0_53) AT=105.025n

.meas tran vdout0_54ck200 FIND v(dout0_54) AT=105.025n

.meas tran vdout0_55ck200 FIND v(dout0_55) AT=105.025n

.meas tran vdout0_56ck200 FIND v(dout0_56) AT=105.025n

.meas tran vdout0_57ck200 FIND v(dout0_57) AT=105.025n

.meas tran vdout0_58ck200 FIND v(dout0_58) AT=105.025n

.meas tran vdout0_59ck200 FIND v(dout0_59) AT=105.025n

.meas tran vdout0_60ck200 FIND v(dout0_60) AT=105.025n

.meas tran vdout0_61ck200 FIND v(dout0_61) AT=105.025n

.meas tran vdout0_62ck200 FIND v(dout0_62) AT=105.025n

.meas tran vdout0_63ck200 FIND v(dout0_63) AT=105.025n

.meas tran vdout0_64ck200 FIND v(dout0_64) AT=105.025n

.meas tran vdout0_65ck200 FIND v(dout0_65) AT=105.025n

.meas tran vdout0_66ck200 FIND v(dout0_66) AT=105.025n

.meas tran vdout0_67ck200 FIND v(dout0_67) AT=105.025n

.meas tran vdout0_68ck200 FIND v(dout0_68) AT=105.025n

.meas tran vdout0_69ck200 FIND v(dout0_69) AT=105.025n

.meas tran vdout0_70ck200 FIND v(dout0_70) AT=105.025n

.meas tran vdout0_71ck200 FIND v(dout0_71) AT=105.025n

.meas tran vdout0_72ck200 FIND v(dout0_72) AT=105.025n

.meas tran vdout0_73ck200 FIND v(dout0_73) AT=105.025n

.meas tran vdout0_74ck200 FIND v(dout0_74) AT=105.025n

.meas tran vdout0_75ck200 FIND v(dout0_75) AT=105.025n

.meas tran vdout0_76ck200 FIND v(dout0_76) AT=105.025n

.meas tran vdout0_77ck200 FIND v(dout0_77) AT=105.025n

.meas tran vdout0_78ck200 FIND v(dout0_78) AT=105.025n

.meas tran vdout0_79ck200 FIND v(dout0_79) AT=105.025n

.meas tran vdout0_80ck200 FIND v(dout0_80) AT=105.025n

.meas tran vdout0_81ck200 FIND v(dout0_81) AT=105.025n

.meas tran vdout0_82ck200 FIND v(dout0_82) AT=105.025n

.meas tran vdout0_83ck200 FIND v(dout0_83) AT=105.025n

.meas tran vdout0_84ck200 FIND v(dout0_84) AT=105.025n

.meas tran vdout0_85ck200 FIND v(dout0_85) AT=105.025n

.meas tran vdout0_86ck200 FIND v(dout0_86) AT=105.025n

.meas tran vdout0_87ck200 FIND v(dout0_87) AT=105.025n

.meas tran vdout0_88ck200 FIND v(dout0_88) AT=105.025n

.meas tran vdout0_89ck200 FIND v(dout0_89) AT=105.025n

.meas tran vdout0_90ck200 FIND v(dout0_90) AT=105.025n

.meas tran vdout0_91ck200 FIND v(dout0_91) AT=105.025n

.meas tran vdout0_92ck200 FIND v(dout0_92) AT=105.025n

.meas tran vdout0_93ck200 FIND v(dout0_93) AT=105.025n

.meas tran vdout0_94ck200 FIND v(dout0_94) AT=105.025n

.meas tran vdout0_95ck200 FIND v(dout0_95) AT=105.025n

.meas tran vdout0_96ck200 FIND v(dout0_96) AT=105.025n

.meas tran vdout0_97ck200 FIND v(dout0_97) AT=105.025n

.meas tran vdout0_98ck200 FIND v(dout0_98) AT=105.025n

.meas tran vdout0_99ck200 FIND v(dout0_99) AT=105.025n

.meas tran vdout0_100ck200 FIND v(dout0_100) AT=105.025n

.meas tran vdout0_101ck200 FIND v(dout0_101) AT=105.025n

.meas tran vdout0_102ck200 FIND v(dout0_102) AT=105.025n

.meas tran vdout0_103ck200 FIND v(dout0_103) AT=105.025n

.meas tran vdout0_104ck200 FIND v(dout0_104) AT=105.025n

.meas tran vdout0_105ck200 FIND v(dout0_105) AT=105.025n

.meas tran vdout0_106ck200 FIND v(dout0_106) AT=105.025n

.meas tran vdout0_107ck200 FIND v(dout0_107) AT=105.025n

.meas tran vdout0_108ck200 FIND v(dout0_108) AT=105.025n

.meas tran vdout0_109ck200 FIND v(dout0_109) AT=105.025n

.meas tran vdout0_110ck200 FIND v(dout0_110) AT=105.025n

.meas tran vdout0_111ck200 FIND v(dout0_111) AT=105.025n

.meas tran vdout0_112ck200 FIND v(dout0_112) AT=105.025n

.meas tran vdout0_113ck200 FIND v(dout0_113) AT=105.025n

.meas tran vdout0_114ck200 FIND v(dout0_114) AT=105.025n

.meas tran vdout0_115ck200 FIND v(dout0_115) AT=105.025n

.meas tran vdout0_116ck200 FIND v(dout0_116) AT=105.025n

.meas tran vdout0_117ck200 FIND v(dout0_117) AT=105.025n

.meas tran vdout0_118ck200 FIND v(dout0_118) AT=105.025n

.meas tran vdout0_119ck200 FIND v(dout0_119) AT=105.025n

.meas tran vdout0_120ck200 FIND v(dout0_120) AT=105.025n

.meas tran vdout0_121ck200 FIND v(dout0_121) AT=105.025n

.meas tran vdout0_122ck200 FIND v(dout0_122) AT=105.025n

.meas tran vdout0_123ck200 FIND v(dout0_123) AT=105.025n

.meas tran vdout0_124ck200 FIND v(dout0_124) AT=105.025n

.meas tran vdout0_125ck200 FIND v(dout0_125) AT=105.025n

.meas tran vdout0_126ck200 FIND v(dout0_126) AT=105.025n

.meas tran vdout0_127ck200 FIND v(dout0_127) AT=105.025n

.meas tran vdout0_128ck200 FIND v(dout0_128) AT=105.025n

.meas tran vdout0_129ck200 FIND v(dout0_129) AT=105.025n

.meas tran vdout0_130ck200 FIND v(dout0_130) AT=105.025n

.meas tran vdout0_131ck200 FIND v(dout0_131) AT=105.025n

.meas tran vdout0_132ck200 FIND v(dout0_132) AT=105.025n

.meas tran vdout0_133ck200 FIND v(dout0_133) AT=105.025n

.meas tran vdout0_134ck200 FIND v(dout0_134) AT=105.025n

.meas tran vdout0_135ck200 FIND v(dout0_135) AT=105.025n

.meas tran vdout0_136ck200 FIND v(dout0_136) AT=105.025n

.meas tran vdout0_137ck200 FIND v(dout0_137) AT=105.025n

.meas tran vdout0_138ck200 FIND v(dout0_138) AT=105.025n

.meas tran vdout0_139ck200 FIND v(dout0_139) AT=105.025n

.meas tran vdout0_140ck200 FIND v(dout0_140) AT=105.025n

.meas tran vdout0_141ck200 FIND v(dout0_141) AT=105.025n

.meas tran vdout0_142ck200 FIND v(dout0_142) AT=105.025n

.meas tran vdout0_143ck200 FIND v(dout0_143) AT=105.025n

.meas tran vdout0_144ck200 FIND v(dout0_144) AT=105.025n

.meas tran vdout0_145ck200 FIND v(dout0_145) AT=105.025n

.meas tran vdout0_146ck200 FIND v(dout0_146) AT=105.025n

.meas tran vdout0_147ck200 FIND v(dout0_147) AT=105.025n

.meas tran vdout0_148ck200 FIND v(dout0_148) AT=105.025n

.meas tran vdout0_149ck200 FIND v(dout0_149) AT=105.025n

.meas tran vdout0_0ck210 FIND v(dout0_0) AT=110.025n

.meas tran vdout0_1ck210 FIND v(dout0_1) AT=110.025n

.meas tran vdout0_2ck210 FIND v(dout0_2) AT=110.025n

.meas tran vdout0_3ck210 FIND v(dout0_3) AT=110.025n

.meas tran vdout0_4ck210 FIND v(dout0_4) AT=110.025n

.meas tran vdout0_5ck210 FIND v(dout0_5) AT=110.025n

.meas tran vdout0_6ck210 FIND v(dout0_6) AT=110.025n

.meas tran vdout0_7ck210 FIND v(dout0_7) AT=110.025n

.meas tran vdout0_8ck210 FIND v(dout0_8) AT=110.025n

.meas tran vdout0_9ck210 FIND v(dout0_9) AT=110.025n

.meas tran vdout0_10ck210 FIND v(dout0_10) AT=110.025n

.meas tran vdout0_11ck210 FIND v(dout0_11) AT=110.025n

.meas tran vdout0_12ck210 FIND v(dout0_12) AT=110.025n

.meas tran vdout0_13ck210 FIND v(dout0_13) AT=110.025n

.meas tran vdout0_14ck210 FIND v(dout0_14) AT=110.025n

.meas tran vdout0_15ck210 FIND v(dout0_15) AT=110.025n

.meas tran vdout0_16ck210 FIND v(dout0_16) AT=110.025n

.meas tran vdout0_17ck210 FIND v(dout0_17) AT=110.025n

.meas tran vdout0_18ck210 FIND v(dout0_18) AT=110.025n

.meas tran vdout0_19ck210 FIND v(dout0_19) AT=110.025n

.meas tran vdout0_20ck210 FIND v(dout0_20) AT=110.025n

.meas tran vdout0_21ck210 FIND v(dout0_21) AT=110.025n

.meas tran vdout0_22ck210 FIND v(dout0_22) AT=110.025n

.meas tran vdout0_23ck210 FIND v(dout0_23) AT=110.025n

.meas tran vdout0_24ck210 FIND v(dout0_24) AT=110.025n

.meas tran vdout0_25ck210 FIND v(dout0_25) AT=110.025n

.meas tran vdout0_26ck210 FIND v(dout0_26) AT=110.025n

.meas tran vdout0_27ck210 FIND v(dout0_27) AT=110.025n

.meas tran vdout0_28ck210 FIND v(dout0_28) AT=110.025n

.meas tran vdout0_29ck210 FIND v(dout0_29) AT=110.025n

.meas tran vdout0_30ck210 FIND v(dout0_30) AT=110.025n

.meas tran vdout0_31ck210 FIND v(dout0_31) AT=110.025n

.meas tran vdout0_32ck210 FIND v(dout0_32) AT=110.025n

.meas tran vdout0_33ck210 FIND v(dout0_33) AT=110.025n

.meas tran vdout0_34ck210 FIND v(dout0_34) AT=110.025n

.meas tran vdout0_35ck210 FIND v(dout0_35) AT=110.025n

.meas tran vdout0_36ck210 FIND v(dout0_36) AT=110.025n

.meas tran vdout0_37ck210 FIND v(dout0_37) AT=110.025n

.meas tran vdout0_38ck210 FIND v(dout0_38) AT=110.025n

.meas tran vdout0_39ck210 FIND v(dout0_39) AT=110.025n

.meas tran vdout0_40ck210 FIND v(dout0_40) AT=110.025n

.meas tran vdout0_41ck210 FIND v(dout0_41) AT=110.025n

.meas tran vdout0_42ck210 FIND v(dout0_42) AT=110.025n

.meas tran vdout0_43ck210 FIND v(dout0_43) AT=110.025n

.meas tran vdout0_44ck210 FIND v(dout0_44) AT=110.025n

.meas tran vdout0_45ck210 FIND v(dout0_45) AT=110.025n

.meas tran vdout0_46ck210 FIND v(dout0_46) AT=110.025n

.meas tran vdout0_47ck210 FIND v(dout0_47) AT=110.025n

.meas tran vdout0_48ck210 FIND v(dout0_48) AT=110.025n

.meas tran vdout0_49ck210 FIND v(dout0_49) AT=110.025n

.meas tran vdout0_50ck210 FIND v(dout0_50) AT=110.025n

.meas tran vdout0_51ck210 FIND v(dout0_51) AT=110.025n

.meas tran vdout0_52ck210 FIND v(dout0_52) AT=110.025n

.meas tran vdout0_53ck210 FIND v(dout0_53) AT=110.025n

.meas tran vdout0_54ck210 FIND v(dout0_54) AT=110.025n

.meas tran vdout0_55ck210 FIND v(dout0_55) AT=110.025n

.meas tran vdout0_56ck210 FIND v(dout0_56) AT=110.025n

.meas tran vdout0_57ck210 FIND v(dout0_57) AT=110.025n

.meas tran vdout0_58ck210 FIND v(dout0_58) AT=110.025n

.meas tran vdout0_59ck210 FIND v(dout0_59) AT=110.025n

.meas tran vdout0_60ck210 FIND v(dout0_60) AT=110.025n

.meas tran vdout0_61ck210 FIND v(dout0_61) AT=110.025n

.meas tran vdout0_62ck210 FIND v(dout0_62) AT=110.025n

.meas tran vdout0_63ck210 FIND v(dout0_63) AT=110.025n

.meas tran vdout0_64ck210 FIND v(dout0_64) AT=110.025n

.meas tran vdout0_65ck210 FIND v(dout0_65) AT=110.025n

.meas tran vdout0_66ck210 FIND v(dout0_66) AT=110.025n

.meas tran vdout0_67ck210 FIND v(dout0_67) AT=110.025n

.meas tran vdout0_68ck210 FIND v(dout0_68) AT=110.025n

.meas tran vdout0_69ck210 FIND v(dout0_69) AT=110.025n

.meas tran vdout0_70ck210 FIND v(dout0_70) AT=110.025n

.meas tran vdout0_71ck210 FIND v(dout0_71) AT=110.025n

.meas tran vdout0_72ck210 FIND v(dout0_72) AT=110.025n

.meas tran vdout0_73ck210 FIND v(dout0_73) AT=110.025n

.meas tran vdout0_74ck210 FIND v(dout0_74) AT=110.025n

.meas tran vdout0_75ck210 FIND v(dout0_75) AT=110.025n

.meas tran vdout0_76ck210 FIND v(dout0_76) AT=110.025n

.meas tran vdout0_77ck210 FIND v(dout0_77) AT=110.025n

.meas tran vdout0_78ck210 FIND v(dout0_78) AT=110.025n

.meas tran vdout0_79ck210 FIND v(dout0_79) AT=110.025n

.meas tran vdout0_80ck210 FIND v(dout0_80) AT=110.025n

.meas tran vdout0_81ck210 FIND v(dout0_81) AT=110.025n

.meas tran vdout0_82ck210 FIND v(dout0_82) AT=110.025n

.meas tran vdout0_83ck210 FIND v(dout0_83) AT=110.025n

.meas tran vdout0_84ck210 FIND v(dout0_84) AT=110.025n

.meas tran vdout0_85ck210 FIND v(dout0_85) AT=110.025n

.meas tran vdout0_86ck210 FIND v(dout0_86) AT=110.025n

.meas tran vdout0_87ck210 FIND v(dout0_87) AT=110.025n

.meas tran vdout0_88ck210 FIND v(dout0_88) AT=110.025n

.meas tran vdout0_89ck210 FIND v(dout0_89) AT=110.025n

.meas tran vdout0_90ck210 FIND v(dout0_90) AT=110.025n

.meas tran vdout0_91ck210 FIND v(dout0_91) AT=110.025n

.meas tran vdout0_92ck210 FIND v(dout0_92) AT=110.025n

.meas tran vdout0_93ck210 FIND v(dout0_93) AT=110.025n

.meas tran vdout0_94ck210 FIND v(dout0_94) AT=110.025n

.meas tran vdout0_95ck210 FIND v(dout0_95) AT=110.025n

.meas tran vdout0_96ck210 FIND v(dout0_96) AT=110.025n

.meas tran vdout0_97ck210 FIND v(dout0_97) AT=110.025n

.meas tran vdout0_98ck210 FIND v(dout0_98) AT=110.025n

.meas tran vdout0_99ck210 FIND v(dout0_99) AT=110.025n

.meas tran vdout0_100ck210 FIND v(dout0_100) AT=110.025n

.meas tran vdout0_101ck210 FIND v(dout0_101) AT=110.025n

.meas tran vdout0_102ck210 FIND v(dout0_102) AT=110.025n

.meas tran vdout0_103ck210 FIND v(dout0_103) AT=110.025n

.meas tran vdout0_104ck210 FIND v(dout0_104) AT=110.025n

.meas tran vdout0_105ck210 FIND v(dout0_105) AT=110.025n

.meas tran vdout0_106ck210 FIND v(dout0_106) AT=110.025n

.meas tran vdout0_107ck210 FIND v(dout0_107) AT=110.025n

.meas tran vdout0_108ck210 FIND v(dout0_108) AT=110.025n

.meas tran vdout0_109ck210 FIND v(dout0_109) AT=110.025n

.meas tran vdout0_110ck210 FIND v(dout0_110) AT=110.025n

.meas tran vdout0_111ck210 FIND v(dout0_111) AT=110.025n

.meas tran vdout0_112ck210 FIND v(dout0_112) AT=110.025n

.meas tran vdout0_113ck210 FIND v(dout0_113) AT=110.025n

.meas tran vdout0_114ck210 FIND v(dout0_114) AT=110.025n

.meas tran vdout0_115ck210 FIND v(dout0_115) AT=110.025n

.meas tran vdout0_116ck210 FIND v(dout0_116) AT=110.025n

.meas tran vdout0_117ck210 FIND v(dout0_117) AT=110.025n

.meas tran vdout0_118ck210 FIND v(dout0_118) AT=110.025n

.meas tran vdout0_119ck210 FIND v(dout0_119) AT=110.025n

.meas tran vdout0_120ck210 FIND v(dout0_120) AT=110.025n

.meas tran vdout0_121ck210 FIND v(dout0_121) AT=110.025n

.meas tran vdout0_122ck210 FIND v(dout0_122) AT=110.025n

.meas tran vdout0_123ck210 FIND v(dout0_123) AT=110.025n

.meas tran vdout0_124ck210 FIND v(dout0_124) AT=110.025n

.meas tran vdout0_125ck210 FIND v(dout0_125) AT=110.025n

.meas tran vdout0_126ck210 FIND v(dout0_126) AT=110.025n

.meas tran vdout0_127ck210 FIND v(dout0_127) AT=110.025n

.meas tran vdout0_128ck210 FIND v(dout0_128) AT=110.025n

.meas tran vdout0_129ck210 FIND v(dout0_129) AT=110.025n

.meas tran vdout0_130ck210 FIND v(dout0_130) AT=110.025n

.meas tran vdout0_131ck210 FIND v(dout0_131) AT=110.025n

.meas tran vdout0_132ck210 FIND v(dout0_132) AT=110.025n

.meas tran vdout0_133ck210 FIND v(dout0_133) AT=110.025n

.meas tran vdout0_134ck210 FIND v(dout0_134) AT=110.025n

.meas tran vdout0_135ck210 FIND v(dout0_135) AT=110.025n

.meas tran vdout0_136ck210 FIND v(dout0_136) AT=110.025n

.meas tran vdout0_137ck210 FIND v(dout0_137) AT=110.025n

.meas tran vdout0_138ck210 FIND v(dout0_138) AT=110.025n

.meas tran vdout0_139ck210 FIND v(dout0_139) AT=110.025n

.meas tran vdout0_140ck210 FIND v(dout0_140) AT=110.025n

.meas tran vdout0_141ck210 FIND v(dout0_141) AT=110.025n

.meas tran vdout0_142ck210 FIND v(dout0_142) AT=110.025n

.meas tran vdout0_143ck210 FIND v(dout0_143) AT=110.025n

.meas tran vdout0_144ck210 FIND v(dout0_144) AT=110.025n

.meas tran vdout0_145ck210 FIND v(dout0_145) AT=110.025n

.meas tran vdout0_146ck210 FIND v(dout0_146) AT=110.025n

.meas tran vdout0_147ck210 FIND v(dout0_147) AT=110.025n

.meas tran vdout0_148ck210 FIND v(dout0_148) AT=110.025n

.meas tran vdout0_149ck210 FIND v(dout0_149) AT=110.025n

.meas tran vdout0_0ck230 FIND v(dout0_0) AT=120.025n

.meas tran vdout0_1ck230 FIND v(dout0_1) AT=120.025n

.meas tran vdout0_2ck230 FIND v(dout0_2) AT=120.025n

.meas tran vdout0_3ck230 FIND v(dout0_3) AT=120.025n

.meas tran vdout0_4ck230 FIND v(dout0_4) AT=120.025n

.meas tran vdout0_5ck230 FIND v(dout0_5) AT=120.025n

.meas tran vdout0_6ck230 FIND v(dout0_6) AT=120.025n

.meas tran vdout0_7ck230 FIND v(dout0_7) AT=120.025n

.meas tran vdout0_8ck230 FIND v(dout0_8) AT=120.025n

.meas tran vdout0_9ck230 FIND v(dout0_9) AT=120.025n

.meas tran vdout0_10ck230 FIND v(dout0_10) AT=120.025n

.meas tran vdout0_11ck230 FIND v(dout0_11) AT=120.025n

.meas tran vdout0_12ck230 FIND v(dout0_12) AT=120.025n

.meas tran vdout0_13ck230 FIND v(dout0_13) AT=120.025n

.meas tran vdout0_14ck230 FIND v(dout0_14) AT=120.025n

.meas tran vdout0_15ck230 FIND v(dout0_15) AT=120.025n

.meas tran vdout0_16ck230 FIND v(dout0_16) AT=120.025n

.meas tran vdout0_17ck230 FIND v(dout0_17) AT=120.025n

.meas tran vdout0_18ck230 FIND v(dout0_18) AT=120.025n

.meas tran vdout0_19ck230 FIND v(dout0_19) AT=120.025n

.meas tran vdout0_20ck230 FIND v(dout0_20) AT=120.025n

.meas tran vdout0_21ck230 FIND v(dout0_21) AT=120.025n

.meas tran vdout0_22ck230 FIND v(dout0_22) AT=120.025n

.meas tran vdout0_23ck230 FIND v(dout0_23) AT=120.025n

.meas tran vdout0_24ck230 FIND v(dout0_24) AT=120.025n

.meas tran vdout0_25ck230 FIND v(dout0_25) AT=120.025n

.meas tran vdout0_26ck230 FIND v(dout0_26) AT=120.025n

.meas tran vdout0_27ck230 FIND v(dout0_27) AT=120.025n

.meas tran vdout0_28ck230 FIND v(dout0_28) AT=120.025n

.meas tran vdout0_29ck230 FIND v(dout0_29) AT=120.025n

.meas tran vdout0_30ck230 FIND v(dout0_30) AT=120.025n

.meas tran vdout0_31ck230 FIND v(dout0_31) AT=120.025n

.meas tran vdout0_32ck230 FIND v(dout0_32) AT=120.025n

.meas tran vdout0_33ck230 FIND v(dout0_33) AT=120.025n

.meas tran vdout0_34ck230 FIND v(dout0_34) AT=120.025n

.meas tran vdout0_35ck230 FIND v(dout0_35) AT=120.025n

.meas tran vdout0_36ck230 FIND v(dout0_36) AT=120.025n

.meas tran vdout0_37ck230 FIND v(dout0_37) AT=120.025n

.meas tran vdout0_38ck230 FIND v(dout0_38) AT=120.025n

.meas tran vdout0_39ck230 FIND v(dout0_39) AT=120.025n

.meas tran vdout0_40ck230 FIND v(dout0_40) AT=120.025n

.meas tran vdout0_41ck230 FIND v(dout0_41) AT=120.025n

.meas tran vdout0_42ck230 FIND v(dout0_42) AT=120.025n

.meas tran vdout0_43ck230 FIND v(dout0_43) AT=120.025n

.meas tran vdout0_44ck230 FIND v(dout0_44) AT=120.025n

.meas tran vdout0_45ck230 FIND v(dout0_45) AT=120.025n

.meas tran vdout0_46ck230 FIND v(dout0_46) AT=120.025n

.meas tran vdout0_47ck230 FIND v(dout0_47) AT=120.025n

.meas tran vdout0_48ck230 FIND v(dout0_48) AT=120.025n

.meas tran vdout0_49ck230 FIND v(dout0_49) AT=120.025n

.meas tran vdout0_50ck230 FIND v(dout0_50) AT=120.025n

.meas tran vdout0_51ck230 FIND v(dout0_51) AT=120.025n

.meas tran vdout0_52ck230 FIND v(dout0_52) AT=120.025n

.meas tran vdout0_53ck230 FIND v(dout0_53) AT=120.025n

.meas tran vdout0_54ck230 FIND v(dout0_54) AT=120.025n

.meas tran vdout0_55ck230 FIND v(dout0_55) AT=120.025n

.meas tran vdout0_56ck230 FIND v(dout0_56) AT=120.025n

.meas tran vdout0_57ck230 FIND v(dout0_57) AT=120.025n

.meas tran vdout0_58ck230 FIND v(dout0_58) AT=120.025n

.meas tran vdout0_59ck230 FIND v(dout0_59) AT=120.025n

.meas tran vdout0_60ck230 FIND v(dout0_60) AT=120.025n

.meas tran vdout0_61ck230 FIND v(dout0_61) AT=120.025n

.meas tran vdout0_62ck230 FIND v(dout0_62) AT=120.025n

.meas tran vdout0_63ck230 FIND v(dout0_63) AT=120.025n

.meas tran vdout0_64ck230 FIND v(dout0_64) AT=120.025n

.meas tran vdout0_65ck230 FIND v(dout0_65) AT=120.025n

.meas tran vdout0_66ck230 FIND v(dout0_66) AT=120.025n

.meas tran vdout0_67ck230 FIND v(dout0_67) AT=120.025n

.meas tran vdout0_68ck230 FIND v(dout0_68) AT=120.025n

.meas tran vdout0_69ck230 FIND v(dout0_69) AT=120.025n

.meas tran vdout0_70ck230 FIND v(dout0_70) AT=120.025n

.meas tran vdout0_71ck230 FIND v(dout0_71) AT=120.025n

.meas tran vdout0_72ck230 FIND v(dout0_72) AT=120.025n

.meas tran vdout0_73ck230 FIND v(dout0_73) AT=120.025n

.meas tran vdout0_74ck230 FIND v(dout0_74) AT=120.025n

.meas tran vdout0_75ck230 FIND v(dout0_75) AT=120.025n

.meas tran vdout0_76ck230 FIND v(dout0_76) AT=120.025n

.meas tran vdout0_77ck230 FIND v(dout0_77) AT=120.025n

.meas tran vdout0_78ck230 FIND v(dout0_78) AT=120.025n

.meas tran vdout0_79ck230 FIND v(dout0_79) AT=120.025n

.meas tran vdout0_80ck230 FIND v(dout0_80) AT=120.025n

.meas tran vdout0_81ck230 FIND v(dout0_81) AT=120.025n

.meas tran vdout0_82ck230 FIND v(dout0_82) AT=120.025n

.meas tran vdout0_83ck230 FIND v(dout0_83) AT=120.025n

.meas tran vdout0_84ck230 FIND v(dout0_84) AT=120.025n

.meas tran vdout0_85ck230 FIND v(dout0_85) AT=120.025n

.meas tran vdout0_86ck230 FIND v(dout0_86) AT=120.025n

.meas tran vdout0_87ck230 FIND v(dout0_87) AT=120.025n

.meas tran vdout0_88ck230 FIND v(dout0_88) AT=120.025n

.meas tran vdout0_89ck230 FIND v(dout0_89) AT=120.025n

.meas tran vdout0_90ck230 FIND v(dout0_90) AT=120.025n

.meas tran vdout0_91ck230 FIND v(dout0_91) AT=120.025n

.meas tran vdout0_92ck230 FIND v(dout0_92) AT=120.025n

.meas tran vdout0_93ck230 FIND v(dout0_93) AT=120.025n

.meas tran vdout0_94ck230 FIND v(dout0_94) AT=120.025n

.meas tran vdout0_95ck230 FIND v(dout0_95) AT=120.025n

.meas tran vdout0_96ck230 FIND v(dout0_96) AT=120.025n

.meas tran vdout0_97ck230 FIND v(dout0_97) AT=120.025n

.meas tran vdout0_98ck230 FIND v(dout0_98) AT=120.025n

.meas tran vdout0_99ck230 FIND v(dout0_99) AT=120.025n

.meas tran vdout0_100ck230 FIND v(dout0_100) AT=120.025n

.meas tran vdout0_101ck230 FIND v(dout0_101) AT=120.025n

.meas tran vdout0_102ck230 FIND v(dout0_102) AT=120.025n

.meas tran vdout0_103ck230 FIND v(dout0_103) AT=120.025n

.meas tran vdout0_104ck230 FIND v(dout0_104) AT=120.025n

.meas tran vdout0_105ck230 FIND v(dout0_105) AT=120.025n

.meas tran vdout0_106ck230 FIND v(dout0_106) AT=120.025n

.meas tran vdout0_107ck230 FIND v(dout0_107) AT=120.025n

.meas tran vdout0_108ck230 FIND v(dout0_108) AT=120.025n

.meas tran vdout0_109ck230 FIND v(dout0_109) AT=120.025n

.meas tran vdout0_110ck230 FIND v(dout0_110) AT=120.025n

.meas tran vdout0_111ck230 FIND v(dout0_111) AT=120.025n

.meas tran vdout0_112ck230 FIND v(dout0_112) AT=120.025n

.meas tran vdout0_113ck230 FIND v(dout0_113) AT=120.025n

.meas tran vdout0_114ck230 FIND v(dout0_114) AT=120.025n

.meas tran vdout0_115ck230 FIND v(dout0_115) AT=120.025n

.meas tran vdout0_116ck230 FIND v(dout0_116) AT=120.025n

.meas tran vdout0_117ck230 FIND v(dout0_117) AT=120.025n

.meas tran vdout0_118ck230 FIND v(dout0_118) AT=120.025n

.meas tran vdout0_119ck230 FIND v(dout0_119) AT=120.025n

.meas tran vdout0_120ck230 FIND v(dout0_120) AT=120.025n

.meas tran vdout0_121ck230 FIND v(dout0_121) AT=120.025n

.meas tran vdout0_122ck230 FIND v(dout0_122) AT=120.025n

.meas tran vdout0_123ck230 FIND v(dout0_123) AT=120.025n

.meas tran vdout0_124ck230 FIND v(dout0_124) AT=120.025n

.meas tran vdout0_125ck230 FIND v(dout0_125) AT=120.025n

.meas tran vdout0_126ck230 FIND v(dout0_126) AT=120.025n

.meas tran vdout0_127ck230 FIND v(dout0_127) AT=120.025n

.meas tran vdout0_128ck230 FIND v(dout0_128) AT=120.025n

.meas tran vdout0_129ck230 FIND v(dout0_129) AT=120.025n

.meas tran vdout0_130ck230 FIND v(dout0_130) AT=120.025n

.meas tran vdout0_131ck230 FIND v(dout0_131) AT=120.025n

.meas tran vdout0_132ck230 FIND v(dout0_132) AT=120.025n

.meas tran vdout0_133ck230 FIND v(dout0_133) AT=120.025n

.meas tran vdout0_134ck230 FIND v(dout0_134) AT=120.025n

.meas tran vdout0_135ck230 FIND v(dout0_135) AT=120.025n

.meas tran vdout0_136ck230 FIND v(dout0_136) AT=120.025n

.meas tran vdout0_137ck230 FIND v(dout0_137) AT=120.025n

.meas tran vdout0_138ck230 FIND v(dout0_138) AT=120.025n

.meas tran vdout0_139ck230 FIND v(dout0_139) AT=120.025n

.meas tran vdout0_140ck230 FIND v(dout0_140) AT=120.025n

.meas tran vdout0_141ck230 FIND v(dout0_141) AT=120.025n

.meas tran vdout0_142ck230 FIND v(dout0_142) AT=120.025n

.meas tran vdout0_143ck230 FIND v(dout0_143) AT=120.025n

.meas tran vdout0_144ck230 FIND v(dout0_144) AT=120.025n

.meas tran vdout0_145ck230 FIND v(dout0_145) AT=120.025n

.meas tran vdout0_146ck230 FIND v(dout0_146) AT=120.025n

.meas tran vdout0_147ck230 FIND v(dout0_147) AT=120.025n

.meas tran vdout0_148ck230 FIND v(dout0_148) AT=120.025n

.meas tran vdout0_149ck230 FIND v(dout0_149) AT=120.025n

.meas tran vdout0_0ck240 FIND v(dout0_0) AT=125.025n

.meas tran vdout0_1ck240 FIND v(dout0_1) AT=125.025n

.meas tran vdout0_2ck240 FIND v(dout0_2) AT=125.025n

.meas tran vdout0_3ck240 FIND v(dout0_3) AT=125.025n

.meas tran vdout0_4ck240 FIND v(dout0_4) AT=125.025n

.meas tran vdout0_5ck240 FIND v(dout0_5) AT=125.025n

.meas tran vdout0_6ck240 FIND v(dout0_6) AT=125.025n

.meas tran vdout0_7ck240 FIND v(dout0_7) AT=125.025n

.meas tran vdout0_8ck240 FIND v(dout0_8) AT=125.025n

.meas tran vdout0_9ck240 FIND v(dout0_9) AT=125.025n

.meas tran vdout0_10ck240 FIND v(dout0_10) AT=125.025n

.meas tran vdout0_11ck240 FIND v(dout0_11) AT=125.025n

.meas tran vdout0_12ck240 FIND v(dout0_12) AT=125.025n

.meas tran vdout0_13ck240 FIND v(dout0_13) AT=125.025n

.meas tran vdout0_14ck240 FIND v(dout0_14) AT=125.025n

.meas tran vdout0_15ck240 FIND v(dout0_15) AT=125.025n

.meas tran vdout0_16ck240 FIND v(dout0_16) AT=125.025n

.meas tran vdout0_17ck240 FIND v(dout0_17) AT=125.025n

.meas tran vdout0_18ck240 FIND v(dout0_18) AT=125.025n

.meas tran vdout0_19ck240 FIND v(dout0_19) AT=125.025n

.meas tran vdout0_20ck240 FIND v(dout0_20) AT=125.025n

.meas tran vdout0_21ck240 FIND v(dout0_21) AT=125.025n

.meas tran vdout0_22ck240 FIND v(dout0_22) AT=125.025n

.meas tran vdout0_23ck240 FIND v(dout0_23) AT=125.025n

.meas tran vdout0_24ck240 FIND v(dout0_24) AT=125.025n

.meas tran vdout0_25ck240 FIND v(dout0_25) AT=125.025n

.meas tran vdout0_26ck240 FIND v(dout0_26) AT=125.025n

.meas tran vdout0_27ck240 FIND v(dout0_27) AT=125.025n

.meas tran vdout0_28ck240 FIND v(dout0_28) AT=125.025n

.meas tran vdout0_29ck240 FIND v(dout0_29) AT=125.025n

.meas tran vdout0_30ck240 FIND v(dout0_30) AT=125.025n

.meas tran vdout0_31ck240 FIND v(dout0_31) AT=125.025n

.meas tran vdout0_32ck240 FIND v(dout0_32) AT=125.025n

.meas tran vdout0_33ck240 FIND v(dout0_33) AT=125.025n

.meas tran vdout0_34ck240 FIND v(dout0_34) AT=125.025n

.meas tran vdout0_35ck240 FIND v(dout0_35) AT=125.025n

.meas tran vdout0_36ck240 FIND v(dout0_36) AT=125.025n

.meas tran vdout0_37ck240 FIND v(dout0_37) AT=125.025n

.meas tran vdout0_38ck240 FIND v(dout0_38) AT=125.025n

.meas tran vdout0_39ck240 FIND v(dout0_39) AT=125.025n

.meas tran vdout0_40ck240 FIND v(dout0_40) AT=125.025n

.meas tran vdout0_41ck240 FIND v(dout0_41) AT=125.025n

.meas tran vdout0_42ck240 FIND v(dout0_42) AT=125.025n

.meas tran vdout0_43ck240 FIND v(dout0_43) AT=125.025n

.meas tran vdout0_44ck240 FIND v(dout0_44) AT=125.025n

.meas tran vdout0_45ck240 FIND v(dout0_45) AT=125.025n

.meas tran vdout0_46ck240 FIND v(dout0_46) AT=125.025n

.meas tran vdout0_47ck240 FIND v(dout0_47) AT=125.025n

.meas tran vdout0_48ck240 FIND v(dout0_48) AT=125.025n

.meas tran vdout0_49ck240 FIND v(dout0_49) AT=125.025n

.meas tran vdout0_50ck240 FIND v(dout0_50) AT=125.025n

.meas tran vdout0_51ck240 FIND v(dout0_51) AT=125.025n

.meas tran vdout0_52ck240 FIND v(dout0_52) AT=125.025n

.meas tran vdout0_53ck240 FIND v(dout0_53) AT=125.025n

.meas tran vdout0_54ck240 FIND v(dout0_54) AT=125.025n

.meas tran vdout0_55ck240 FIND v(dout0_55) AT=125.025n

.meas tran vdout0_56ck240 FIND v(dout0_56) AT=125.025n

.meas tran vdout0_57ck240 FIND v(dout0_57) AT=125.025n

.meas tran vdout0_58ck240 FIND v(dout0_58) AT=125.025n

.meas tran vdout0_59ck240 FIND v(dout0_59) AT=125.025n

.meas tran vdout0_60ck240 FIND v(dout0_60) AT=125.025n

.meas tran vdout0_61ck240 FIND v(dout0_61) AT=125.025n

.meas tran vdout0_62ck240 FIND v(dout0_62) AT=125.025n

.meas tran vdout0_63ck240 FIND v(dout0_63) AT=125.025n

.meas tran vdout0_64ck240 FIND v(dout0_64) AT=125.025n

.meas tran vdout0_65ck240 FIND v(dout0_65) AT=125.025n

.meas tran vdout0_66ck240 FIND v(dout0_66) AT=125.025n

.meas tran vdout0_67ck240 FIND v(dout0_67) AT=125.025n

.meas tran vdout0_68ck240 FIND v(dout0_68) AT=125.025n

.meas tran vdout0_69ck240 FIND v(dout0_69) AT=125.025n

.meas tran vdout0_70ck240 FIND v(dout0_70) AT=125.025n

.meas tran vdout0_71ck240 FIND v(dout0_71) AT=125.025n

.meas tran vdout0_72ck240 FIND v(dout0_72) AT=125.025n

.meas tran vdout0_73ck240 FIND v(dout0_73) AT=125.025n

.meas tran vdout0_74ck240 FIND v(dout0_74) AT=125.025n

.meas tran vdout0_75ck240 FIND v(dout0_75) AT=125.025n

.meas tran vdout0_76ck240 FIND v(dout0_76) AT=125.025n

.meas tran vdout0_77ck240 FIND v(dout0_77) AT=125.025n

.meas tran vdout0_78ck240 FIND v(dout0_78) AT=125.025n

.meas tran vdout0_79ck240 FIND v(dout0_79) AT=125.025n

.meas tran vdout0_80ck240 FIND v(dout0_80) AT=125.025n

.meas tran vdout0_81ck240 FIND v(dout0_81) AT=125.025n

.meas tran vdout0_82ck240 FIND v(dout0_82) AT=125.025n

.meas tran vdout0_83ck240 FIND v(dout0_83) AT=125.025n

.meas tran vdout0_84ck240 FIND v(dout0_84) AT=125.025n

.meas tran vdout0_85ck240 FIND v(dout0_85) AT=125.025n

.meas tran vdout0_86ck240 FIND v(dout0_86) AT=125.025n

.meas tran vdout0_87ck240 FIND v(dout0_87) AT=125.025n

.meas tran vdout0_88ck240 FIND v(dout0_88) AT=125.025n

.meas tran vdout0_89ck240 FIND v(dout0_89) AT=125.025n

.meas tran vdout0_90ck240 FIND v(dout0_90) AT=125.025n

.meas tran vdout0_91ck240 FIND v(dout0_91) AT=125.025n

.meas tran vdout0_92ck240 FIND v(dout0_92) AT=125.025n

.meas tran vdout0_93ck240 FIND v(dout0_93) AT=125.025n

.meas tran vdout0_94ck240 FIND v(dout0_94) AT=125.025n

.meas tran vdout0_95ck240 FIND v(dout0_95) AT=125.025n

.meas tran vdout0_96ck240 FIND v(dout0_96) AT=125.025n

.meas tran vdout0_97ck240 FIND v(dout0_97) AT=125.025n

.meas tran vdout0_98ck240 FIND v(dout0_98) AT=125.025n

.meas tran vdout0_99ck240 FIND v(dout0_99) AT=125.025n

.meas tran vdout0_100ck240 FIND v(dout0_100) AT=125.025n

.meas tran vdout0_101ck240 FIND v(dout0_101) AT=125.025n

.meas tran vdout0_102ck240 FIND v(dout0_102) AT=125.025n

.meas tran vdout0_103ck240 FIND v(dout0_103) AT=125.025n

.meas tran vdout0_104ck240 FIND v(dout0_104) AT=125.025n

.meas tran vdout0_105ck240 FIND v(dout0_105) AT=125.025n

.meas tran vdout0_106ck240 FIND v(dout0_106) AT=125.025n

.meas tran vdout0_107ck240 FIND v(dout0_107) AT=125.025n

.meas tran vdout0_108ck240 FIND v(dout0_108) AT=125.025n

.meas tran vdout0_109ck240 FIND v(dout0_109) AT=125.025n

.meas tran vdout0_110ck240 FIND v(dout0_110) AT=125.025n

.meas tran vdout0_111ck240 FIND v(dout0_111) AT=125.025n

.meas tran vdout0_112ck240 FIND v(dout0_112) AT=125.025n

.meas tran vdout0_113ck240 FIND v(dout0_113) AT=125.025n

.meas tran vdout0_114ck240 FIND v(dout0_114) AT=125.025n

.meas tran vdout0_115ck240 FIND v(dout0_115) AT=125.025n

.meas tran vdout0_116ck240 FIND v(dout0_116) AT=125.025n

.meas tran vdout0_117ck240 FIND v(dout0_117) AT=125.025n

.meas tran vdout0_118ck240 FIND v(dout0_118) AT=125.025n

.meas tran vdout0_119ck240 FIND v(dout0_119) AT=125.025n

.meas tran vdout0_120ck240 FIND v(dout0_120) AT=125.025n

.meas tran vdout0_121ck240 FIND v(dout0_121) AT=125.025n

.meas tran vdout0_122ck240 FIND v(dout0_122) AT=125.025n

.meas tran vdout0_123ck240 FIND v(dout0_123) AT=125.025n

.meas tran vdout0_124ck240 FIND v(dout0_124) AT=125.025n

.meas tran vdout0_125ck240 FIND v(dout0_125) AT=125.025n

.meas tran vdout0_126ck240 FIND v(dout0_126) AT=125.025n

.meas tran vdout0_127ck240 FIND v(dout0_127) AT=125.025n

.meas tran vdout0_128ck240 FIND v(dout0_128) AT=125.025n

.meas tran vdout0_129ck240 FIND v(dout0_129) AT=125.025n

.meas tran vdout0_130ck240 FIND v(dout0_130) AT=125.025n

.meas tran vdout0_131ck240 FIND v(dout0_131) AT=125.025n

.meas tran vdout0_132ck240 FIND v(dout0_132) AT=125.025n

.meas tran vdout0_133ck240 FIND v(dout0_133) AT=125.025n

.meas tran vdout0_134ck240 FIND v(dout0_134) AT=125.025n

.meas tran vdout0_135ck240 FIND v(dout0_135) AT=125.025n

.meas tran vdout0_136ck240 FIND v(dout0_136) AT=125.025n

.meas tran vdout0_137ck240 FIND v(dout0_137) AT=125.025n

.meas tran vdout0_138ck240 FIND v(dout0_138) AT=125.025n

.meas tran vdout0_139ck240 FIND v(dout0_139) AT=125.025n

.meas tran vdout0_140ck240 FIND v(dout0_140) AT=125.025n

.meas tran vdout0_141ck240 FIND v(dout0_141) AT=125.025n

.meas tran vdout0_142ck240 FIND v(dout0_142) AT=125.025n

.meas tran vdout0_143ck240 FIND v(dout0_143) AT=125.025n

.meas tran vdout0_144ck240 FIND v(dout0_144) AT=125.025n

.meas tran vdout0_145ck240 FIND v(dout0_145) AT=125.025n

.meas tran vdout0_146ck240 FIND v(dout0_146) AT=125.025n

.meas tran vdout0_147ck240 FIND v(dout0_147) AT=125.025n

.meas tran vdout0_148ck240 FIND v(dout0_148) AT=125.025n

.meas tran vdout0_149ck240 FIND v(dout0_149) AT=125.025n

.meas tran vdout0_0ck250 FIND v(dout0_0) AT=130.025n

.meas tran vdout0_1ck250 FIND v(dout0_1) AT=130.025n

.meas tran vdout0_2ck250 FIND v(dout0_2) AT=130.025n

.meas tran vdout0_3ck250 FIND v(dout0_3) AT=130.025n

.meas tran vdout0_4ck250 FIND v(dout0_4) AT=130.025n

.meas tran vdout0_5ck250 FIND v(dout0_5) AT=130.025n

.meas tran vdout0_6ck250 FIND v(dout0_6) AT=130.025n

.meas tran vdout0_7ck250 FIND v(dout0_7) AT=130.025n

.meas tran vdout0_8ck250 FIND v(dout0_8) AT=130.025n

.meas tran vdout0_9ck250 FIND v(dout0_9) AT=130.025n

.meas tran vdout0_10ck250 FIND v(dout0_10) AT=130.025n

.meas tran vdout0_11ck250 FIND v(dout0_11) AT=130.025n

.meas tran vdout0_12ck250 FIND v(dout0_12) AT=130.025n

.meas tran vdout0_13ck250 FIND v(dout0_13) AT=130.025n

.meas tran vdout0_14ck250 FIND v(dout0_14) AT=130.025n

.meas tran vdout0_15ck250 FIND v(dout0_15) AT=130.025n

.meas tran vdout0_16ck250 FIND v(dout0_16) AT=130.025n

.meas tran vdout0_17ck250 FIND v(dout0_17) AT=130.025n

.meas tran vdout0_18ck250 FIND v(dout0_18) AT=130.025n

.meas tran vdout0_19ck250 FIND v(dout0_19) AT=130.025n

.meas tran vdout0_20ck250 FIND v(dout0_20) AT=130.025n

.meas tran vdout0_21ck250 FIND v(dout0_21) AT=130.025n

.meas tran vdout0_22ck250 FIND v(dout0_22) AT=130.025n

.meas tran vdout0_23ck250 FIND v(dout0_23) AT=130.025n

.meas tran vdout0_24ck250 FIND v(dout0_24) AT=130.025n

.meas tran vdout0_25ck250 FIND v(dout0_25) AT=130.025n

.meas tran vdout0_26ck250 FIND v(dout0_26) AT=130.025n

.meas tran vdout0_27ck250 FIND v(dout0_27) AT=130.025n

.meas tran vdout0_28ck250 FIND v(dout0_28) AT=130.025n

.meas tran vdout0_29ck250 FIND v(dout0_29) AT=130.025n

.meas tran vdout0_30ck250 FIND v(dout0_30) AT=130.025n

.meas tran vdout0_31ck250 FIND v(dout0_31) AT=130.025n

.meas tran vdout0_32ck250 FIND v(dout0_32) AT=130.025n

.meas tran vdout0_33ck250 FIND v(dout0_33) AT=130.025n

.meas tran vdout0_34ck250 FIND v(dout0_34) AT=130.025n

.meas tran vdout0_35ck250 FIND v(dout0_35) AT=130.025n

.meas tran vdout0_36ck250 FIND v(dout0_36) AT=130.025n

.meas tran vdout0_37ck250 FIND v(dout0_37) AT=130.025n

.meas tran vdout0_38ck250 FIND v(dout0_38) AT=130.025n

.meas tran vdout0_39ck250 FIND v(dout0_39) AT=130.025n

.meas tran vdout0_40ck250 FIND v(dout0_40) AT=130.025n

.meas tran vdout0_41ck250 FIND v(dout0_41) AT=130.025n

.meas tran vdout0_42ck250 FIND v(dout0_42) AT=130.025n

.meas tran vdout0_43ck250 FIND v(dout0_43) AT=130.025n

.meas tran vdout0_44ck250 FIND v(dout0_44) AT=130.025n

.meas tran vdout0_45ck250 FIND v(dout0_45) AT=130.025n

.meas tran vdout0_46ck250 FIND v(dout0_46) AT=130.025n

.meas tran vdout0_47ck250 FIND v(dout0_47) AT=130.025n

.meas tran vdout0_48ck250 FIND v(dout0_48) AT=130.025n

.meas tran vdout0_49ck250 FIND v(dout0_49) AT=130.025n

.meas tran vdout0_50ck250 FIND v(dout0_50) AT=130.025n

.meas tran vdout0_51ck250 FIND v(dout0_51) AT=130.025n

.meas tran vdout0_52ck250 FIND v(dout0_52) AT=130.025n

.meas tran vdout0_53ck250 FIND v(dout0_53) AT=130.025n

.meas tran vdout0_54ck250 FIND v(dout0_54) AT=130.025n

.meas tran vdout0_55ck250 FIND v(dout0_55) AT=130.025n

.meas tran vdout0_56ck250 FIND v(dout0_56) AT=130.025n

.meas tran vdout0_57ck250 FIND v(dout0_57) AT=130.025n

.meas tran vdout0_58ck250 FIND v(dout0_58) AT=130.025n

.meas tran vdout0_59ck250 FIND v(dout0_59) AT=130.025n

.meas tran vdout0_60ck250 FIND v(dout0_60) AT=130.025n

.meas tran vdout0_61ck250 FIND v(dout0_61) AT=130.025n

.meas tran vdout0_62ck250 FIND v(dout0_62) AT=130.025n

.meas tran vdout0_63ck250 FIND v(dout0_63) AT=130.025n

.meas tran vdout0_64ck250 FIND v(dout0_64) AT=130.025n

.meas tran vdout0_65ck250 FIND v(dout0_65) AT=130.025n

.meas tran vdout0_66ck250 FIND v(dout0_66) AT=130.025n

.meas tran vdout0_67ck250 FIND v(dout0_67) AT=130.025n

.meas tran vdout0_68ck250 FIND v(dout0_68) AT=130.025n

.meas tran vdout0_69ck250 FIND v(dout0_69) AT=130.025n

.meas tran vdout0_70ck250 FIND v(dout0_70) AT=130.025n

.meas tran vdout0_71ck250 FIND v(dout0_71) AT=130.025n

.meas tran vdout0_72ck250 FIND v(dout0_72) AT=130.025n

.meas tran vdout0_73ck250 FIND v(dout0_73) AT=130.025n

.meas tran vdout0_74ck250 FIND v(dout0_74) AT=130.025n

.meas tran vdout0_75ck250 FIND v(dout0_75) AT=130.025n

.meas tran vdout0_76ck250 FIND v(dout0_76) AT=130.025n

.meas tran vdout0_77ck250 FIND v(dout0_77) AT=130.025n

.meas tran vdout0_78ck250 FIND v(dout0_78) AT=130.025n

.meas tran vdout0_79ck250 FIND v(dout0_79) AT=130.025n

.meas tran vdout0_80ck250 FIND v(dout0_80) AT=130.025n

.meas tran vdout0_81ck250 FIND v(dout0_81) AT=130.025n

.meas tran vdout0_82ck250 FIND v(dout0_82) AT=130.025n

.meas tran vdout0_83ck250 FIND v(dout0_83) AT=130.025n

.meas tran vdout0_84ck250 FIND v(dout0_84) AT=130.025n

.meas tran vdout0_85ck250 FIND v(dout0_85) AT=130.025n

.meas tran vdout0_86ck250 FIND v(dout0_86) AT=130.025n

.meas tran vdout0_87ck250 FIND v(dout0_87) AT=130.025n

.meas tran vdout0_88ck250 FIND v(dout0_88) AT=130.025n

.meas tran vdout0_89ck250 FIND v(dout0_89) AT=130.025n

.meas tran vdout0_90ck250 FIND v(dout0_90) AT=130.025n

.meas tran vdout0_91ck250 FIND v(dout0_91) AT=130.025n

.meas tran vdout0_92ck250 FIND v(dout0_92) AT=130.025n

.meas tran vdout0_93ck250 FIND v(dout0_93) AT=130.025n

.meas tran vdout0_94ck250 FIND v(dout0_94) AT=130.025n

.meas tran vdout0_95ck250 FIND v(dout0_95) AT=130.025n

.meas tran vdout0_96ck250 FIND v(dout0_96) AT=130.025n

.meas tran vdout0_97ck250 FIND v(dout0_97) AT=130.025n

.meas tran vdout0_98ck250 FIND v(dout0_98) AT=130.025n

.meas tran vdout0_99ck250 FIND v(dout0_99) AT=130.025n

.meas tran vdout0_100ck250 FIND v(dout0_100) AT=130.025n

.meas tran vdout0_101ck250 FIND v(dout0_101) AT=130.025n

.meas tran vdout0_102ck250 FIND v(dout0_102) AT=130.025n

.meas tran vdout0_103ck250 FIND v(dout0_103) AT=130.025n

.meas tran vdout0_104ck250 FIND v(dout0_104) AT=130.025n

.meas tran vdout0_105ck250 FIND v(dout0_105) AT=130.025n

.meas tran vdout0_106ck250 FIND v(dout0_106) AT=130.025n

.meas tran vdout0_107ck250 FIND v(dout0_107) AT=130.025n

.meas tran vdout0_108ck250 FIND v(dout0_108) AT=130.025n

.meas tran vdout0_109ck250 FIND v(dout0_109) AT=130.025n

.meas tran vdout0_110ck250 FIND v(dout0_110) AT=130.025n

.meas tran vdout0_111ck250 FIND v(dout0_111) AT=130.025n

.meas tran vdout0_112ck250 FIND v(dout0_112) AT=130.025n

.meas tran vdout0_113ck250 FIND v(dout0_113) AT=130.025n

.meas tran vdout0_114ck250 FIND v(dout0_114) AT=130.025n

.meas tran vdout0_115ck250 FIND v(dout0_115) AT=130.025n

.meas tran vdout0_116ck250 FIND v(dout0_116) AT=130.025n

.meas tran vdout0_117ck250 FIND v(dout0_117) AT=130.025n

.meas tran vdout0_118ck250 FIND v(dout0_118) AT=130.025n

.meas tran vdout0_119ck250 FIND v(dout0_119) AT=130.025n

.meas tran vdout0_120ck250 FIND v(dout0_120) AT=130.025n

.meas tran vdout0_121ck250 FIND v(dout0_121) AT=130.025n

.meas tran vdout0_122ck250 FIND v(dout0_122) AT=130.025n

.meas tran vdout0_123ck250 FIND v(dout0_123) AT=130.025n

.meas tran vdout0_124ck250 FIND v(dout0_124) AT=130.025n

.meas tran vdout0_125ck250 FIND v(dout0_125) AT=130.025n

.meas tran vdout0_126ck250 FIND v(dout0_126) AT=130.025n

.meas tran vdout0_127ck250 FIND v(dout0_127) AT=130.025n

.meas tran vdout0_128ck250 FIND v(dout0_128) AT=130.025n

.meas tran vdout0_129ck250 FIND v(dout0_129) AT=130.025n

.meas tran vdout0_130ck250 FIND v(dout0_130) AT=130.025n

.meas tran vdout0_131ck250 FIND v(dout0_131) AT=130.025n

.meas tran vdout0_132ck250 FIND v(dout0_132) AT=130.025n

.meas tran vdout0_133ck250 FIND v(dout0_133) AT=130.025n

.meas tran vdout0_134ck250 FIND v(dout0_134) AT=130.025n

.meas tran vdout0_135ck250 FIND v(dout0_135) AT=130.025n

.meas tran vdout0_136ck250 FIND v(dout0_136) AT=130.025n

.meas tran vdout0_137ck250 FIND v(dout0_137) AT=130.025n

.meas tran vdout0_138ck250 FIND v(dout0_138) AT=130.025n

.meas tran vdout0_139ck250 FIND v(dout0_139) AT=130.025n

.meas tran vdout0_140ck250 FIND v(dout0_140) AT=130.025n

.meas tran vdout0_141ck250 FIND v(dout0_141) AT=130.025n

.meas tran vdout0_142ck250 FIND v(dout0_142) AT=130.025n

.meas tran vdout0_143ck250 FIND v(dout0_143) AT=130.025n

.meas tran vdout0_144ck250 FIND v(dout0_144) AT=130.025n

.meas tran vdout0_145ck250 FIND v(dout0_145) AT=130.025n

.meas tran vdout0_146ck250 FIND v(dout0_146) AT=130.025n

.meas tran vdout0_147ck250 FIND v(dout0_147) AT=130.025n

.meas tran vdout0_148ck250 FIND v(dout0_148) AT=130.025n

.meas tran vdout0_149ck250 FIND v(dout0_149) AT=130.025n

.meas tran vdout0_0ck260 FIND v(dout0_0) AT=135.025n

.meas tran vdout0_1ck260 FIND v(dout0_1) AT=135.025n

.meas tran vdout0_2ck260 FIND v(dout0_2) AT=135.025n

.meas tran vdout0_3ck260 FIND v(dout0_3) AT=135.025n

.meas tran vdout0_4ck260 FIND v(dout0_4) AT=135.025n

.meas tran vdout0_5ck260 FIND v(dout0_5) AT=135.025n

.meas tran vdout0_6ck260 FIND v(dout0_6) AT=135.025n

.meas tran vdout0_7ck260 FIND v(dout0_7) AT=135.025n

.meas tran vdout0_8ck260 FIND v(dout0_8) AT=135.025n

.meas tran vdout0_9ck260 FIND v(dout0_9) AT=135.025n

.meas tran vdout0_10ck260 FIND v(dout0_10) AT=135.025n

.meas tran vdout0_11ck260 FIND v(dout0_11) AT=135.025n

.meas tran vdout0_12ck260 FIND v(dout0_12) AT=135.025n

.meas tran vdout0_13ck260 FIND v(dout0_13) AT=135.025n

.meas tran vdout0_14ck260 FIND v(dout0_14) AT=135.025n

.meas tran vdout0_15ck260 FIND v(dout0_15) AT=135.025n

.meas tran vdout0_16ck260 FIND v(dout0_16) AT=135.025n

.meas tran vdout0_17ck260 FIND v(dout0_17) AT=135.025n

.meas tran vdout0_18ck260 FIND v(dout0_18) AT=135.025n

.meas tran vdout0_19ck260 FIND v(dout0_19) AT=135.025n

.meas tran vdout0_20ck260 FIND v(dout0_20) AT=135.025n

.meas tran vdout0_21ck260 FIND v(dout0_21) AT=135.025n

.meas tran vdout0_22ck260 FIND v(dout0_22) AT=135.025n

.meas tran vdout0_23ck260 FIND v(dout0_23) AT=135.025n

.meas tran vdout0_24ck260 FIND v(dout0_24) AT=135.025n

.meas tran vdout0_25ck260 FIND v(dout0_25) AT=135.025n

.meas tran vdout0_26ck260 FIND v(dout0_26) AT=135.025n

.meas tran vdout0_27ck260 FIND v(dout0_27) AT=135.025n

.meas tran vdout0_28ck260 FIND v(dout0_28) AT=135.025n

.meas tran vdout0_29ck260 FIND v(dout0_29) AT=135.025n

.meas tran vdout0_30ck260 FIND v(dout0_30) AT=135.025n

.meas tran vdout0_31ck260 FIND v(dout0_31) AT=135.025n

.meas tran vdout0_32ck260 FIND v(dout0_32) AT=135.025n

.meas tran vdout0_33ck260 FIND v(dout0_33) AT=135.025n

.meas tran vdout0_34ck260 FIND v(dout0_34) AT=135.025n

.meas tran vdout0_35ck260 FIND v(dout0_35) AT=135.025n

.meas tran vdout0_36ck260 FIND v(dout0_36) AT=135.025n

.meas tran vdout0_37ck260 FIND v(dout0_37) AT=135.025n

.meas tran vdout0_38ck260 FIND v(dout0_38) AT=135.025n

.meas tran vdout0_39ck260 FIND v(dout0_39) AT=135.025n

.meas tran vdout0_40ck260 FIND v(dout0_40) AT=135.025n

.meas tran vdout0_41ck260 FIND v(dout0_41) AT=135.025n

.meas tran vdout0_42ck260 FIND v(dout0_42) AT=135.025n

.meas tran vdout0_43ck260 FIND v(dout0_43) AT=135.025n

.meas tran vdout0_44ck260 FIND v(dout0_44) AT=135.025n

.meas tran vdout0_45ck260 FIND v(dout0_45) AT=135.025n

.meas tran vdout0_46ck260 FIND v(dout0_46) AT=135.025n

.meas tran vdout0_47ck260 FIND v(dout0_47) AT=135.025n

.meas tran vdout0_48ck260 FIND v(dout0_48) AT=135.025n

.meas tran vdout0_49ck260 FIND v(dout0_49) AT=135.025n

.meas tran vdout0_50ck260 FIND v(dout0_50) AT=135.025n

.meas tran vdout0_51ck260 FIND v(dout0_51) AT=135.025n

.meas tran vdout0_52ck260 FIND v(dout0_52) AT=135.025n

.meas tran vdout0_53ck260 FIND v(dout0_53) AT=135.025n

.meas tran vdout0_54ck260 FIND v(dout0_54) AT=135.025n

.meas tran vdout0_55ck260 FIND v(dout0_55) AT=135.025n

.meas tran vdout0_56ck260 FIND v(dout0_56) AT=135.025n

.meas tran vdout0_57ck260 FIND v(dout0_57) AT=135.025n

.meas tran vdout0_58ck260 FIND v(dout0_58) AT=135.025n

.meas tran vdout0_59ck260 FIND v(dout0_59) AT=135.025n

.meas tran vdout0_60ck260 FIND v(dout0_60) AT=135.025n

.meas tran vdout0_61ck260 FIND v(dout0_61) AT=135.025n

.meas tran vdout0_62ck260 FIND v(dout0_62) AT=135.025n

.meas tran vdout0_63ck260 FIND v(dout0_63) AT=135.025n

.meas tran vdout0_64ck260 FIND v(dout0_64) AT=135.025n

.meas tran vdout0_65ck260 FIND v(dout0_65) AT=135.025n

.meas tran vdout0_66ck260 FIND v(dout0_66) AT=135.025n

.meas tran vdout0_67ck260 FIND v(dout0_67) AT=135.025n

.meas tran vdout0_68ck260 FIND v(dout0_68) AT=135.025n

.meas tran vdout0_69ck260 FIND v(dout0_69) AT=135.025n

.meas tran vdout0_70ck260 FIND v(dout0_70) AT=135.025n

.meas tran vdout0_71ck260 FIND v(dout0_71) AT=135.025n

.meas tran vdout0_72ck260 FIND v(dout0_72) AT=135.025n

.meas tran vdout0_73ck260 FIND v(dout0_73) AT=135.025n

.meas tran vdout0_74ck260 FIND v(dout0_74) AT=135.025n

.meas tran vdout0_75ck260 FIND v(dout0_75) AT=135.025n

.meas tran vdout0_76ck260 FIND v(dout0_76) AT=135.025n

.meas tran vdout0_77ck260 FIND v(dout0_77) AT=135.025n

.meas tran vdout0_78ck260 FIND v(dout0_78) AT=135.025n

.meas tran vdout0_79ck260 FIND v(dout0_79) AT=135.025n

.meas tran vdout0_80ck260 FIND v(dout0_80) AT=135.025n

.meas tran vdout0_81ck260 FIND v(dout0_81) AT=135.025n

.meas tran vdout0_82ck260 FIND v(dout0_82) AT=135.025n

.meas tran vdout0_83ck260 FIND v(dout0_83) AT=135.025n

.meas tran vdout0_84ck260 FIND v(dout0_84) AT=135.025n

.meas tran vdout0_85ck260 FIND v(dout0_85) AT=135.025n

.meas tran vdout0_86ck260 FIND v(dout0_86) AT=135.025n

.meas tran vdout0_87ck260 FIND v(dout0_87) AT=135.025n

.meas tran vdout0_88ck260 FIND v(dout0_88) AT=135.025n

.meas tran vdout0_89ck260 FIND v(dout0_89) AT=135.025n

.meas tran vdout0_90ck260 FIND v(dout0_90) AT=135.025n

.meas tran vdout0_91ck260 FIND v(dout0_91) AT=135.025n

.meas tran vdout0_92ck260 FIND v(dout0_92) AT=135.025n

.meas tran vdout0_93ck260 FIND v(dout0_93) AT=135.025n

.meas tran vdout0_94ck260 FIND v(dout0_94) AT=135.025n

.meas tran vdout0_95ck260 FIND v(dout0_95) AT=135.025n

.meas tran vdout0_96ck260 FIND v(dout0_96) AT=135.025n

.meas tran vdout0_97ck260 FIND v(dout0_97) AT=135.025n

.meas tran vdout0_98ck260 FIND v(dout0_98) AT=135.025n

.meas tran vdout0_99ck260 FIND v(dout0_99) AT=135.025n

.meas tran vdout0_100ck260 FIND v(dout0_100) AT=135.025n

.meas tran vdout0_101ck260 FIND v(dout0_101) AT=135.025n

.meas tran vdout0_102ck260 FIND v(dout0_102) AT=135.025n

.meas tran vdout0_103ck260 FIND v(dout0_103) AT=135.025n

.meas tran vdout0_104ck260 FIND v(dout0_104) AT=135.025n

.meas tran vdout0_105ck260 FIND v(dout0_105) AT=135.025n

.meas tran vdout0_106ck260 FIND v(dout0_106) AT=135.025n

.meas tran vdout0_107ck260 FIND v(dout0_107) AT=135.025n

.meas tran vdout0_108ck260 FIND v(dout0_108) AT=135.025n

.meas tran vdout0_109ck260 FIND v(dout0_109) AT=135.025n

.meas tran vdout0_110ck260 FIND v(dout0_110) AT=135.025n

.meas tran vdout0_111ck260 FIND v(dout0_111) AT=135.025n

.meas tran vdout0_112ck260 FIND v(dout0_112) AT=135.025n

.meas tran vdout0_113ck260 FIND v(dout0_113) AT=135.025n

.meas tran vdout0_114ck260 FIND v(dout0_114) AT=135.025n

.meas tran vdout0_115ck260 FIND v(dout0_115) AT=135.025n

.meas tran vdout0_116ck260 FIND v(dout0_116) AT=135.025n

.meas tran vdout0_117ck260 FIND v(dout0_117) AT=135.025n

.meas tran vdout0_118ck260 FIND v(dout0_118) AT=135.025n

.meas tran vdout0_119ck260 FIND v(dout0_119) AT=135.025n

.meas tran vdout0_120ck260 FIND v(dout0_120) AT=135.025n

.meas tran vdout0_121ck260 FIND v(dout0_121) AT=135.025n

.meas tran vdout0_122ck260 FIND v(dout0_122) AT=135.025n

.meas tran vdout0_123ck260 FIND v(dout0_123) AT=135.025n

.meas tran vdout0_124ck260 FIND v(dout0_124) AT=135.025n

.meas tran vdout0_125ck260 FIND v(dout0_125) AT=135.025n

.meas tran vdout0_126ck260 FIND v(dout0_126) AT=135.025n

.meas tran vdout0_127ck260 FIND v(dout0_127) AT=135.025n

.meas tran vdout0_128ck260 FIND v(dout0_128) AT=135.025n

.meas tran vdout0_129ck260 FIND v(dout0_129) AT=135.025n

.meas tran vdout0_130ck260 FIND v(dout0_130) AT=135.025n

.meas tran vdout0_131ck260 FIND v(dout0_131) AT=135.025n

.meas tran vdout0_132ck260 FIND v(dout0_132) AT=135.025n

.meas tran vdout0_133ck260 FIND v(dout0_133) AT=135.025n

.meas tran vdout0_134ck260 FIND v(dout0_134) AT=135.025n

.meas tran vdout0_135ck260 FIND v(dout0_135) AT=135.025n

.meas tran vdout0_136ck260 FIND v(dout0_136) AT=135.025n

.meas tran vdout0_137ck260 FIND v(dout0_137) AT=135.025n

.meas tran vdout0_138ck260 FIND v(dout0_138) AT=135.025n

.meas tran vdout0_139ck260 FIND v(dout0_139) AT=135.025n

.meas tran vdout0_140ck260 FIND v(dout0_140) AT=135.025n

.meas tran vdout0_141ck260 FIND v(dout0_141) AT=135.025n

.meas tran vdout0_142ck260 FIND v(dout0_142) AT=135.025n

.meas tran vdout0_143ck260 FIND v(dout0_143) AT=135.025n

.meas tran vdout0_144ck260 FIND v(dout0_144) AT=135.025n

.meas tran vdout0_145ck260 FIND v(dout0_145) AT=135.025n

.meas tran vdout0_146ck260 FIND v(dout0_146) AT=135.025n

.meas tran vdout0_147ck260 FIND v(dout0_147) AT=135.025n

.meas tran vdout0_148ck260 FIND v(dout0_148) AT=135.025n

.meas tran vdout0_149ck260 FIND v(dout0_149) AT=135.025n

.meas tran vdout0_0ck290 FIND v(dout0_0) AT=150.025n

.meas tran vdout0_1ck290 FIND v(dout0_1) AT=150.025n

.meas tran vdout0_2ck290 FIND v(dout0_2) AT=150.025n

.meas tran vdout0_3ck290 FIND v(dout0_3) AT=150.025n

.meas tran vdout0_4ck290 FIND v(dout0_4) AT=150.025n

.meas tran vdout0_5ck290 FIND v(dout0_5) AT=150.025n

.meas tran vdout0_6ck290 FIND v(dout0_6) AT=150.025n

.meas tran vdout0_7ck290 FIND v(dout0_7) AT=150.025n

.meas tran vdout0_8ck290 FIND v(dout0_8) AT=150.025n

.meas tran vdout0_9ck290 FIND v(dout0_9) AT=150.025n

.meas tran vdout0_10ck290 FIND v(dout0_10) AT=150.025n

.meas tran vdout0_11ck290 FIND v(dout0_11) AT=150.025n

.meas tran vdout0_12ck290 FIND v(dout0_12) AT=150.025n

.meas tran vdout0_13ck290 FIND v(dout0_13) AT=150.025n

.meas tran vdout0_14ck290 FIND v(dout0_14) AT=150.025n

.meas tran vdout0_15ck290 FIND v(dout0_15) AT=150.025n

.meas tran vdout0_16ck290 FIND v(dout0_16) AT=150.025n

.meas tran vdout0_17ck290 FIND v(dout0_17) AT=150.025n

.meas tran vdout0_18ck290 FIND v(dout0_18) AT=150.025n

.meas tran vdout0_19ck290 FIND v(dout0_19) AT=150.025n

.meas tran vdout0_20ck290 FIND v(dout0_20) AT=150.025n

.meas tran vdout0_21ck290 FIND v(dout0_21) AT=150.025n

.meas tran vdout0_22ck290 FIND v(dout0_22) AT=150.025n

.meas tran vdout0_23ck290 FIND v(dout0_23) AT=150.025n

.meas tran vdout0_24ck290 FIND v(dout0_24) AT=150.025n

.meas tran vdout0_25ck290 FIND v(dout0_25) AT=150.025n

.meas tran vdout0_26ck290 FIND v(dout0_26) AT=150.025n

.meas tran vdout0_27ck290 FIND v(dout0_27) AT=150.025n

.meas tran vdout0_28ck290 FIND v(dout0_28) AT=150.025n

.meas tran vdout0_29ck290 FIND v(dout0_29) AT=150.025n

.meas tran vdout0_30ck290 FIND v(dout0_30) AT=150.025n

.meas tran vdout0_31ck290 FIND v(dout0_31) AT=150.025n

.meas tran vdout0_32ck290 FIND v(dout0_32) AT=150.025n

.meas tran vdout0_33ck290 FIND v(dout0_33) AT=150.025n

.meas tran vdout0_34ck290 FIND v(dout0_34) AT=150.025n

.meas tran vdout0_35ck290 FIND v(dout0_35) AT=150.025n

.meas tran vdout0_36ck290 FIND v(dout0_36) AT=150.025n

.meas tran vdout0_37ck290 FIND v(dout0_37) AT=150.025n

.meas tran vdout0_38ck290 FIND v(dout0_38) AT=150.025n

.meas tran vdout0_39ck290 FIND v(dout0_39) AT=150.025n

.meas tran vdout0_40ck290 FIND v(dout0_40) AT=150.025n

.meas tran vdout0_41ck290 FIND v(dout0_41) AT=150.025n

.meas tran vdout0_42ck290 FIND v(dout0_42) AT=150.025n

.meas tran vdout0_43ck290 FIND v(dout0_43) AT=150.025n

.meas tran vdout0_44ck290 FIND v(dout0_44) AT=150.025n

.meas tran vdout0_45ck290 FIND v(dout0_45) AT=150.025n

.meas tran vdout0_46ck290 FIND v(dout0_46) AT=150.025n

.meas tran vdout0_47ck290 FIND v(dout0_47) AT=150.025n

.meas tran vdout0_48ck290 FIND v(dout0_48) AT=150.025n

.meas tran vdout0_49ck290 FIND v(dout0_49) AT=150.025n

.meas tran vdout0_50ck290 FIND v(dout0_50) AT=150.025n

.meas tran vdout0_51ck290 FIND v(dout0_51) AT=150.025n

.meas tran vdout0_52ck290 FIND v(dout0_52) AT=150.025n

.meas tran vdout0_53ck290 FIND v(dout0_53) AT=150.025n

.meas tran vdout0_54ck290 FIND v(dout0_54) AT=150.025n

.meas tran vdout0_55ck290 FIND v(dout0_55) AT=150.025n

.meas tran vdout0_56ck290 FIND v(dout0_56) AT=150.025n

.meas tran vdout0_57ck290 FIND v(dout0_57) AT=150.025n

.meas tran vdout0_58ck290 FIND v(dout0_58) AT=150.025n

.meas tran vdout0_59ck290 FIND v(dout0_59) AT=150.025n

.meas tran vdout0_60ck290 FIND v(dout0_60) AT=150.025n

.meas tran vdout0_61ck290 FIND v(dout0_61) AT=150.025n

.meas tran vdout0_62ck290 FIND v(dout0_62) AT=150.025n

.meas tran vdout0_63ck290 FIND v(dout0_63) AT=150.025n

.meas tran vdout0_64ck290 FIND v(dout0_64) AT=150.025n

.meas tran vdout0_65ck290 FIND v(dout0_65) AT=150.025n

.meas tran vdout0_66ck290 FIND v(dout0_66) AT=150.025n

.meas tran vdout0_67ck290 FIND v(dout0_67) AT=150.025n

.meas tran vdout0_68ck290 FIND v(dout0_68) AT=150.025n

.meas tran vdout0_69ck290 FIND v(dout0_69) AT=150.025n

.meas tran vdout0_70ck290 FIND v(dout0_70) AT=150.025n

.meas tran vdout0_71ck290 FIND v(dout0_71) AT=150.025n

.meas tran vdout0_72ck290 FIND v(dout0_72) AT=150.025n

.meas tran vdout0_73ck290 FIND v(dout0_73) AT=150.025n

.meas tran vdout0_74ck290 FIND v(dout0_74) AT=150.025n

.meas tran vdout0_75ck290 FIND v(dout0_75) AT=150.025n

.meas tran vdout0_76ck290 FIND v(dout0_76) AT=150.025n

.meas tran vdout0_77ck290 FIND v(dout0_77) AT=150.025n

.meas tran vdout0_78ck290 FIND v(dout0_78) AT=150.025n

.meas tran vdout0_79ck290 FIND v(dout0_79) AT=150.025n

.meas tran vdout0_80ck290 FIND v(dout0_80) AT=150.025n

.meas tran vdout0_81ck290 FIND v(dout0_81) AT=150.025n

.meas tran vdout0_82ck290 FIND v(dout0_82) AT=150.025n

.meas tran vdout0_83ck290 FIND v(dout0_83) AT=150.025n

.meas tran vdout0_84ck290 FIND v(dout0_84) AT=150.025n

.meas tran vdout0_85ck290 FIND v(dout0_85) AT=150.025n

.meas tran vdout0_86ck290 FIND v(dout0_86) AT=150.025n

.meas tran vdout0_87ck290 FIND v(dout0_87) AT=150.025n

.meas tran vdout0_88ck290 FIND v(dout0_88) AT=150.025n

.meas tran vdout0_89ck290 FIND v(dout0_89) AT=150.025n

.meas tran vdout0_90ck290 FIND v(dout0_90) AT=150.025n

.meas tran vdout0_91ck290 FIND v(dout0_91) AT=150.025n

.meas tran vdout0_92ck290 FIND v(dout0_92) AT=150.025n

.meas tran vdout0_93ck290 FIND v(dout0_93) AT=150.025n

.meas tran vdout0_94ck290 FIND v(dout0_94) AT=150.025n

.meas tran vdout0_95ck290 FIND v(dout0_95) AT=150.025n

.meas tran vdout0_96ck290 FIND v(dout0_96) AT=150.025n

.meas tran vdout0_97ck290 FIND v(dout0_97) AT=150.025n

.meas tran vdout0_98ck290 FIND v(dout0_98) AT=150.025n

.meas tran vdout0_99ck290 FIND v(dout0_99) AT=150.025n

.meas tran vdout0_100ck290 FIND v(dout0_100) AT=150.025n

.meas tran vdout0_101ck290 FIND v(dout0_101) AT=150.025n

.meas tran vdout0_102ck290 FIND v(dout0_102) AT=150.025n

.meas tran vdout0_103ck290 FIND v(dout0_103) AT=150.025n

.meas tran vdout0_104ck290 FIND v(dout0_104) AT=150.025n

.meas tran vdout0_105ck290 FIND v(dout0_105) AT=150.025n

.meas tran vdout0_106ck290 FIND v(dout0_106) AT=150.025n

.meas tran vdout0_107ck290 FIND v(dout0_107) AT=150.025n

.meas tran vdout0_108ck290 FIND v(dout0_108) AT=150.025n

.meas tran vdout0_109ck290 FIND v(dout0_109) AT=150.025n

.meas tran vdout0_110ck290 FIND v(dout0_110) AT=150.025n

.meas tran vdout0_111ck290 FIND v(dout0_111) AT=150.025n

.meas tran vdout0_112ck290 FIND v(dout0_112) AT=150.025n

.meas tran vdout0_113ck290 FIND v(dout0_113) AT=150.025n

.meas tran vdout0_114ck290 FIND v(dout0_114) AT=150.025n

.meas tran vdout0_115ck290 FIND v(dout0_115) AT=150.025n

.meas tran vdout0_116ck290 FIND v(dout0_116) AT=150.025n

.meas tran vdout0_117ck290 FIND v(dout0_117) AT=150.025n

.meas tran vdout0_118ck290 FIND v(dout0_118) AT=150.025n

.meas tran vdout0_119ck290 FIND v(dout0_119) AT=150.025n

.meas tran vdout0_120ck290 FIND v(dout0_120) AT=150.025n

.meas tran vdout0_121ck290 FIND v(dout0_121) AT=150.025n

.meas tran vdout0_122ck290 FIND v(dout0_122) AT=150.025n

.meas tran vdout0_123ck290 FIND v(dout0_123) AT=150.025n

.meas tran vdout0_124ck290 FIND v(dout0_124) AT=150.025n

.meas tran vdout0_125ck290 FIND v(dout0_125) AT=150.025n

.meas tran vdout0_126ck290 FIND v(dout0_126) AT=150.025n

.meas tran vdout0_127ck290 FIND v(dout0_127) AT=150.025n

.meas tran vdout0_128ck290 FIND v(dout0_128) AT=150.025n

.meas tran vdout0_129ck290 FIND v(dout0_129) AT=150.025n

.meas tran vdout0_130ck290 FIND v(dout0_130) AT=150.025n

.meas tran vdout0_131ck290 FIND v(dout0_131) AT=150.025n

.meas tran vdout0_132ck290 FIND v(dout0_132) AT=150.025n

.meas tran vdout0_133ck290 FIND v(dout0_133) AT=150.025n

.meas tran vdout0_134ck290 FIND v(dout0_134) AT=150.025n

.meas tran vdout0_135ck290 FIND v(dout0_135) AT=150.025n

.meas tran vdout0_136ck290 FIND v(dout0_136) AT=150.025n

.meas tran vdout0_137ck290 FIND v(dout0_137) AT=150.025n

.meas tran vdout0_138ck290 FIND v(dout0_138) AT=150.025n

.meas tran vdout0_139ck290 FIND v(dout0_139) AT=150.025n

.meas tran vdout0_140ck290 FIND v(dout0_140) AT=150.025n

.meas tran vdout0_141ck290 FIND v(dout0_141) AT=150.025n

.meas tran vdout0_142ck290 FIND v(dout0_142) AT=150.025n

.meas tran vdout0_143ck290 FIND v(dout0_143) AT=150.025n

.meas tran vdout0_144ck290 FIND v(dout0_144) AT=150.025n

.meas tran vdout0_145ck290 FIND v(dout0_145) AT=150.025n

.meas tran vdout0_146ck290 FIND v(dout0_146) AT=150.025n

.meas tran vdout0_147ck290 FIND v(dout0_147) AT=150.025n

.meas tran vdout0_148ck290 FIND v(dout0_148) AT=150.025n

.meas tran vdout0_149ck290 FIND v(dout0_149) AT=150.025n

.meas tran vdout0_0ck300 FIND v(dout0_0) AT=155.025n

.meas tran vdout0_1ck300 FIND v(dout0_1) AT=155.025n

.meas tran vdout0_2ck300 FIND v(dout0_2) AT=155.025n

.meas tran vdout0_3ck300 FIND v(dout0_3) AT=155.025n

.meas tran vdout0_4ck300 FIND v(dout0_4) AT=155.025n

.meas tran vdout0_5ck300 FIND v(dout0_5) AT=155.025n

.meas tran vdout0_6ck300 FIND v(dout0_6) AT=155.025n

.meas tran vdout0_7ck300 FIND v(dout0_7) AT=155.025n

.meas tran vdout0_8ck300 FIND v(dout0_8) AT=155.025n

.meas tran vdout0_9ck300 FIND v(dout0_9) AT=155.025n

.meas tran vdout0_10ck300 FIND v(dout0_10) AT=155.025n

.meas tran vdout0_11ck300 FIND v(dout0_11) AT=155.025n

.meas tran vdout0_12ck300 FIND v(dout0_12) AT=155.025n

.meas tran vdout0_13ck300 FIND v(dout0_13) AT=155.025n

.meas tran vdout0_14ck300 FIND v(dout0_14) AT=155.025n

.meas tran vdout0_15ck300 FIND v(dout0_15) AT=155.025n

.meas tran vdout0_16ck300 FIND v(dout0_16) AT=155.025n

.meas tran vdout0_17ck300 FIND v(dout0_17) AT=155.025n

.meas tran vdout0_18ck300 FIND v(dout0_18) AT=155.025n

.meas tran vdout0_19ck300 FIND v(dout0_19) AT=155.025n

.meas tran vdout0_20ck300 FIND v(dout0_20) AT=155.025n

.meas tran vdout0_21ck300 FIND v(dout0_21) AT=155.025n

.meas tran vdout0_22ck300 FIND v(dout0_22) AT=155.025n

.meas tran vdout0_23ck300 FIND v(dout0_23) AT=155.025n

.meas tran vdout0_24ck300 FIND v(dout0_24) AT=155.025n

.meas tran vdout0_25ck300 FIND v(dout0_25) AT=155.025n

.meas tran vdout0_26ck300 FIND v(dout0_26) AT=155.025n

.meas tran vdout0_27ck300 FIND v(dout0_27) AT=155.025n

.meas tran vdout0_28ck300 FIND v(dout0_28) AT=155.025n

.meas tran vdout0_29ck300 FIND v(dout0_29) AT=155.025n

.meas tran vdout0_30ck300 FIND v(dout0_30) AT=155.025n

.meas tran vdout0_31ck300 FIND v(dout0_31) AT=155.025n

.meas tran vdout0_32ck300 FIND v(dout0_32) AT=155.025n

.meas tran vdout0_33ck300 FIND v(dout0_33) AT=155.025n

.meas tran vdout0_34ck300 FIND v(dout0_34) AT=155.025n

.meas tran vdout0_35ck300 FIND v(dout0_35) AT=155.025n

.meas tran vdout0_36ck300 FIND v(dout0_36) AT=155.025n

.meas tran vdout0_37ck300 FIND v(dout0_37) AT=155.025n

.meas tran vdout0_38ck300 FIND v(dout0_38) AT=155.025n

.meas tran vdout0_39ck300 FIND v(dout0_39) AT=155.025n

.meas tran vdout0_40ck300 FIND v(dout0_40) AT=155.025n

.meas tran vdout0_41ck300 FIND v(dout0_41) AT=155.025n

.meas tran vdout0_42ck300 FIND v(dout0_42) AT=155.025n

.meas tran vdout0_43ck300 FIND v(dout0_43) AT=155.025n

.meas tran vdout0_44ck300 FIND v(dout0_44) AT=155.025n

.meas tran vdout0_45ck300 FIND v(dout0_45) AT=155.025n

.meas tran vdout0_46ck300 FIND v(dout0_46) AT=155.025n

.meas tran vdout0_47ck300 FIND v(dout0_47) AT=155.025n

.meas tran vdout0_48ck300 FIND v(dout0_48) AT=155.025n

.meas tran vdout0_49ck300 FIND v(dout0_49) AT=155.025n

.meas tran vdout0_50ck300 FIND v(dout0_50) AT=155.025n

.meas tran vdout0_51ck300 FIND v(dout0_51) AT=155.025n

.meas tran vdout0_52ck300 FIND v(dout0_52) AT=155.025n

.meas tran vdout0_53ck300 FIND v(dout0_53) AT=155.025n

.meas tran vdout0_54ck300 FIND v(dout0_54) AT=155.025n

.meas tran vdout0_55ck300 FIND v(dout0_55) AT=155.025n

.meas tran vdout0_56ck300 FIND v(dout0_56) AT=155.025n

.meas tran vdout0_57ck300 FIND v(dout0_57) AT=155.025n

.meas tran vdout0_58ck300 FIND v(dout0_58) AT=155.025n

.meas tran vdout0_59ck300 FIND v(dout0_59) AT=155.025n

.meas tran vdout0_60ck300 FIND v(dout0_60) AT=155.025n

.meas tran vdout0_61ck300 FIND v(dout0_61) AT=155.025n

.meas tran vdout0_62ck300 FIND v(dout0_62) AT=155.025n

.meas tran vdout0_63ck300 FIND v(dout0_63) AT=155.025n

.meas tran vdout0_64ck300 FIND v(dout0_64) AT=155.025n

.meas tran vdout0_65ck300 FIND v(dout0_65) AT=155.025n

.meas tran vdout0_66ck300 FIND v(dout0_66) AT=155.025n

.meas tran vdout0_67ck300 FIND v(dout0_67) AT=155.025n

.meas tran vdout0_68ck300 FIND v(dout0_68) AT=155.025n

.meas tran vdout0_69ck300 FIND v(dout0_69) AT=155.025n

.meas tran vdout0_70ck300 FIND v(dout0_70) AT=155.025n

.meas tran vdout0_71ck300 FIND v(dout0_71) AT=155.025n

.meas tran vdout0_72ck300 FIND v(dout0_72) AT=155.025n

.meas tran vdout0_73ck300 FIND v(dout0_73) AT=155.025n

.meas tran vdout0_74ck300 FIND v(dout0_74) AT=155.025n

.meas tran vdout0_75ck300 FIND v(dout0_75) AT=155.025n

.meas tran vdout0_76ck300 FIND v(dout0_76) AT=155.025n

.meas tran vdout0_77ck300 FIND v(dout0_77) AT=155.025n

.meas tran vdout0_78ck300 FIND v(dout0_78) AT=155.025n

.meas tran vdout0_79ck300 FIND v(dout0_79) AT=155.025n

.meas tran vdout0_80ck300 FIND v(dout0_80) AT=155.025n

.meas tran vdout0_81ck300 FIND v(dout0_81) AT=155.025n

.meas tran vdout0_82ck300 FIND v(dout0_82) AT=155.025n

.meas tran vdout0_83ck300 FIND v(dout0_83) AT=155.025n

.meas tran vdout0_84ck300 FIND v(dout0_84) AT=155.025n

.meas tran vdout0_85ck300 FIND v(dout0_85) AT=155.025n

.meas tran vdout0_86ck300 FIND v(dout0_86) AT=155.025n

.meas tran vdout0_87ck300 FIND v(dout0_87) AT=155.025n

.meas tran vdout0_88ck300 FIND v(dout0_88) AT=155.025n

.meas tran vdout0_89ck300 FIND v(dout0_89) AT=155.025n

.meas tran vdout0_90ck300 FIND v(dout0_90) AT=155.025n

.meas tran vdout0_91ck300 FIND v(dout0_91) AT=155.025n

.meas tran vdout0_92ck300 FIND v(dout0_92) AT=155.025n

.meas tran vdout0_93ck300 FIND v(dout0_93) AT=155.025n

.meas tran vdout0_94ck300 FIND v(dout0_94) AT=155.025n

.meas tran vdout0_95ck300 FIND v(dout0_95) AT=155.025n

.meas tran vdout0_96ck300 FIND v(dout0_96) AT=155.025n

.meas tran vdout0_97ck300 FIND v(dout0_97) AT=155.025n

.meas tran vdout0_98ck300 FIND v(dout0_98) AT=155.025n

.meas tran vdout0_99ck300 FIND v(dout0_99) AT=155.025n

.meas tran vdout0_100ck300 FIND v(dout0_100) AT=155.025n

.meas tran vdout0_101ck300 FIND v(dout0_101) AT=155.025n

.meas tran vdout0_102ck300 FIND v(dout0_102) AT=155.025n

.meas tran vdout0_103ck300 FIND v(dout0_103) AT=155.025n

.meas tran vdout0_104ck300 FIND v(dout0_104) AT=155.025n

.meas tran vdout0_105ck300 FIND v(dout0_105) AT=155.025n

.meas tran vdout0_106ck300 FIND v(dout0_106) AT=155.025n

.meas tran vdout0_107ck300 FIND v(dout0_107) AT=155.025n

.meas tran vdout0_108ck300 FIND v(dout0_108) AT=155.025n

.meas tran vdout0_109ck300 FIND v(dout0_109) AT=155.025n

.meas tran vdout0_110ck300 FIND v(dout0_110) AT=155.025n

.meas tran vdout0_111ck300 FIND v(dout0_111) AT=155.025n

.meas tran vdout0_112ck300 FIND v(dout0_112) AT=155.025n

.meas tran vdout0_113ck300 FIND v(dout0_113) AT=155.025n

.meas tran vdout0_114ck300 FIND v(dout0_114) AT=155.025n

.meas tran vdout0_115ck300 FIND v(dout0_115) AT=155.025n

.meas tran vdout0_116ck300 FIND v(dout0_116) AT=155.025n

.meas tran vdout0_117ck300 FIND v(dout0_117) AT=155.025n

.meas tran vdout0_118ck300 FIND v(dout0_118) AT=155.025n

.meas tran vdout0_119ck300 FIND v(dout0_119) AT=155.025n

.meas tran vdout0_120ck300 FIND v(dout0_120) AT=155.025n

.meas tran vdout0_121ck300 FIND v(dout0_121) AT=155.025n

.meas tran vdout0_122ck300 FIND v(dout0_122) AT=155.025n

.meas tran vdout0_123ck300 FIND v(dout0_123) AT=155.025n

.meas tran vdout0_124ck300 FIND v(dout0_124) AT=155.025n

.meas tran vdout0_125ck300 FIND v(dout0_125) AT=155.025n

.meas tran vdout0_126ck300 FIND v(dout0_126) AT=155.025n

.meas tran vdout0_127ck300 FIND v(dout0_127) AT=155.025n

.meas tran vdout0_128ck300 FIND v(dout0_128) AT=155.025n

.meas tran vdout0_129ck300 FIND v(dout0_129) AT=155.025n

.meas tran vdout0_130ck300 FIND v(dout0_130) AT=155.025n

.meas tran vdout0_131ck300 FIND v(dout0_131) AT=155.025n

.meas tran vdout0_132ck300 FIND v(dout0_132) AT=155.025n

.meas tran vdout0_133ck300 FIND v(dout0_133) AT=155.025n

.meas tran vdout0_134ck300 FIND v(dout0_134) AT=155.025n

.meas tran vdout0_135ck300 FIND v(dout0_135) AT=155.025n

.meas tran vdout0_136ck300 FIND v(dout0_136) AT=155.025n

.meas tran vdout0_137ck300 FIND v(dout0_137) AT=155.025n

.meas tran vdout0_138ck300 FIND v(dout0_138) AT=155.025n

.meas tran vdout0_139ck300 FIND v(dout0_139) AT=155.025n

.meas tran vdout0_140ck300 FIND v(dout0_140) AT=155.025n

.meas tran vdout0_141ck300 FIND v(dout0_141) AT=155.025n

.meas tran vdout0_142ck300 FIND v(dout0_142) AT=155.025n

.meas tran vdout0_143ck300 FIND v(dout0_143) AT=155.025n

.meas tran vdout0_144ck300 FIND v(dout0_144) AT=155.025n

.meas tran vdout0_145ck300 FIND v(dout0_145) AT=155.025n

.meas tran vdout0_146ck300 FIND v(dout0_146) AT=155.025n

.meas tran vdout0_147ck300 FIND v(dout0_147) AT=155.025n

.meas tran vdout0_148ck300 FIND v(dout0_148) AT=155.025n

.meas tran vdout0_149ck300 FIND v(dout0_149) AT=155.025n

.meas tran vdout0_0ck320 FIND v(dout0_0) AT=165.025n

.meas tran vdout0_1ck320 FIND v(dout0_1) AT=165.025n

.meas tran vdout0_2ck320 FIND v(dout0_2) AT=165.025n

.meas tran vdout0_3ck320 FIND v(dout0_3) AT=165.025n

.meas tran vdout0_4ck320 FIND v(dout0_4) AT=165.025n

.meas tran vdout0_5ck320 FIND v(dout0_5) AT=165.025n

.meas tran vdout0_6ck320 FIND v(dout0_6) AT=165.025n

.meas tran vdout0_7ck320 FIND v(dout0_7) AT=165.025n

.meas tran vdout0_8ck320 FIND v(dout0_8) AT=165.025n

.meas tran vdout0_9ck320 FIND v(dout0_9) AT=165.025n

.meas tran vdout0_10ck320 FIND v(dout0_10) AT=165.025n

.meas tran vdout0_11ck320 FIND v(dout0_11) AT=165.025n

.meas tran vdout0_12ck320 FIND v(dout0_12) AT=165.025n

.meas tran vdout0_13ck320 FIND v(dout0_13) AT=165.025n

.meas tran vdout0_14ck320 FIND v(dout0_14) AT=165.025n

.meas tran vdout0_15ck320 FIND v(dout0_15) AT=165.025n

.meas tran vdout0_16ck320 FIND v(dout0_16) AT=165.025n

.meas tran vdout0_17ck320 FIND v(dout0_17) AT=165.025n

.meas tran vdout0_18ck320 FIND v(dout0_18) AT=165.025n

.meas tran vdout0_19ck320 FIND v(dout0_19) AT=165.025n

.meas tran vdout0_20ck320 FIND v(dout0_20) AT=165.025n

.meas tran vdout0_21ck320 FIND v(dout0_21) AT=165.025n

.meas tran vdout0_22ck320 FIND v(dout0_22) AT=165.025n

.meas tran vdout0_23ck320 FIND v(dout0_23) AT=165.025n

.meas tran vdout0_24ck320 FIND v(dout0_24) AT=165.025n

.meas tran vdout0_25ck320 FIND v(dout0_25) AT=165.025n

.meas tran vdout0_26ck320 FIND v(dout0_26) AT=165.025n

.meas tran vdout0_27ck320 FIND v(dout0_27) AT=165.025n

.meas tran vdout0_28ck320 FIND v(dout0_28) AT=165.025n

.meas tran vdout0_29ck320 FIND v(dout0_29) AT=165.025n

.meas tran vdout0_30ck320 FIND v(dout0_30) AT=165.025n

.meas tran vdout0_31ck320 FIND v(dout0_31) AT=165.025n

.meas tran vdout0_32ck320 FIND v(dout0_32) AT=165.025n

.meas tran vdout0_33ck320 FIND v(dout0_33) AT=165.025n

.meas tran vdout0_34ck320 FIND v(dout0_34) AT=165.025n

.meas tran vdout0_35ck320 FIND v(dout0_35) AT=165.025n

.meas tran vdout0_36ck320 FIND v(dout0_36) AT=165.025n

.meas tran vdout0_37ck320 FIND v(dout0_37) AT=165.025n

.meas tran vdout0_38ck320 FIND v(dout0_38) AT=165.025n

.meas tran vdout0_39ck320 FIND v(dout0_39) AT=165.025n

.meas tran vdout0_40ck320 FIND v(dout0_40) AT=165.025n

.meas tran vdout0_41ck320 FIND v(dout0_41) AT=165.025n

.meas tran vdout0_42ck320 FIND v(dout0_42) AT=165.025n

.meas tran vdout0_43ck320 FIND v(dout0_43) AT=165.025n

.meas tran vdout0_44ck320 FIND v(dout0_44) AT=165.025n

.meas tran vdout0_45ck320 FIND v(dout0_45) AT=165.025n

.meas tran vdout0_46ck320 FIND v(dout0_46) AT=165.025n

.meas tran vdout0_47ck320 FIND v(dout0_47) AT=165.025n

.meas tran vdout0_48ck320 FIND v(dout0_48) AT=165.025n

.meas tran vdout0_49ck320 FIND v(dout0_49) AT=165.025n

.meas tran vdout0_50ck320 FIND v(dout0_50) AT=165.025n

.meas tran vdout0_51ck320 FIND v(dout0_51) AT=165.025n

.meas tran vdout0_52ck320 FIND v(dout0_52) AT=165.025n

.meas tran vdout0_53ck320 FIND v(dout0_53) AT=165.025n

.meas tran vdout0_54ck320 FIND v(dout0_54) AT=165.025n

.meas tran vdout0_55ck320 FIND v(dout0_55) AT=165.025n

.meas tran vdout0_56ck320 FIND v(dout0_56) AT=165.025n

.meas tran vdout0_57ck320 FIND v(dout0_57) AT=165.025n

.meas tran vdout0_58ck320 FIND v(dout0_58) AT=165.025n

.meas tran vdout0_59ck320 FIND v(dout0_59) AT=165.025n

.meas tran vdout0_60ck320 FIND v(dout0_60) AT=165.025n

.meas tran vdout0_61ck320 FIND v(dout0_61) AT=165.025n

.meas tran vdout0_62ck320 FIND v(dout0_62) AT=165.025n

.meas tran vdout0_63ck320 FIND v(dout0_63) AT=165.025n

.meas tran vdout0_64ck320 FIND v(dout0_64) AT=165.025n

.meas tran vdout0_65ck320 FIND v(dout0_65) AT=165.025n

.meas tran vdout0_66ck320 FIND v(dout0_66) AT=165.025n

.meas tran vdout0_67ck320 FIND v(dout0_67) AT=165.025n

.meas tran vdout0_68ck320 FIND v(dout0_68) AT=165.025n

.meas tran vdout0_69ck320 FIND v(dout0_69) AT=165.025n

.meas tran vdout0_70ck320 FIND v(dout0_70) AT=165.025n

.meas tran vdout0_71ck320 FIND v(dout0_71) AT=165.025n

.meas tran vdout0_72ck320 FIND v(dout0_72) AT=165.025n

.meas tran vdout0_73ck320 FIND v(dout0_73) AT=165.025n

.meas tran vdout0_74ck320 FIND v(dout0_74) AT=165.025n

.meas tran vdout0_75ck320 FIND v(dout0_75) AT=165.025n

.meas tran vdout0_76ck320 FIND v(dout0_76) AT=165.025n

.meas tran vdout0_77ck320 FIND v(dout0_77) AT=165.025n

.meas tran vdout0_78ck320 FIND v(dout0_78) AT=165.025n

.meas tran vdout0_79ck320 FIND v(dout0_79) AT=165.025n

.meas tran vdout0_80ck320 FIND v(dout0_80) AT=165.025n

.meas tran vdout0_81ck320 FIND v(dout0_81) AT=165.025n

.meas tran vdout0_82ck320 FIND v(dout0_82) AT=165.025n

.meas tran vdout0_83ck320 FIND v(dout0_83) AT=165.025n

.meas tran vdout0_84ck320 FIND v(dout0_84) AT=165.025n

.meas tran vdout0_85ck320 FIND v(dout0_85) AT=165.025n

.meas tran vdout0_86ck320 FIND v(dout0_86) AT=165.025n

.meas tran vdout0_87ck320 FIND v(dout0_87) AT=165.025n

.meas tran vdout0_88ck320 FIND v(dout0_88) AT=165.025n

.meas tran vdout0_89ck320 FIND v(dout0_89) AT=165.025n

.meas tran vdout0_90ck320 FIND v(dout0_90) AT=165.025n

.meas tran vdout0_91ck320 FIND v(dout0_91) AT=165.025n

.meas tran vdout0_92ck320 FIND v(dout0_92) AT=165.025n

.meas tran vdout0_93ck320 FIND v(dout0_93) AT=165.025n

.meas tran vdout0_94ck320 FIND v(dout0_94) AT=165.025n

.meas tran vdout0_95ck320 FIND v(dout0_95) AT=165.025n

.meas tran vdout0_96ck320 FIND v(dout0_96) AT=165.025n

.meas tran vdout0_97ck320 FIND v(dout0_97) AT=165.025n

.meas tran vdout0_98ck320 FIND v(dout0_98) AT=165.025n

.meas tran vdout0_99ck320 FIND v(dout0_99) AT=165.025n

.meas tran vdout0_100ck320 FIND v(dout0_100) AT=165.025n

.meas tran vdout0_101ck320 FIND v(dout0_101) AT=165.025n

.meas tran vdout0_102ck320 FIND v(dout0_102) AT=165.025n

.meas tran vdout0_103ck320 FIND v(dout0_103) AT=165.025n

.meas tran vdout0_104ck320 FIND v(dout0_104) AT=165.025n

.meas tran vdout0_105ck320 FIND v(dout0_105) AT=165.025n

.meas tran vdout0_106ck320 FIND v(dout0_106) AT=165.025n

.meas tran vdout0_107ck320 FIND v(dout0_107) AT=165.025n

.meas tran vdout0_108ck320 FIND v(dout0_108) AT=165.025n

.meas tran vdout0_109ck320 FIND v(dout0_109) AT=165.025n

.meas tran vdout0_110ck320 FIND v(dout0_110) AT=165.025n

.meas tran vdout0_111ck320 FIND v(dout0_111) AT=165.025n

.meas tran vdout0_112ck320 FIND v(dout0_112) AT=165.025n

.meas tran vdout0_113ck320 FIND v(dout0_113) AT=165.025n

.meas tran vdout0_114ck320 FIND v(dout0_114) AT=165.025n

.meas tran vdout0_115ck320 FIND v(dout0_115) AT=165.025n

.meas tran vdout0_116ck320 FIND v(dout0_116) AT=165.025n

.meas tran vdout0_117ck320 FIND v(dout0_117) AT=165.025n

.meas tran vdout0_118ck320 FIND v(dout0_118) AT=165.025n

.meas tran vdout0_119ck320 FIND v(dout0_119) AT=165.025n

.meas tran vdout0_120ck320 FIND v(dout0_120) AT=165.025n

.meas tran vdout0_121ck320 FIND v(dout0_121) AT=165.025n

.meas tran vdout0_122ck320 FIND v(dout0_122) AT=165.025n

.meas tran vdout0_123ck320 FIND v(dout0_123) AT=165.025n

.meas tran vdout0_124ck320 FIND v(dout0_124) AT=165.025n

.meas tran vdout0_125ck320 FIND v(dout0_125) AT=165.025n

.meas tran vdout0_126ck320 FIND v(dout0_126) AT=165.025n

.meas tran vdout0_127ck320 FIND v(dout0_127) AT=165.025n

.meas tran vdout0_128ck320 FIND v(dout0_128) AT=165.025n

.meas tran vdout0_129ck320 FIND v(dout0_129) AT=165.025n

.meas tran vdout0_130ck320 FIND v(dout0_130) AT=165.025n

.meas tran vdout0_131ck320 FIND v(dout0_131) AT=165.025n

.meas tran vdout0_132ck320 FIND v(dout0_132) AT=165.025n

.meas tran vdout0_133ck320 FIND v(dout0_133) AT=165.025n

.meas tran vdout0_134ck320 FIND v(dout0_134) AT=165.025n

.meas tran vdout0_135ck320 FIND v(dout0_135) AT=165.025n

.meas tran vdout0_136ck320 FIND v(dout0_136) AT=165.025n

.meas tran vdout0_137ck320 FIND v(dout0_137) AT=165.025n

.meas tran vdout0_138ck320 FIND v(dout0_138) AT=165.025n

.meas tran vdout0_139ck320 FIND v(dout0_139) AT=165.025n

.meas tran vdout0_140ck320 FIND v(dout0_140) AT=165.025n

.meas tran vdout0_141ck320 FIND v(dout0_141) AT=165.025n

.meas tran vdout0_142ck320 FIND v(dout0_142) AT=165.025n

.meas tran vdout0_143ck320 FIND v(dout0_143) AT=165.025n

.meas tran vdout0_144ck320 FIND v(dout0_144) AT=165.025n

.meas tran vdout0_145ck320 FIND v(dout0_145) AT=165.025n

.meas tran vdout0_146ck320 FIND v(dout0_146) AT=165.025n

.meas tran vdout0_147ck320 FIND v(dout0_147) AT=165.025n

.meas tran vdout0_148ck320 FIND v(dout0_148) AT=165.025n

.meas tran vdout0_149ck320 FIND v(dout0_149) AT=165.025n

.meas tran vdout0_0ck330 FIND v(dout0_0) AT=170.025n

.meas tran vdout0_1ck330 FIND v(dout0_1) AT=170.025n

.meas tran vdout0_2ck330 FIND v(dout0_2) AT=170.025n

.meas tran vdout0_3ck330 FIND v(dout0_3) AT=170.025n

.meas tran vdout0_4ck330 FIND v(dout0_4) AT=170.025n

.meas tran vdout0_5ck330 FIND v(dout0_5) AT=170.025n

.meas tran vdout0_6ck330 FIND v(dout0_6) AT=170.025n

.meas tran vdout0_7ck330 FIND v(dout0_7) AT=170.025n

.meas tran vdout0_8ck330 FIND v(dout0_8) AT=170.025n

.meas tran vdout0_9ck330 FIND v(dout0_9) AT=170.025n

.meas tran vdout0_10ck330 FIND v(dout0_10) AT=170.025n

.meas tran vdout0_11ck330 FIND v(dout0_11) AT=170.025n

.meas tran vdout0_12ck330 FIND v(dout0_12) AT=170.025n

.meas tran vdout0_13ck330 FIND v(dout0_13) AT=170.025n

.meas tran vdout0_14ck330 FIND v(dout0_14) AT=170.025n

.meas tran vdout0_15ck330 FIND v(dout0_15) AT=170.025n

.meas tran vdout0_16ck330 FIND v(dout0_16) AT=170.025n

.meas tran vdout0_17ck330 FIND v(dout0_17) AT=170.025n

.meas tran vdout0_18ck330 FIND v(dout0_18) AT=170.025n

.meas tran vdout0_19ck330 FIND v(dout0_19) AT=170.025n

.meas tran vdout0_20ck330 FIND v(dout0_20) AT=170.025n

.meas tran vdout0_21ck330 FIND v(dout0_21) AT=170.025n

.meas tran vdout0_22ck330 FIND v(dout0_22) AT=170.025n

.meas tran vdout0_23ck330 FIND v(dout0_23) AT=170.025n

.meas tran vdout0_24ck330 FIND v(dout0_24) AT=170.025n

.meas tran vdout0_25ck330 FIND v(dout0_25) AT=170.025n

.meas tran vdout0_26ck330 FIND v(dout0_26) AT=170.025n

.meas tran vdout0_27ck330 FIND v(dout0_27) AT=170.025n

.meas tran vdout0_28ck330 FIND v(dout0_28) AT=170.025n

.meas tran vdout0_29ck330 FIND v(dout0_29) AT=170.025n

.meas tran vdout0_30ck330 FIND v(dout0_30) AT=170.025n

.meas tran vdout0_31ck330 FIND v(dout0_31) AT=170.025n

.meas tran vdout0_32ck330 FIND v(dout0_32) AT=170.025n

.meas tran vdout0_33ck330 FIND v(dout0_33) AT=170.025n

.meas tran vdout0_34ck330 FIND v(dout0_34) AT=170.025n

.meas tran vdout0_35ck330 FIND v(dout0_35) AT=170.025n

.meas tran vdout0_36ck330 FIND v(dout0_36) AT=170.025n

.meas tran vdout0_37ck330 FIND v(dout0_37) AT=170.025n

.meas tran vdout0_38ck330 FIND v(dout0_38) AT=170.025n

.meas tran vdout0_39ck330 FIND v(dout0_39) AT=170.025n

.meas tran vdout0_40ck330 FIND v(dout0_40) AT=170.025n

.meas tran vdout0_41ck330 FIND v(dout0_41) AT=170.025n

.meas tran vdout0_42ck330 FIND v(dout0_42) AT=170.025n

.meas tran vdout0_43ck330 FIND v(dout0_43) AT=170.025n

.meas tran vdout0_44ck330 FIND v(dout0_44) AT=170.025n

.meas tran vdout0_45ck330 FIND v(dout0_45) AT=170.025n

.meas tran vdout0_46ck330 FIND v(dout0_46) AT=170.025n

.meas tran vdout0_47ck330 FIND v(dout0_47) AT=170.025n

.meas tran vdout0_48ck330 FIND v(dout0_48) AT=170.025n

.meas tran vdout0_49ck330 FIND v(dout0_49) AT=170.025n

.meas tran vdout0_50ck330 FIND v(dout0_50) AT=170.025n

.meas tran vdout0_51ck330 FIND v(dout0_51) AT=170.025n

.meas tran vdout0_52ck330 FIND v(dout0_52) AT=170.025n

.meas tran vdout0_53ck330 FIND v(dout0_53) AT=170.025n

.meas tran vdout0_54ck330 FIND v(dout0_54) AT=170.025n

.meas tran vdout0_55ck330 FIND v(dout0_55) AT=170.025n

.meas tran vdout0_56ck330 FIND v(dout0_56) AT=170.025n

.meas tran vdout0_57ck330 FIND v(dout0_57) AT=170.025n

.meas tran vdout0_58ck330 FIND v(dout0_58) AT=170.025n

.meas tran vdout0_59ck330 FIND v(dout0_59) AT=170.025n

.meas tran vdout0_60ck330 FIND v(dout0_60) AT=170.025n

.meas tran vdout0_61ck330 FIND v(dout0_61) AT=170.025n

.meas tran vdout0_62ck330 FIND v(dout0_62) AT=170.025n

.meas tran vdout0_63ck330 FIND v(dout0_63) AT=170.025n

.meas tran vdout0_64ck330 FIND v(dout0_64) AT=170.025n

.meas tran vdout0_65ck330 FIND v(dout0_65) AT=170.025n

.meas tran vdout0_66ck330 FIND v(dout0_66) AT=170.025n

.meas tran vdout0_67ck330 FIND v(dout0_67) AT=170.025n

.meas tran vdout0_68ck330 FIND v(dout0_68) AT=170.025n

.meas tran vdout0_69ck330 FIND v(dout0_69) AT=170.025n

.meas tran vdout0_70ck330 FIND v(dout0_70) AT=170.025n

.meas tran vdout0_71ck330 FIND v(dout0_71) AT=170.025n

.meas tran vdout0_72ck330 FIND v(dout0_72) AT=170.025n

.meas tran vdout0_73ck330 FIND v(dout0_73) AT=170.025n

.meas tran vdout0_74ck330 FIND v(dout0_74) AT=170.025n

.meas tran vdout0_75ck330 FIND v(dout0_75) AT=170.025n

.meas tran vdout0_76ck330 FIND v(dout0_76) AT=170.025n

.meas tran vdout0_77ck330 FIND v(dout0_77) AT=170.025n

.meas tran vdout0_78ck330 FIND v(dout0_78) AT=170.025n

.meas tran vdout0_79ck330 FIND v(dout0_79) AT=170.025n

.meas tran vdout0_80ck330 FIND v(dout0_80) AT=170.025n

.meas tran vdout0_81ck330 FIND v(dout0_81) AT=170.025n

.meas tran vdout0_82ck330 FIND v(dout0_82) AT=170.025n

.meas tran vdout0_83ck330 FIND v(dout0_83) AT=170.025n

.meas tran vdout0_84ck330 FIND v(dout0_84) AT=170.025n

.meas tran vdout0_85ck330 FIND v(dout0_85) AT=170.025n

.meas tran vdout0_86ck330 FIND v(dout0_86) AT=170.025n

.meas tran vdout0_87ck330 FIND v(dout0_87) AT=170.025n

.meas tran vdout0_88ck330 FIND v(dout0_88) AT=170.025n

.meas tran vdout0_89ck330 FIND v(dout0_89) AT=170.025n

.meas tran vdout0_90ck330 FIND v(dout0_90) AT=170.025n

.meas tran vdout0_91ck330 FIND v(dout0_91) AT=170.025n

.meas tran vdout0_92ck330 FIND v(dout0_92) AT=170.025n

.meas tran vdout0_93ck330 FIND v(dout0_93) AT=170.025n

.meas tran vdout0_94ck330 FIND v(dout0_94) AT=170.025n

.meas tran vdout0_95ck330 FIND v(dout0_95) AT=170.025n

.meas tran vdout0_96ck330 FIND v(dout0_96) AT=170.025n

.meas tran vdout0_97ck330 FIND v(dout0_97) AT=170.025n

.meas tran vdout0_98ck330 FIND v(dout0_98) AT=170.025n

.meas tran vdout0_99ck330 FIND v(dout0_99) AT=170.025n

.meas tran vdout0_100ck330 FIND v(dout0_100) AT=170.025n

.meas tran vdout0_101ck330 FIND v(dout0_101) AT=170.025n

.meas tran vdout0_102ck330 FIND v(dout0_102) AT=170.025n

.meas tran vdout0_103ck330 FIND v(dout0_103) AT=170.025n

.meas tran vdout0_104ck330 FIND v(dout0_104) AT=170.025n

.meas tran vdout0_105ck330 FIND v(dout0_105) AT=170.025n

.meas tran vdout0_106ck330 FIND v(dout0_106) AT=170.025n

.meas tran vdout0_107ck330 FIND v(dout0_107) AT=170.025n

.meas tran vdout0_108ck330 FIND v(dout0_108) AT=170.025n

.meas tran vdout0_109ck330 FIND v(dout0_109) AT=170.025n

.meas tran vdout0_110ck330 FIND v(dout0_110) AT=170.025n

.meas tran vdout0_111ck330 FIND v(dout0_111) AT=170.025n

.meas tran vdout0_112ck330 FIND v(dout0_112) AT=170.025n

.meas tran vdout0_113ck330 FIND v(dout0_113) AT=170.025n

.meas tran vdout0_114ck330 FIND v(dout0_114) AT=170.025n

.meas tran vdout0_115ck330 FIND v(dout0_115) AT=170.025n

.meas tran vdout0_116ck330 FIND v(dout0_116) AT=170.025n

.meas tran vdout0_117ck330 FIND v(dout0_117) AT=170.025n

.meas tran vdout0_118ck330 FIND v(dout0_118) AT=170.025n

.meas tran vdout0_119ck330 FIND v(dout0_119) AT=170.025n

.meas tran vdout0_120ck330 FIND v(dout0_120) AT=170.025n

.meas tran vdout0_121ck330 FIND v(dout0_121) AT=170.025n

.meas tran vdout0_122ck330 FIND v(dout0_122) AT=170.025n

.meas tran vdout0_123ck330 FIND v(dout0_123) AT=170.025n

.meas tran vdout0_124ck330 FIND v(dout0_124) AT=170.025n

.meas tran vdout0_125ck330 FIND v(dout0_125) AT=170.025n

.meas tran vdout0_126ck330 FIND v(dout0_126) AT=170.025n

.meas tran vdout0_127ck330 FIND v(dout0_127) AT=170.025n

.meas tran vdout0_128ck330 FIND v(dout0_128) AT=170.025n

.meas tran vdout0_129ck330 FIND v(dout0_129) AT=170.025n

.meas tran vdout0_130ck330 FIND v(dout0_130) AT=170.025n

.meas tran vdout0_131ck330 FIND v(dout0_131) AT=170.025n

.meas tran vdout0_132ck330 FIND v(dout0_132) AT=170.025n

.meas tran vdout0_133ck330 FIND v(dout0_133) AT=170.025n

.meas tran vdout0_134ck330 FIND v(dout0_134) AT=170.025n

.meas tran vdout0_135ck330 FIND v(dout0_135) AT=170.025n

.meas tran vdout0_136ck330 FIND v(dout0_136) AT=170.025n

.meas tran vdout0_137ck330 FIND v(dout0_137) AT=170.025n

.meas tran vdout0_138ck330 FIND v(dout0_138) AT=170.025n

.meas tran vdout0_139ck330 FIND v(dout0_139) AT=170.025n

.meas tran vdout0_140ck330 FIND v(dout0_140) AT=170.025n

.meas tran vdout0_141ck330 FIND v(dout0_141) AT=170.025n

.meas tran vdout0_142ck330 FIND v(dout0_142) AT=170.025n

.meas tran vdout0_143ck330 FIND v(dout0_143) AT=170.025n

.meas tran vdout0_144ck330 FIND v(dout0_144) AT=170.025n

.meas tran vdout0_145ck330 FIND v(dout0_145) AT=170.025n

.meas tran vdout0_146ck330 FIND v(dout0_146) AT=170.025n

.meas tran vdout0_147ck330 FIND v(dout0_147) AT=170.025n

.meas tran vdout0_148ck330 FIND v(dout0_148) AT=170.025n

.meas tran vdout0_149ck330 FIND v(dout0_149) AT=170.025n

.meas tran vdout0_0ck350 FIND v(dout0_0) AT=180.025n

.meas tran vdout0_1ck350 FIND v(dout0_1) AT=180.025n

.meas tran vdout0_2ck350 FIND v(dout0_2) AT=180.025n

.meas tran vdout0_3ck350 FIND v(dout0_3) AT=180.025n

.meas tran vdout0_4ck350 FIND v(dout0_4) AT=180.025n

.meas tran vdout0_5ck350 FIND v(dout0_5) AT=180.025n

.meas tran vdout0_6ck350 FIND v(dout0_6) AT=180.025n

.meas tran vdout0_7ck350 FIND v(dout0_7) AT=180.025n

.meas tran vdout0_8ck350 FIND v(dout0_8) AT=180.025n

.meas tran vdout0_9ck350 FIND v(dout0_9) AT=180.025n

.meas tran vdout0_10ck350 FIND v(dout0_10) AT=180.025n

.meas tran vdout0_11ck350 FIND v(dout0_11) AT=180.025n

.meas tran vdout0_12ck350 FIND v(dout0_12) AT=180.025n

.meas tran vdout0_13ck350 FIND v(dout0_13) AT=180.025n

.meas tran vdout0_14ck350 FIND v(dout0_14) AT=180.025n

.meas tran vdout0_15ck350 FIND v(dout0_15) AT=180.025n

.meas tran vdout0_16ck350 FIND v(dout0_16) AT=180.025n

.meas tran vdout0_17ck350 FIND v(dout0_17) AT=180.025n

.meas tran vdout0_18ck350 FIND v(dout0_18) AT=180.025n

.meas tran vdout0_19ck350 FIND v(dout0_19) AT=180.025n

.meas tran vdout0_20ck350 FIND v(dout0_20) AT=180.025n

.meas tran vdout0_21ck350 FIND v(dout0_21) AT=180.025n

.meas tran vdout0_22ck350 FIND v(dout0_22) AT=180.025n

.meas tran vdout0_23ck350 FIND v(dout0_23) AT=180.025n

.meas tran vdout0_24ck350 FIND v(dout0_24) AT=180.025n

.meas tran vdout0_25ck350 FIND v(dout0_25) AT=180.025n

.meas tran vdout0_26ck350 FIND v(dout0_26) AT=180.025n

.meas tran vdout0_27ck350 FIND v(dout0_27) AT=180.025n

.meas tran vdout0_28ck350 FIND v(dout0_28) AT=180.025n

.meas tran vdout0_29ck350 FIND v(dout0_29) AT=180.025n

.meas tran vdout0_30ck350 FIND v(dout0_30) AT=180.025n

.meas tran vdout0_31ck350 FIND v(dout0_31) AT=180.025n

.meas tran vdout0_32ck350 FIND v(dout0_32) AT=180.025n

.meas tran vdout0_33ck350 FIND v(dout0_33) AT=180.025n

.meas tran vdout0_34ck350 FIND v(dout0_34) AT=180.025n

.meas tran vdout0_35ck350 FIND v(dout0_35) AT=180.025n

.meas tran vdout0_36ck350 FIND v(dout0_36) AT=180.025n

.meas tran vdout0_37ck350 FIND v(dout0_37) AT=180.025n

.meas tran vdout0_38ck350 FIND v(dout0_38) AT=180.025n

.meas tran vdout0_39ck350 FIND v(dout0_39) AT=180.025n

.meas tran vdout0_40ck350 FIND v(dout0_40) AT=180.025n

.meas tran vdout0_41ck350 FIND v(dout0_41) AT=180.025n

.meas tran vdout0_42ck350 FIND v(dout0_42) AT=180.025n

.meas tran vdout0_43ck350 FIND v(dout0_43) AT=180.025n

.meas tran vdout0_44ck350 FIND v(dout0_44) AT=180.025n

.meas tran vdout0_45ck350 FIND v(dout0_45) AT=180.025n

.meas tran vdout0_46ck350 FIND v(dout0_46) AT=180.025n

.meas tran vdout0_47ck350 FIND v(dout0_47) AT=180.025n

.meas tran vdout0_48ck350 FIND v(dout0_48) AT=180.025n

.meas tran vdout0_49ck350 FIND v(dout0_49) AT=180.025n

.meas tran vdout0_50ck350 FIND v(dout0_50) AT=180.025n

.meas tran vdout0_51ck350 FIND v(dout0_51) AT=180.025n

.meas tran vdout0_52ck350 FIND v(dout0_52) AT=180.025n

.meas tran vdout0_53ck350 FIND v(dout0_53) AT=180.025n

.meas tran vdout0_54ck350 FIND v(dout0_54) AT=180.025n

.meas tran vdout0_55ck350 FIND v(dout0_55) AT=180.025n

.meas tran vdout0_56ck350 FIND v(dout0_56) AT=180.025n

.meas tran vdout0_57ck350 FIND v(dout0_57) AT=180.025n

.meas tran vdout0_58ck350 FIND v(dout0_58) AT=180.025n

.meas tran vdout0_59ck350 FIND v(dout0_59) AT=180.025n

.meas tran vdout0_60ck350 FIND v(dout0_60) AT=180.025n

.meas tran vdout0_61ck350 FIND v(dout0_61) AT=180.025n

.meas tran vdout0_62ck350 FIND v(dout0_62) AT=180.025n

.meas tran vdout0_63ck350 FIND v(dout0_63) AT=180.025n

.meas tran vdout0_64ck350 FIND v(dout0_64) AT=180.025n

.meas tran vdout0_65ck350 FIND v(dout0_65) AT=180.025n

.meas tran vdout0_66ck350 FIND v(dout0_66) AT=180.025n

.meas tran vdout0_67ck350 FIND v(dout0_67) AT=180.025n

.meas tran vdout0_68ck350 FIND v(dout0_68) AT=180.025n

.meas tran vdout0_69ck350 FIND v(dout0_69) AT=180.025n

.meas tran vdout0_70ck350 FIND v(dout0_70) AT=180.025n

.meas tran vdout0_71ck350 FIND v(dout0_71) AT=180.025n

.meas tran vdout0_72ck350 FIND v(dout0_72) AT=180.025n

.meas tran vdout0_73ck350 FIND v(dout0_73) AT=180.025n

.meas tran vdout0_74ck350 FIND v(dout0_74) AT=180.025n

.meas tran vdout0_75ck350 FIND v(dout0_75) AT=180.025n

.meas tran vdout0_76ck350 FIND v(dout0_76) AT=180.025n

.meas tran vdout0_77ck350 FIND v(dout0_77) AT=180.025n

.meas tran vdout0_78ck350 FIND v(dout0_78) AT=180.025n

.meas tran vdout0_79ck350 FIND v(dout0_79) AT=180.025n

.meas tran vdout0_80ck350 FIND v(dout0_80) AT=180.025n

.meas tran vdout0_81ck350 FIND v(dout0_81) AT=180.025n

.meas tran vdout0_82ck350 FIND v(dout0_82) AT=180.025n

.meas tran vdout0_83ck350 FIND v(dout0_83) AT=180.025n

.meas tran vdout0_84ck350 FIND v(dout0_84) AT=180.025n

.meas tran vdout0_85ck350 FIND v(dout0_85) AT=180.025n

.meas tran vdout0_86ck350 FIND v(dout0_86) AT=180.025n

.meas tran vdout0_87ck350 FIND v(dout0_87) AT=180.025n

.meas tran vdout0_88ck350 FIND v(dout0_88) AT=180.025n

.meas tran vdout0_89ck350 FIND v(dout0_89) AT=180.025n

.meas tran vdout0_90ck350 FIND v(dout0_90) AT=180.025n

.meas tran vdout0_91ck350 FIND v(dout0_91) AT=180.025n

.meas tran vdout0_92ck350 FIND v(dout0_92) AT=180.025n

.meas tran vdout0_93ck350 FIND v(dout0_93) AT=180.025n

.meas tran vdout0_94ck350 FIND v(dout0_94) AT=180.025n

.meas tran vdout0_95ck350 FIND v(dout0_95) AT=180.025n

.meas tran vdout0_96ck350 FIND v(dout0_96) AT=180.025n

.meas tran vdout0_97ck350 FIND v(dout0_97) AT=180.025n

.meas tran vdout0_98ck350 FIND v(dout0_98) AT=180.025n

.meas tran vdout0_99ck350 FIND v(dout0_99) AT=180.025n

.meas tran vdout0_100ck350 FIND v(dout0_100) AT=180.025n

.meas tran vdout0_101ck350 FIND v(dout0_101) AT=180.025n

.meas tran vdout0_102ck350 FIND v(dout0_102) AT=180.025n

.meas tran vdout0_103ck350 FIND v(dout0_103) AT=180.025n

.meas tran vdout0_104ck350 FIND v(dout0_104) AT=180.025n

.meas tran vdout0_105ck350 FIND v(dout0_105) AT=180.025n

.meas tran vdout0_106ck350 FIND v(dout0_106) AT=180.025n

.meas tran vdout0_107ck350 FIND v(dout0_107) AT=180.025n

.meas tran vdout0_108ck350 FIND v(dout0_108) AT=180.025n

.meas tran vdout0_109ck350 FIND v(dout0_109) AT=180.025n

.meas tran vdout0_110ck350 FIND v(dout0_110) AT=180.025n

.meas tran vdout0_111ck350 FIND v(dout0_111) AT=180.025n

.meas tran vdout0_112ck350 FIND v(dout0_112) AT=180.025n

.meas tran vdout0_113ck350 FIND v(dout0_113) AT=180.025n

.meas tran vdout0_114ck350 FIND v(dout0_114) AT=180.025n

.meas tran vdout0_115ck350 FIND v(dout0_115) AT=180.025n

.meas tran vdout0_116ck350 FIND v(dout0_116) AT=180.025n

.meas tran vdout0_117ck350 FIND v(dout0_117) AT=180.025n

.meas tran vdout0_118ck350 FIND v(dout0_118) AT=180.025n

.meas tran vdout0_119ck350 FIND v(dout0_119) AT=180.025n

.meas tran vdout0_120ck350 FIND v(dout0_120) AT=180.025n

.meas tran vdout0_121ck350 FIND v(dout0_121) AT=180.025n

.meas tran vdout0_122ck350 FIND v(dout0_122) AT=180.025n

.meas tran vdout0_123ck350 FIND v(dout0_123) AT=180.025n

.meas tran vdout0_124ck350 FIND v(dout0_124) AT=180.025n

.meas tran vdout0_125ck350 FIND v(dout0_125) AT=180.025n

.meas tran vdout0_126ck350 FIND v(dout0_126) AT=180.025n

.meas tran vdout0_127ck350 FIND v(dout0_127) AT=180.025n

.meas tran vdout0_128ck350 FIND v(dout0_128) AT=180.025n

.meas tran vdout0_129ck350 FIND v(dout0_129) AT=180.025n

.meas tran vdout0_130ck350 FIND v(dout0_130) AT=180.025n

.meas tran vdout0_131ck350 FIND v(dout0_131) AT=180.025n

.meas tran vdout0_132ck350 FIND v(dout0_132) AT=180.025n

.meas tran vdout0_133ck350 FIND v(dout0_133) AT=180.025n

.meas tran vdout0_134ck350 FIND v(dout0_134) AT=180.025n

.meas tran vdout0_135ck350 FIND v(dout0_135) AT=180.025n

.meas tran vdout0_136ck350 FIND v(dout0_136) AT=180.025n

.meas tran vdout0_137ck350 FIND v(dout0_137) AT=180.025n

.meas tran vdout0_138ck350 FIND v(dout0_138) AT=180.025n

.meas tran vdout0_139ck350 FIND v(dout0_139) AT=180.025n

.meas tran vdout0_140ck350 FIND v(dout0_140) AT=180.025n

.meas tran vdout0_141ck350 FIND v(dout0_141) AT=180.025n

.meas tran vdout0_142ck350 FIND v(dout0_142) AT=180.025n

.meas tran vdout0_143ck350 FIND v(dout0_143) AT=180.025n

.meas tran vdout0_144ck350 FIND v(dout0_144) AT=180.025n

.meas tran vdout0_145ck350 FIND v(dout0_145) AT=180.025n

.meas tran vdout0_146ck350 FIND v(dout0_146) AT=180.025n

.meas tran vdout0_147ck350 FIND v(dout0_147) AT=180.025n

.meas tran vdout0_148ck350 FIND v(dout0_148) AT=180.025n

.meas tran vdout0_149ck350 FIND v(dout0_149) AT=180.025n

.meas tran vdout0_0ck360 FIND v(dout0_0) AT=185.025n

.meas tran vdout0_1ck360 FIND v(dout0_1) AT=185.025n

.meas tran vdout0_2ck360 FIND v(dout0_2) AT=185.025n

.meas tran vdout0_3ck360 FIND v(dout0_3) AT=185.025n

.meas tran vdout0_4ck360 FIND v(dout0_4) AT=185.025n

.meas tran vdout0_5ck360 FIND v(dout0_5) AT=185.025n

.meas tran vdout0_6ck360 FIND v(dout0_6) AT=185.025n

.meas tran vdout0_7ck360 FIND v(dout0_7) AT=185.025n

.meas tran vdout0_8ck360 FIND v(dout0_8) AT=185.025n

.meas tran vdout0_9ck360 FIND v(dout0_9) AT=185.025n

.meas tran vdout0_10ck360 FIND v(dout0_10) AT=185.025n

.meas tran vdout0_11ck360 FIND v(dout0_11) AT=185.025n

.meas tran vdout0_12ck360 FIND v(dout0_12) AT=185.025n

.meas tran vdout0_13ck360 FIND v(dout0_13) AT=185.025n

.meas tran vdout0_14ck360 FIND v(dout0_14) AT=185.025n

.meas tran vdout0_15ck360 FIND v(dout0_15) AT=185.025n

.meas tran vdout0_16ck360 FIND v(dout0_16) AT=185.025n

.meas tran vdout0_17ck360 FIND v(dout0_17) AT=185.025n

.meas tran vdout0_18ck360 FIND v(dout0_18) AT=185.025n

.meas tran vdout0_19ck360 FIND v(dout0_19) AT=185.025n

.meas tran vdout0_20ck360 FIND v(dout0_20) AT=185.025n

.meas tran vdout0_21ck360 FIND v(dout0_21) AT=185.025n

.meas tran vdout0_22ck360 FIND v(dout0_22) AT=185.025n

.meas tran vdout0_23ck360 FIND v(dout0_23) AT=185.025n

.meas tran vdout0_24ck360 FIND v(dout0_24) AT=185.025n

.meas tran vdout0_25ck360 FIND v(dout0_25) AT=185.025n

.meas tran vdout0_26ck360 FIND v(dout0_26) AT=185.025n

.meas tran vdout0_27ck360 FIND v(dout0_27) AT=185.025n

.meas tran vdout0_28ck360 FIND v(dout0_28) AT=185.025n

.meas tran vdout0_29ck360 FIND v(dout0_29) AT=185.025n

.meas tran vdout0_30ck360 FIND v(dout0_30) AT=185.025n

.meas tran vdout0_31ck360 FIND v(dout0_31) AT=185.025n

.meas tran vdout0_32ck360 FIND v(dout0_32) AT=185.025n

.meas tran vdout0_33ck360 FIND v(dout0_33) AT=185.025n

.meas tran vdout0_34ck360 FIND v(dout0_34) AT=185.025n

.meas tran vdout0_35ck360 FIND v(dout0_35) AT=185.025n

.meas tran vdout0_36ck360 FIND v(dout0_36) AT=185.025n

.meas tran vdout0_37ck360 FIND v(dout0_37) AT=185.025n

.meas tran vdout0_38ck360 FIND v(dout0_38) AT=185.025n

.meas tran vdout0_39ck360 FIND v(dout0_39) AT=185.025n

.meas tran vdout0_40ck360 FIND v(dout0_40) AT=185.025n

.meas tran vdout0_41ck360 FIND v(dout0_41) AT=185.025n

.meas tran vdout0_42ck360 FIND v(dout0_42) AT=185.025n

.meas tran vdout0_43ck360 FIND v(dout0_43) AT=185.025n

.meas tran vdout0_44ck360 FIND v(dout0_44) AT=185.025n

.meas tran vdout0_45ck360 FIND v(dout0_45) AT=185.025n

.meas tran vdout0_46ck360 FIND v(dout0_46) AT=185.025n

.meas tran vdout0_47ck360 FIND v(dout0_47) AT=185.025n

.meas tran vdout0_48ck360 FIND v(dout0_48) AT=185.025n

.meas tran vdout0_49ck360 FIND v(dout0_49) AT=185.025n

.meas tran vdout0_50ck360 FIND v(dout0_50) AT=185.025n

.meas tran vdout0_51ck360 FIND v(dout0_51) AT=185.025n

.meas tran vdout0_52ck360 FIND v(dout0_52) AT=185.025n

.meas tran vdout0_53ck360 FIND v(dout0_53) AT=185.025n

.meas tran vdout0_54ck360 FIND v(dout0_54) AT=185.025n

.meas tran vdout0_55ck360 FIND v(dout0_55) AT=185.025n

.meas tran vdout0_56ck360 FIND v(dout0_56) AT=185.025n

.meas tran vdout0_57ck360 FIND v(dout0_57) AT=185.025n

.meas tran vdout0_58ck360 FIND v(dout0_58) AT=185.025n

.meas tran vdout0_59ck360 FIND v(dout0_59) AT=185.025n

.meas tran vdout0_60ck360 FIND v(dout0_60) AT=185.025n

.meas tran vdout0_61ck360 FIND v(dout0_61) AT=185.025n

.meas tran vdout0_62ck360 FIND v(dout0_62) AT=185.025n

.meas tran vdout0_63ck360 FIND v(dout0_63) AT=185.025n

.meas tran vdout0_64ck360 FIND v(dout0_64) AT=185.025n

.meas tran vdout0_65ck360 FIND v(dout0_65) AT=185.025n

.meas tran vdout0_66ck360 FIND v(dout0_66) AT=185.025n

.meas tran vdout0_67ck360 FIND v(dout0_67) AT=185.025n

.meas tran vdout0_68ck360 FIND v(dout0_68) AT=185.025n

.meas tran vdout0_69ck360 FIND v(dout0_69) AT=185.025n

.meas tran vdout0_70ck360 FIND v(dout0_70) AT=185.025n

.meas tran vdout0_71ck360 FIND v(dout0_71) AT=185.025n

.meas tran vdout0_72ck360 FIND v(dout0_72) AT=185.025n

.meas tran vdout0_73ck360 FIND v(dout0_73) AT=185.025n

.meas tran vdout0_74ck360 FIND v(dout0_74) AT=185.025n

.meas tran vdout0_75ck360 FIND v(dout0_75) AT=185.025n

.meas tran vdout0_76ck360 FIND v(dout0_76) AT=185.025n

.meas tran vdout0_77ck360 FIND v(dout0_77) AT=185.025n

.meas tran vdout0_78ck360 FIND v(dout0_78) AT=185.025n

.meas tran vdout0_79ck360 FIND v(dout0_79) AT=185.025n

.meas tran vdout0_80ck360 FIND v(dout0_80) AT=185.025n

.meas tran vdout0_81ck360 FIND v(dout0_81) AT=185.025n

.meas tran vdout0_82ck360 FIND v(dout0_82) AT=185.025n

.meas tran vdout0_83ck360 FIND v(dout0_83) AT=185.025n

.meas tran vdout0_84ck360 FIND v(dout0_84) AT=185.025n

.meas tran vdout0_85ck360 FIND v(dout0_85) AT=185.025n

.meas tran vdout0_86ck360 FIND v(dout0_86) AT=185.025n

.meas tran vdout0_87ck360 FIND v(dout0_87) AT=185.025n

.meas tran vdout0_88ck360 FIND v(dout0_88) AT=185.025n

.meas tran vdout0_89ck360 FIND v(dout0_89) AT=185.025n

.meas tran vdout0_90ck360 FIND v(dout0_90) AT=185.025n

.meas tran vdout0_91ck360 FIND v(dout0_91) AT=185.025n

.meas tran vdout0_92ck360 FIND v(dout0_92) AT=185.025n

.meas tran vdout0_93ck360 FIND v(dout0_93) AT=185.025n

.meas tran vdout0_94ck360 FIND v(dout0_94) AT=185.025n

.meas tran vdout0_95ck360 FIND v(dout0_95) AT=185.025n

.meas tran vdout0_96ck360 FIND v(dout0_96) AT=185.025n

.meas tran vdout0_97ck360 FIND v(dout0_97) AT=185.025n

.meas tran vdout0_98ck360 FIND v(dout0_98) AT=185.025n

.meas tran vdout0_99ck360 FIND v(dout0_99) AT=185.025n

.meas tran vdout0_100ck360 FIND v(dout0_100) AT=185.025n

.meas tran vdout0_101ck360 FIND v(dout0_101) AT=185.025n

.meas tran vdout0_102ck360 FIND v(dout0_102) AT=185.025n

.meas tran vdout0_103ck360 FIND v(dout0_103) AT=185.025n

.meas tran vdout0_104ck360 FIND v(dout0_104) AT=185.025n

.meas tran vdout0_105ck360 FIND v(dout0_105) AT=185.025n

.meas tran vdout0_106ck360 FIND v(dout0_106) AT=185.025n

.meas tran vdout0_107ck360 FIND v(dout0_107) AT=185.025n

.meas tran vdout0_108ck360 FIND v(dout0_108) AT=185.025n

.meas tran vdout0_109ck360 FIND v(dout0_109) AT=185.025n

.meas tran vdout0_110ck360 FIND v(dout0_110) AT=185.025n

.meas tran vdout0_111ck360 FIND v(dout0_111) AT=185.025n

.meas tran vdout0_112ck360 FIND v(dout0_112) AT=185.025n

.meas tran vdout0_113ck360 FIND v(dout0_113) AT=185.025n

.meas tran vdout0_114ck360 FIND v(dout0_114) AT=185.025n

.meas tran vdout0_115ck360 FIND v(dout0_115) AT=185.025n

.meas tran vdout0_116ck360 FIND v(dout0_116) AT=185.025n

.meas tran vdout0_117ck360 FIND v(dout0_117) AT=185.025n

.meas tran vdout0_118ck360 FIND v(dout0_118) AT=185.025n

.meas tran vdout0_119ck360 FIND v(dout0_119) AT=185.025n

.meas tran vdout0_120ck360 FIND v(dout0_120) AT=185.025n

.meas tran vdout0_121ck360 FIND v(dout0_121) AT=185.025n

.meas tran vdout0_122ck360 FIND v(dout0_122) AT=185.025n

.meas tran vdout0_123ck360 FIND v(dout0_123) AT=185.025n

.meas tran vdout0_124ck360 FIND v(dout0_124) AT=185.025n

.meas tran vdout0_125ck360 FIND v(dout0_125) AT=185.025n

.meas tran vdout0_126ck360 FIND v(dout0_126) AT=185.025n

.meas tran vdout0_127ck360 FIND v(dout0_127) AT=185.025n

.meas tran vdout0_128ck360 FIND v(dout0_128) AT=185.025n

.meas tran vdout0_129ck360 FIND v(dout0_129) AT=185.025n

.meas tran vdout0_130ck360 FIND v(dout0_130) AT=185.025n

.meas tran vdout0_131ck360 FIND v(dout0_131) AT=185.025n

.meas tran vdout0_132ck360 FIND v(dout0_132) AT=185.025n

.meas tran vdout0_133ck360 FIND v(dout0_133) AT=185.025n

.meas tran vdout0_134ck360 FIND v(dout0_134) AT=185.025n

.meas tran vdout0_135ck360 FIND v(dout0_135) AT=185.025n

.meas tran vdout0_136ck360 FIND v(dout0_136) AT=185.025n

.meas tran vdout0_137ck360 FIND v(dout0_137) AT=185.025n

.meas tran vdout0_138ck360 FIND v(dout0_138) AT=185.025n

.meas tran vdout0_139ck360 FIND v(dout0_139) AT=185.025n

.meas tran vdout0_140ck360 FIND v(dout0_140) AT=185.025n

.meas tran vdout0_141ck360 FIND v(dout0_141) AT=185.025n

.meas tran vdout0_142ck360 FIND v(dout0_142) AT=185.025n

.meas tran vdout0_143ck360 FIND v(dout0_143) AT=185.025n

.meas tran vdout0_144ck360 FIND v(dout0_144) AT=185.025n

.meas tran vdout0_145ck360 FIND v(dout0_145) AT=185.025n

.meas tran vdout0_146ck360 FIND v(dout0_146) AT=185.025n

.meas tran vdout0_147ck360 FIND v(dout0_147) AT=185.025n

.meas tran vdout0_148ck360 FIND v(dout0_148) AT=185.025n

.meas tran vdout0_149ck360 FIND v(dout0_149) AT=185.025n

.meas tran vdout0_0ck380 FIND v(dout0_0) AT=195.025n

.meas tran vdout0_1ck380 FIND v(dout0_1) AT=195.025n

.meas tran vdout0_2ck380 FIND v(dout0_2) AT=195.025n

.meas tran vdout0_3ck380 FIND v(dout0_3) AT=195.025n

.meas tran vdout0_4ck380 FIND v(dout0_4) AT=195.025n

.meas tran vdout0_5ck380 FIND v(dout0_5) AT=195.025n

.meas tran vdout0_6ck380 FIND v(dout0_6) AT=195.025n

.meas tran vdout0_7ck380 FIND v(dout0_7) AT=195.025n

.meas tran vdout0_8ck380 FIND v(dout0_8) AT=195.025n

.meas tran vdout0_9ck380 FIND v(dout0_9) AT=195.025n

.meas tran vdout0_10ck380 FIND v(dout0_10) AT=195.025n

.meas tran vdout0_11ck380 FIND v(dout0_11) AT=195.025n

.meas tran vdout0_12ck380 FIND v(dout0_12) AT=195.025n

.meas tran vdout0_13ck380 FIND v(dout0_13) AT=195.025n

.meas tran vdout0_14ck380 FIND v(dout0_14) AT=195.025n

.meas tran vdout0_15ck380 FIND v(dout0_15) AT=195.025n

.meas tran vdout0_16ck380 FIND v(dout0_16) AT=195.025n

.meas tran vdout0_17ck380 FIND v(dout0_17) AT=195.025n

.meas tran vdout0_18ck380 FIND v(dout0_18) AT=195.025n

.meas tran vdout0_19ck380 FIND v(dout0_19) AT=195.025n

.meas tran vdout0_20ck380 FIND v(dout0_20) AT=195.025n

.meas tran vdout0_21ck380 FIND v(dout0_21) AT=195.025n

.meas tran vdout0_22ck380 FIND v(dout0_22) AT=195.025n

.meas tran vdout0_23ck380 FIND v(dout0_23) AT=195.025n

.meas tran vdout0_24ck380 FIND v(dout0_24) AT=195.025n

.meas tran vdout0_25ck380 FIND v(dout0_25) AT=195.025n

.meas tran vdout0_26ck380 FIND v(dout0_26) AT=195.025n

.meas tran vdout0_27ck380 FIND v(dout0_27) AT=195.025n

.meas tran vdout0_28ck380 FIND v(dout0_28) AT=195.025n

.meas tran vdout0_29ck380 FIND v(dout0_29) AT=195.025n

.meas tran vdout0_30ck380 FIND v(dout0_30) AT=195.025n

.meas tran vdout0_31ck380 FIND v(dout0_31) AT=195.025n

.meas tran vdout0_32ck380 FIND v(dout0_32) AT=195.025n

.meas tran vdout0_33ck380 FIND v(dout0_33) AT=195.025n

.meas tran vdout0_34ck380 FIND v(dout0_34) AT=195.025n

.meas tran vdout0_35ck380 FIND v(dout0_35) AT=195.025n

.meas tran vdout0_36ck380 FIND v(dout0_36) AT=195.025n

.meas tran vdout0_37ck380 FIND v(dout0_37) AT=195.025n

.meas tran vdout0_38ck380 FIND v(dout0_38) AT=195.025n

.meas tran vdout0_39ck380 FIND v(dout0_39) AT=195.025n

.meas tran vdout0_40ck380 FIND v(dout0_40) AT=195.025n

.meas tran vdout0_41ck380 FIND v(dout0_41) AT=195.025n

.meas tran vdout0_42ck380 FIND v(dout0_42) AT=195.025n

.meas tran vdout0_43ck380 FIND v(dout0_43) AT=195.025n

.meas tran vdout0_44ck380 FIND v(dout0_44) AT=195.025n

.meas tran vdout0_45ck380 FIND v(dout0_45) AT=195.025n

.meas tran vdout0_46ck380 FIND v(dout0_46) AT=195.025n

.meas tran vdout0_47ck380 FIND v(dout0_47) AT=195.025n

.meas tran vdout0_48ck380 FIND v(dout0_48) AT=195.025n

.meas tran vdout0_49ck380 FIND v(dout0_49) AT=195.025n

.meas tran vdout0_50ck380 FIND v(dout0_50) AT=195.025n

.meas tran vdout0_51ck380 FIND v(dout0_51) AT=195.025n

.meas tran vdout0_52ck380 FIND v(dout0_52) AT=195.025n

.meas tran vdout0_53ck380 FIND v(dout0_53) AT=195.025n

.meas tran vdout0_54ck380 FIND v(dout0_54) AT=195.025n

.meas tran vdout0_55ck380 FIND v(dout0_55) AT=195.025n

.meas tran vdout0_56ck380 FIND v(dout0_56) AT=195.025n

.meas tran vdout0_57ck380 FIND v(dout0_57) AT=195.025n

.meas tran vdout0_58ck380 FIND v(dout0_58) AT=195.025n

.meas tran vdout0_59ck380 FIND v(dout0_59) AT=195.025n

.meas tran vdout0_60ck380 FIND v(dout0_60) AT=195.025n

.meas tran vdout0_61ck380 FIND v(dout0_61) AT=195.025n

.meas tran vdout0_62ck380 FIND v(dout0_62) AT=195.025n

.meas tran vdout0_63ck380 FIND v(dout0_63) AT=195.025n

.meas tran vdout0_64ck380 FIND v(dout0_64) AT=195.025n

.meas tran vdout0_65ck380 FIND v(dout0_65) AT=195.025n

.meas tran vdout0_66ck380 FIND v(dout0_66) AT=195.025n

.meas tran vdout0_67ck380 FIND v(dout0_67) AT=195.025n

.meas tran vdout0_68ck380 FIND v(dout0_68) AT=195.025n

.meas tran vdout0_69ck380 FIND v(dout0_69) AT=195.025n

.meas tran vdout0_70ck380 FIND v(dout0_70) AT=195.025n

.meas tran vdout0_71ck380 FIND v(dout0_71) AT=195.025n

.meas tran vdout0_72ck380 FIND v(dout0_72) AT=195.025n

.meas tran vdout0_73ck380 FIND v(dout0_73) AT=195.025n

.meas tran vdout0_74ck380 FIND v(dout0_74) AT=195.025n

.meas tran vdout0_75ck380 FIND v(dout0_75) AT=195.025n

.meas tran vdout0_76ck380 FIND v(dout0_76) AT=195.025n

.meas tran vdout0_77ck380 FIND v(dout0_77) AT=195.025n

.meas tran vdout0_78ck380 FIND v(dout0_78) AT=195.025n

.meas tran vdout0_79ck380 FIND v(dout0_79) AT=195.025n

.meas tran vdout0_80ck380 FIND v(dout0_80) AT=195.025n

.meas tran vdout0_81ck380 FIND v(dout0_81) AT=195.025n

.meas tran vdout0_82ck380 FIND v(dout0_82) AT=195.025n

.meas tran vdout0_83ck380 FIND v(dout0_83) AT=195.025n

.meas tran vdout0_84ck380 FIND v(dout0_84) AT=195.025n

.meas tran vdout0_85ck380 FIND v(dout0_85) AT=195.025n

.meas tran vdout0_86ck380 FIND v(dout0_86) AT=195.025n

.meas tran vdout0_87ck380 FIND v(dout0_87) AT=195.025n

.meas tran vdout0_88ck380 FIND v(dout0_88) AT=195.025n

.meas tran vdout0_89ck380 FIND v(dout0_89) AT=195.025n

.meas tran vdout0_90ck380 FIND v(dout0_90) AT=195.025n

.meas tran vdout0_91ck380 FIND v(dout0_91) AT=195.025n

.meas tran vdout0_92ck380 FIND v(dout0_92) AT=195.025n

.meas tran vdout0_93ck380 FIND v(dout0_93) AT=195.025n

.meas tran vdout0_94ck380 FIND v(dout0_94) AT=195.025n

.meas tran vdout0_95ck380 FIND v(dout0_95) AT=195.025n

.meas tran vdout0_96ck380 FIND v(dout0_96) AT=195.025n

.meas tran vdout0_97ck380 FIND v(dout0_97) AT=195.025n

.meas tran vdout0_98ck380 FIND v(dout0_98) AT=195.025n

.meas tran vdout0_99ck380 FIND v(dout0_99) AT=195.025n

.meas tran vdout0_100ck380 FIND v(dout0_100) AT=195.025n

.meas tran vdout0_101ck380 FIND v(dout0_101) AT=195.025n

.meas tran vdout0_102ck380 FIND v(dout0_102) AT=195.025n

.meas tran vdout0_103ck380 FIND v(dout0_103) AT=195.025n

.meas tran vdout0_104ck380 FIND v(dout0_104) AT=195.025n

.meas tran vdout0_105ck380 FIND v(dout0_105) AT=195.025n

.meas tran vdout0_106ck380 FIND v(dout0_106) AT=195.025n

.meas tran vdout0_107ck380 FIND v(dout0_107) AT=195.025n

.meas tran vdout0_108ck380 FIND v(dout0_108) AT=195.025n

.meas tran vdout0_109ck380 FIND v(dout0_109) AT=195.025n

.meas tran vdout0_110ck380 FIND v(dout0_110) AT=195.025n

.meas tran vdout0_111ck380 FIND v(dout0_111) AT=195.025n

.meas tran vdout0_112ck380 FIND v(dout0_112) AT=195.025n

.meas tran vdout0_113ck380 FIND v(dout0_113) AT=195.025n

.meas tran vdout0_114ck380 FIND v(dout0_114) AT=195.025n

.meas tran vdout0_115ck380 FIND v(dout0_115) AT=195.025n

.meas tran vdout0_116ck380 FIND v(dout0_116) AT=195.025n

.meas tran vdout0_117ck380 FIND v(dout0_117) AT=195.025n

.meas tran vdout0_118ck380 FIND v(dout0_118) AT=195.025n

.meas tran vdout0_119ck380 FIND v(dout0_119) AT=195.025n

.meas tran vdout0_120ck380 FIND v(dout0_120) AT=195.025n

.meas tran vdout0_121ck380 FIND v(dout0_121) AT=195.025n

.meas tran vdout0_122ck380 FIND v(dout0_122) AT=195.025n

.meas tran vdout0_123ck380 FIND v(dout0_123) AT=195.025n

.meas tran vdout0_124ck380 FIND v(dout0_124) AT=195.025n

.meas tran vdout0_125ck380 FIND v(dout0_125) AT=195.025n

.meas tran vdout0_126ck380 FIND v(dout0_126) AT=195.025n

.meas tran vdout0_127ck380 FIND v(dout0_127) AT=195.025n

.meas tran vdout0_128ck380 FIND v(dout0_128) AT=195.025n

.meas tran vdout0_129ck380 FIND v(dout0_129) AT=195.025n

.meas tran vdout0_130ck380 FIND v(dout0_130) AT=195.025n

.meas tran vdout0_131ck380 FIND v(dout0_131) AT=195.025n

.meas tran vdout0_132ck380 FIND v(dout0_132) AT=195.025n

.meas tran vdout0_133ck380 FIND v(dout0_133) AT=195.025n

.meas tran vdout0_134ck380 FIND v(dout0_134) AT=195.025n

.meas tran vdout0_135ck380 FIND v(dout0_135) AT=195.025n

.meas tran vdout0_136ck380 FIND v(dout0_136) AT=195.025n

.meas tran vdout0_137ck380 FIND v(dout0_137) AT=195.025n

.meas tran vdout0_138ck380 FIND v(dout0_138) AT=195.025n

.meas tran vdout0_139ck380 FIND v(dout0_139) AT=195.025n

.meas tran vdout0_140ck380 FIND v(dout0_140) AT=195.025n

.meas tran vdout0_141ck380 FIND v(dout0_141) AT=195.025n

.meas tran vdout0_142ck380 FIND v(dout0_142) AT=195.025n

.meas tran vdout0_143ck380 FIND v(dout0_143) AT=195.025n

.meas tran vdout0_144ck380 FIND v(dout0_144) AT=195.025n

.meas tran vdout0_145ck380 FIND v(dout0_145) AT=195.025n

.meas tran vdout0_146ck380 FIND v(dout0_146) AT=195.025n

.meas tran vdout0_147ck380 FIND v(dout0_147) AT=195.025n

.meas tran vdout0_148ck380 FIND v(dout0_148) AT=195.025n

.meas tran vdout0_149ck380 FIND v(dout0_149) AT=195.025n

.meas tran vdout0_0ck390 FIND v(dout0_0) AT=200.025n

.meas tran vdout0_1ck390 FIND v(dout0_1) AT=200.025n

.meas tran vdout0_2ck390 FIND v(dout0_2) AT=200.025n

.meas tran vdout0_3ck390 FIND v(dout0_3) AT=200.025n

.meas tran vdout0_4ck390 FIND v(dout0_4) AT=200.025n

.meas tran vdout0_5ck390 FIND v(dout0_5) AT=200.025n

.meas tran vdout0_6ck390 FIND v(dout0_6) AT=200.025n

.meas tran vdout0_7ck390 FIND v(dout0_7) AT=200.025n

.meas tran vdout0_8ck390 FIND v(dout0_8) AT=200.025n

.meas tran vdout0_9ck390 FIND v(dout0_9) AT=200.025n

.meas tran vdout0_10ck390 FIND v(dout0_10) AT=200.025n

.meas tran vdout0_11ck390 FIND v(dout0_11) AT=200.025n

.meas tran vdout0_12ck390 FIND v(dout0_12) AT=200.025n

.meas tran vdout0_13ck390 FIND v(dout0_13) AT=200.025n

.meas tran vdout0_14ck390 FIND v(dout0_14) AT=200.025n

.meas tran vdout0_15ck390 FIND v(dout0_15) AT=200.025n

.meas tran vdout0_16ck390 FIND v(dout0_16) AT=200.025n

.meas tran vdout0_17ck390 FIND v(dout0_17) AT=200.025n

.meas tran vdout0_18ck390 FIND v(dout0_18) AT=200.025n

.meas tran vdout0_19ck390 FIND v(dout0_19) AT=200.025n

.meas tran vdout0_20ck390 FIND v(dout0_20) AT=200.025n

.meas tran vdout0_21ck390 FIND v(dout0_21) AT=200.025n

.meas tran vdout0_22ck390 FIND v(dout0_22) AT=200.025n

.meas tran vdout0_23ck390 FIND v(dout0_23) AT=200.025n

.meas tran vdout0_24ck390 FIND v(dout0_24) AT=200.025n

.meas tran vdout0_25ck390 FIND v(dout0_25) AT=200.025n

.meas tran vdout0_26ck390 FIND v(dout0_26) AT=200.025n

.meas tran vdout0_27ck390 FIND v(dout0_27) AT=200.025n

.meas tran vdout0_28ck390 FIND v(dout0_28) AT=200.025n

.meas tran vdout0_29ck390 FIND v(dout0_29) AT=200.025n

.meas tran vdout0_30ck390 FIND v(dout0_30) AT=200.025n

.meas tran vdout0_31ck390 FIND v(dout0_31) AT=200.025n

.meas tran vdout0_32ck390 FIND v(dout0_32) AT=200.025n

.meas tran vdout0_33ck390 FIND v(dout0_33) AT=200.025n

.meas tran vdout0_34ck390 FIND v(dout0_34) AT=200.025n

.meas tran vdout0_35ck390 FIND v(dout0_35) AT=200.025n

.meas tran vdout0_36ck390 FIND v(dout0_36) AT=200.025n

.meas tran vdout0_37ck390 FIND v(dout0_37) AT=200.025n

.meas tran vdout0_38ck390 FIND v(dout0_38) AT=200.025n

.meas tran vdout0_39ck390 FIND v(dout0_39) AT=200.025n

.meas tran vdout0_40ck390 FIND v(dout0_40) AT=200.025n

.meas tran vdout0_41ck390 FIND v(dout0_41) AT=200.025n

.meas tran vdout0_42ck390 FIND v(dout0_42) AT=200.025n

.meas tran vdout0_43ck390 FIND v(dout0_43) AT=200.025n

.meas tran vdout0_44ck390 FIND v(dout0_44) AT=200.025n

.meas tran vdout0_45ck390 FIND v(dout0_45) AT=200.025n

.meas tran vdout0_46ck390 FIND v(dout0_46) AT=200.025n

.meas tran vdout0_47ck390 FIND v(dout0_47) AT=200.025n

.meas tran vdout0_48ck390 FIND v(dout0_48) AT=200.025n

.meas tran vdout0_49ck390 FIND v(dout0_49) AT=200.025n

.meas tran vdout0_50ck390 FIND v(dout0_50) AT=200.025n

.meas tran vdout0_51ck390 FIND v(dout0_51) AT=200.025n

.meas tran vdout0_52ck390 FIND v(dout0_52) AT=200.025n

.meas tran vdout0_53ck390 FIND v(dout0_53) AT=200.025n

.meas tran vdout0_54ck390 FIND v(dout0_54) AT=200.025n

.meas tran vdout0_55ck390 FIND v(dout0_55) AT=200.025n

.meas tran vdout0_56ck390 FIND v(dout0_56) AT=200.025n

.meas tran vdout0_57ck390 FIND v(dout0_57) AT=200.025n

.meas tran vdout0_58ck390 FIND v(dout0_58) AT=200.025n

.meas tran vdout0_59ck390 FIND v(dout0_59) AT=200.025n

.meas tran vdout0_60ck390 FIND v(dout0_60) AT=200.025n

.meas tran vdout0_61ck390 FIND v(dout0_61) AT=200.025n

.meas tran vdout0_62ck390 FIND v(dout0_62) AT=200.025n

.meas tran vdout0_63ck390 FIND v(dout0_63) AT=200.025n

.meas tran vdout0_64ck390 FIND v(dout0_64) AT=200.025n

.meas tran vdout0_65ck390 FIND v(dout0_65) AT=200.025n

.meas tran vdout0_66ck390 FIND v(dout0_66) AT=200.025n

.meas tran vdout0_67ck390 FIND v(dout0_67) AT=200.025n

.meas tran vdout0_68ck390 FIND v(dout0_68) AT=200.025n

.meas tran vdout0_69ck390 FIND v(dout0_69) AT=200.025n

.meas tran vdout0_70ck390 FIND v(dout0_70) AT=200.025n

.meas tran vdout0_71ck390 FIND v(dout0_71) AT=200.025n

.meas tran vdout0_72ck390 FIND v(dout0_72) AT=200.025n

.meas tran vdout0_73ck390 FIND v(dout0_73) AT=200.025n

.meas tran vdout0_74ck390 FIND v(dout0_74) AT=200.025n

.meas tran vdout0_75ck390 FIND v(dout0_75) AT=200.025n

.meas tran vdout0_76ck390 FIND v(dout0_76) AT=200.025n

.meas tran vdout0_77ck390 FIND v(dout0_77) AT=200.025n

.meas tran vdout0_78ck390 FIND v(dout0_78) AT=200.025n

.meas tran vdout0_79ck390 FIND v(dout0_79) AT=200.025n

.meas tran vdout0_80ck390 FIND v(dout0_80) AT=200.025n

.meas tran vdout0_81ck390 FIND v(dout0_81) AT=200.025n

.meas tran vdout0_82ck390 FIND v(dout0_82) AT=200.025n

.meas tran vdout0_83ck390 FIND v(dout0_83) AT=200.025n

.meas tran vdout0_84ck390 FIND v(dout0_84) AT=200.025n

.meas tran vdout0_85ck390 FIND v(dout0_85) AT=200.025n

.meas tran vdout0_86ck390 FIND v(dout0_86) AT=200.025n

.meas tran vdout0_87ck390 FIND v(dout0_87) AT=200.025n

.meas tran vdout0_88ck390 FIND v(dout0_88) AT=200.025n

.meas tran vdout0_89ck390 FIND v(dout0_89) AT=200.025n

.meas tran vdout0_90ck390 FIND v(dout0_90) AT=200.025n

.meas tran vdout0_91ck390 FIND v(dout0_91) AT=200.025n

.meas tran vdout0_92ck390 FIND v(dout0_92) AT=200.025n

.meas tran vdout0_93ck390 FIND v(dout0_93) AT=200.025n

.meas tran vdout0_94ck390 FIND v(dout0_94) AT=200.025n

.meas tran vdout0_95ck390 FIND v(dout0_95) AT=200.025n

.meas tran vdout0_96ck390 FIND v(dout0_96) AT=200.025n

.meas tran vdout0_97ck390 FIND v(dout0_97) AT=200.025n

.meas tran vdout0_98ck390 FIND v(dout0_98) AT=200.025n

.meas tran vdout0_99ck390 FIND v(dout0_99) AT=200.025n

.meas tran vdout0_100ck390 FIND v(dout0_100) AT=200.025n

.meas tran vdout0_101ck390 FIND v(dout0_101) AT=200.025n

.meas tran vdout0_102ck390 FIND v(dout0_102) AT=200.025n

.meas tran vdout0_103ck390 FIND v(dout0_103) AT=200.025n

.meas tran vdout0_104ck390 FIND v(dout0_104) AT=200.025n

.meas tran vdout0_105ck390 FIND v(dout0_105) AT=200.025n

.meas tran vdout0_106ck390 FIND v(dout0_106) AT=200.025n

.meas tran vdout0_107ck390 FIND v(dout0_107) AT=200.025n

.meas tran vdout0_108ck390 FIND v(dout0_108) AT=200.025n

.meas tran vdout0_109ck390 FIND v(dout0_109) AT=200.025n

.meas tran vdout0_110ck390 FIND v(dout0_110) AT=200.025n

.meas tran vdout0_111ck390 FIND v(dout0_111) AT=200.025n

.meas tran vdout0_112ck390 FIND v(dout0_112) AT=200.025n

.meas tran vdout0_113ck390 FIND v(dout0_113) AT=200.025n

.meas tran vdout0_114ck390 FIND v(dout0_114) AT=200.025n

.meas tran vdout0_115ck390 FIND v(dout0_115) AT=200.025n

.meas tran vdout0_116ck390 FIND v(dout0_116) AT=200.025n

.meas tran vdout0_117ck390 FIND v(dout0_117) AT=200.025n

.meas tran vdout0_118ck390 FIND v(dout0_118) AT=200.025n

.meas tran vdout0_119ck390 FIND v(dout0_119) AT=200.025n

.meas tran vdout0_120ck390 FIND v(dout0_120) AT=200.025n

.meas tran vdout0_121ck390 FIND v(dout0_121) AT=200.025n

.meas tran vdout0_122ck390 FIND v(dout0_122) AT=200.025n

.meas tran vdout0_123ck390 FIND v(dout0_123) AT=200.025n

.meas tran vdout0_124ck390 FIND v(dout0_124) AT=200.025n

.meas tran vdout0_125ck390 FIND v(dout0_125) AT=200.025n

.meas tran vdout0_126ck390 FIND v(dout0_126) AT=200.025n

.meas tran vdout0_127ck390 FIND v(dout0_127) AT=200.025n

.meas tran vdout0_128ck390 FIND v(dout0_128) AT=200.025n

.meas tran vdout0_129ck390 FIND v(dout0_129) AT=200.025n

.meas tran vdout0_130ck390 FIND v(dout0_130) AT=200.025n

.meas tran vdout0_131ck390 FIND v(dout0_131) AT=200.025n

.meas tran vdout0_132ck390 FIND v(dout0_132) AT=200.025n

.meas tran vdout0_133ck390 FIND v(dout0_133) AT=200.025n

.meas tran vdout0_134ck390 FIND v(dout0_134) AT=200.025n

.meas tran vdout0_135ck390 FIND v(dout0_135) AT=200.025n

.meas tran vdout0_136ck390 FIND v(dout0_136) AT=200.025n

.meas tran vdout0_137ck390 FIND v(dout0_137) AT=200.025n

.meas tran vdout0_138ck390 FIND v(dout0_138) AT=200.025n

.meas tran vdout0_139ck390 FIND v(dout0_139) AT=200.025n

.meas tran vdout0_140ck390 FIND v(dout0_140) AT=200.025n

.meas tran vdout0_141ck390 FIND v(dout0_141) AT=200.025n

.meas tran vdout0_142ck390 FIND v(dout0_142) AT=200.025n

.meas tran vdout0_143ck390 FIND v(dout0_143) AT=200.025n

.meas tran vdout0_144ck390 FIND v(dout0_144) AT=200.025n

.meas tran vdout0_145ck390 FIND v(dout0_145) AT=200.025n

.meas tran vdout0_146ck390 FIND v(dout0_146) AT=200.025n

.meas tran vdout0_147ck390 FIND v(dout0_147) AT=200.025n

.meas tran vdout0_148ck390 FIND v(dout0_148) AT=200.025n

.meas tran vdout0_149ck390 FIND v(dout0_149) AT=200.025n

.meas tran vdout0_0ck400 FIND v(dout0_0) AT=205.025n

.meas tran vdout0_1ck400 FIND v(dout0_1) AT=205.025n

.meas tran vdout0_2ck400 FIND v(dout0_2) AT=205.025n

.meas tran vdout0_3ck400 FIND v(dout0_3) AT=205.025n

.meas tran vdout0_4ck400 FIND v(dout0_4) AT=205.025n

.meas tran vdout0_5ck400 FIND v(dout0_5) AT=205.025n

.meas tran vdout0_6ck400 FIND v(dout0_6) AT=205.025n

.meas tran vdout0_7ck400 FIND v(dout0_7) AT=205.025n

.meas tran vdout0_8ck400 FIND v(dout0_8) AT=205.025n

.meas tran vdout0_9ck400 FIND v(dout0_9) AT=205.025n

.meas tran vdout0_10ck400 FIND v(dout0_10) AT=205.025n

.meas tran vdout0_11ck400 FIND v(dout0_11) AT=205.025n

.meas tran vdout0_12ck400 FIND v(dout0_12) AT=205.025n

.meas tran vdout0_13ck400 FIND v(dout0_13) AT=205.025n

.meas tran vdout0_14ck400 FIND v(dout0_14) AT=205.025n

.meas tran vdout0_15ck400 FIND v(dout0_15) AT=205.025n

.meas tran vdout0_16ck400 FIND v(dout0_16) AT=205.025n

.meas tran vdout0_17ck400 FIND v(dout0_17) AT=205.025n

.meas tran vdout0_18ck400 FIND v(dout0_18) AT=205.025n

.meas tran vdout0_19ck400 FIND v(dout0_19) AT=205.025n

.meas tran vdout0_20ck400 FIND v(dout0_20) AT=205.025n

.meas tran vdout0_21ck400 FIND v(dout0_21) AT=205.025n

.meas tran vdout0_22ck400 FIND v(dout0_22) AT=205.025n

.meas tran vdout0_23ck400 FIND v(dout0_23) AT=205.025n

.meas tran vdout0_24ck400 FIND v(dout0_24) AT=205.025n

.meas tran vdout0_25ck400 FIND v(dout0_25) AT=205.025n

.meas tran vdout0_26ck400 FIND v(dout0_26) AT=205.025n

.meas tran vdout0_27ck400 FIND v(dout0_27) AT=205.025n

.meas tran vdout0_28ck400 FIND v(dout0_28) AT=205.025n

.meas tran vdout0_29ck400 FIND v(dout0_29) AT=205.025n

.meas tran vdout0_30ck400 FIND v(dout0_30) AT=205.025n

.meas tran vdout0_31ck400 FIND v(dout0_31) AT=205.025n

.meas tran vdout0_32ck400 FIND v(dout0_32) AT=205.025n

.meas tran vdout0_33ck400 FIND v(dout0_33) AT=205.025n

.meas tran vdout0_34ck400 FIND v(dout0_34) AT=205.025n

.meas tran vdout0_35ck400 FIND v(dout0_35) AT=205.025n

.meas tran vdout0_36ck400 FIND v(dout0_36) AT=205.025n

.meas tran vdout0_37ck400 FIND v(dout0_37) AT=205.025n

.meas tran vdout0_38ck400 FIND v(dout0_38) AT=205.025n

.meas tran vdout0_39ck400 FIND v(dout0_39) AT=205.025n

.meas tran vdout0_40ck400 FIND v(dout0_40) AT=205.025n

.meas tran vdout0_41ck400 FIND v(dout0_41) AT=205.025n

.meas tran vdout0_42ck400 FIND v(dout0_42) AT=205.025n

.meas tran vdout0_43ck400 FIND v(dout0_43) AT=205.025n

.meas tran vdout0_44ck400 FIND v(dout0_44) AT=205.025n

.meas tran vdout0_45ck400 FIND v(dout0_45) AT=205.025n

.meas tran vdout0_46ck400 FIND v(dout0_46) AT=205.025n

.meas tran vdout0_47ck400 FIND v(dout0_47) AT=205.025n

.meas tran vdout0_48ck400 FIND v(dout0_48) AT=205.025n

.meas tran vdout0_49ck400 FIND v(dout0_49) AT=205.025n

.meas tran vdout0_50ck400 FIND v(dout0_50) AT=205.025n

.meas tran vdout0_51ck400 FIND v(dout0_51) AT=205.025n

.meas tran vdout0_52ck400 FIND v(dout0_52) AT=205.025n

.meas tran vdout0_53ck400 FIND v(dout0_53) AT=205.025n

.meas tran vdout0_54ck400 FIND v(dout0_54) AT=205.025n

.meas tran vdout0_55ck400 FIND v(dout0_55) AT=205.025n

.meas tran vdout0_56ck400 FIND v(dout0_56) AT=205.025n

.meas tran vdout0_57ck400 FIND v(dout0_57) AT=205.025n

.meas tran vdout0_58ck400 FIND v(dout0_58) AT=205.025n

.meas tran vdout0_59ck400 FIND v(dout0_59) AT=205.025n

.meas tran vdout0_60ck400 FIND v(dout0_60) AT=205.025n

.meas tran vdout0_61ck400 FIND v(dout0_61) AT=205.025n

.meas tran vdout0_62ck400 FIND v(dout0_62) AT=205.025n

.meas tran vdout0_63ck400 FIND v(dout0_63) AT=205.025n

.meas tran vdout0_64ck400 FIND v(dout0_64) AT=205.025n

.meas tran vdout0_65ck400 FIND v(dout0_65) AT=205.025n

.meas tran vdout0_66ck400 FIND v(dout0_66) AT=205.025n

.meas tran vdout0_67ck400 FIND v(dout0_67) AT=205.025n

.meas tran vdout0_68ck400 FIND v(dout0_68) AT=205.025n

.meas tran vdout0_69ck400 FIND v(dout0_69) AT=205.025n

.meas tran vdout0_70ck400 FIND v(dout0_70) AT=205.025n

.meas tran vdout0_71ck400 FIND v(dout0_71) AT=205.025n

.meas tran vdout0_72ck400 FIND v(dout0_72) AT=205.025n

.meas tran vdout0_73ck400 FIND v(dout0_73) AT=205.025n

.meas tran vdout0_74ck400 FIND v(dout0_74) AT=205.025n

.meas tran vdout0_75ck400 FIND v(dout0_75) AT=205.025n

.meas tran vdout0_76ck400 FIND v(dout0_76) AT=205.025n

.meas tran vdout0_77ck400 FIND v(dout0_77) AT=205.025n

.meas tran vdout0_78ck400 FIND v(dout0_78) AT=205.025n

.meas tran vdout0_79ck400 FIND v(dout0_79) AT=205.025n

.meas tran vdout0_80ck400 FIND v(dout0_80) AT=205.025n

.meas tran vdout0_81ck400 FIND v(dout0_81) AT=205.025n

.meas tran vdout0_82ck400 FIND v(dout0_82) AT=205.025n

.meas tran vdout0_83ck400 FIND v(dout0_83) AT=205.025n

.meas tran vdout0_84ck400 FIND v(dout0_84) AT=205.025n

.meas tran vdout0_85ck400 FIND v(dout0_85) AT=205.025n

.meas tran vdout0_86ck400 FIND v(dout0_86) AT=205.025n

.meas tran vdout0_87ck400 FIND v(dout0_87) AT=205.025n

.meas tran vdout0_88ck400 FIND v(dout0_88) AT=205.025n

.meas tran vdout0_89ck400 FIND v(dout0_89) AT=205.025n

.meas tran vdout0_90ck400 FIND v(dout0_90) AT=205.025n

.meas tran vdout0_91ck400 FIND v(dout0_91) AT=205.025n

.meas tran vdout0_92ck400 FIND v(dout0_92) AT=205.025n

.meas tran vdout0_93ck400 FIND v(dout0_93) AT=205.025n

.meas tran vdout0_94ck400 FIND v(dout0_94) AT=205.025n

.meas tran vdout0_95ck400 FIND v(dout0_95) AT=205.025n

.meas tran vdout0_96ck400 FIND v(dout0_96) AT=205.025n

.meas tran vdout0_97ck400 FIND v(dout0_97) AT=205.025n

.meas tran vdout0_98ck400 FIND v(dout0_98) AT=205.025n

.meas tran vdout0_99ck400 FIND v(dout0_99) AT=205.025n

.meas tran vdout0_100ck400 FIND v(dout0_100) AT=205.025n

.meas tran vdout0_101ck400 FIND v(dout0_101) AT=205.025n

.meas tran vdout0_102ck400 FIND v(dout0_102) AT=205.025n

.meas tran vdout0_103ck400 FIND v(dout0_103) AT=205.025n

.meas tran vdout0_104ck400 FIND v(dout0_104) AT=205.025n

.meas tran vdout0_105ck400 FIND v(dout0_105) AT=205.025n

.meas tran vdout0_106ck400 FIND v(dout0_106) AT=205.025n

.meas tran vdout0_107ck400 FIND v(dout0_107) AT=205.025n

.meas tran vdout0_108ck400 FIND v(dout0_108) AT=205.025n

.meas tran vdout0_109ck400 FIND v(dout0_109) AT=205.025n

.meas tran vdout0_110ck400 FIND v(dout0_110) AT=205.025n

.meas tran vdout0_111ck400 FIND v(dout0_111) AT=205.025n

.meas tran vdout0_112ck400 FIND v(dout0_112) AT=205.025n

.meas tran vdout0_113ck400 FIND v(dout0_113) AT=205.025n

.meas tran vdout0_114ck400 FIND v(dout0_114) AT=205.025n

.meas tran vdout0_115ck400 FIND v(dout0_115) AT=205.025n

.meas tran vdout0_116ck400 FIND v(dout0_116) AT=205.025n

.meas tran vdout0_117ck400 FIND v(dout0_117) AT=205.025n

.meas tran vdout0_118ck400 FIND v(dout0_118) AT=205.025n

.meas tran vdout0_119ck400 FIND v(dout0_119) AT=205.025n

.meas tran vdout0_120ck400 FIND v(dout0_120) AT=205.025n

.meas tran vdout0_121ck400 FIND v(dout0_121) AT=205.025n

.meas tran vdout0_122ck400 FIND v(dout0_122) AT=205.025n

.meas tran vdout0_123ck400 FIND v(dout0_123) AT=205.025n

.meas tran vdout0_124ck400 FIND v(dout0_124) AT=205.025n

.meas tran vdout0_125ck400 FIND v(dout0_125) AT=205.025n

.meas tran vdout0_126ck400 FIND v(dout0_126) AT=205.025n

.meas tran vdout0_127ck400 FIND v(dout0_127) AT=205.025n

.meas tran vdout0_128ck400 FIND v(dout0_128) AT=205.025n

.meas tran vdout0_129ck400 FIND v(dout0_129) AT=205.025n

.meas tran vdout0_130ck400 FIND v(dout0_130) AT=205.025n

.meas tran vdout0_131ck400 FIND v(dout0_131) AT=205.025n

.meas tran vdout0_132ck400 FIND v(dout0_132) AT=205.025n

.meas tran vdout0_133ck400 FIND v(dout0_133) AT=205.025n

.meas tran vdout0_134ck400 FIND v(dout0_134) AT=205.025n

.meas tran vdout0_135ck400 FIND v(dout0_135) AT=205.025n

.meas tran vdout0_136ck400 FIND v(dout0_136) AT=205.025n

.meas tran vdout0_137ck400 FIND v(dout0_137) AT=205.025n

.meas tran vdout0_138ck400 FIND v(dout0_138) AT=205.025n

.meas tran vdout0_139ck400 FIND v(dout0_139) AT=205.025n

.meas tran vdout0_140ck400 FIND v(dout0_140) AT=205.025n

.meas tran vdout0_141ck400 FIND v(dout0_141) AT=205.025n

.meas tran vdout0_142ck400 FIND v(dout0_142) AT=205.025n

.meas tran vdout0_143ck400 FIND v(dout0_143) AT=205.025n

.meas tran vdout0_144ck400 FIND v(dout0_144) AT=205.025n

.meas tran vdout0_145ck400 FIND v(dout0_145) AT=205.025n

.meas tran vdout0_146ck400 FIND v(dout0_146) AT=205.025n

.meas tran vdout0_147ck400 FIND v(dout0_147) AT=205.025n

.meas tran vdout0_148ck400 FIND v(dout0_148) AT=205.025n

.meas tran vdout0_149ck400 FIND v(dout0_149) AT=205.025n

.meas tran vdout0_0ck420 FIND v(dout0_0) AT=215.025n

.meas tran vdout0_1ck420 FIND v(dout0_1) AT=215.025n

.meas tran vdout0_2ck420 FIND v(dout0_2) AT=215.025n

.meas tran vdout0_3ck420 FIND v(dout0_3) AT=215.025n

.meas tran vdout0_4ck420 FIND v(dout0_4) AT=215.025n

.meas tran vdout0_5ck420 FIND v(dout0_5) AT=215.025n

.meas tran vdout0_6ck420 FIND v(dout0_6) AT=215.025n

.meas tran vdout0_7ck420 FIND v(dout0_7) AT=215.025n

.meas tran vdout0_8ck420 FIND v(dout0_8) AT=215.025n

.meas tran vdout0_9ck420 FIND v(dout0_9) AT=215.025n

.meas tran vdout0_10ck420 FIND v(dout0_10) AT=215.025n

.meas tran vdout0_11ck420 FIND v(dout0_11) AT=215.025n

.meas tran vdout0_12ck420 FIND v(dout0_12) AT=215.025n

.meas tran vdout0_13ck420 FIND v(dout0_13) AT=215.025n

.meas tran vdout0_14ck420 FIND v(dout0_14) AT=215.025n

.meas tran vdout0_15ck420 FIND v(dout0_15) AT=215.025n

.meas tran vdout0_16ck420 FIND v(dout0_16) AT=215.025n

.meas tran vdout0_17ck420 FIND v(dout0_17) AT=215.025n

.meas tran vdout0_18ck420 FIND v(dout0_18) AT=215.025n

.meas tran vdout0_19ck420 FIND v(dout0_19) AT=215.025n

.meas tran vdout0_20ck420 FIND v(dout0_20) AT=215.025n

.meas tran vdout0_21ck420 FIND v(dout0_21) AT=215.025n

.meas tran vdout0_22ck420 FIND v(dout0_22) AT=215.025n

.meas tran vdout0_23ck420 FIND v(dout0_23) AT=215.025n

.meas tran vdout0_24ck420 FIND v(dout0_24) AT=215.025n

.meas tran vdout0_25ck420 FIND v(dout0_25) AT=215.025n

.meas tran vdout0_26ck420 FIND v(dout0_26) AT=215.025n

.meas tran vdout0_27ck420 FIND v(dout0_27) AT=215.025n

.meas tran vdout0_28ck420 FIND v(dout0_28) AT=215.025n

.meas tran vdout0_29ck420 FIND v(dout0_29) AT=215.025n

.meas tran vdout0_30ck420 FIND v(dout0_30) AT=215.025n

.meas tran vdout0_31ck420 FIND v(dout0_31) AT=215.025n

.meas tran vdout0_32ck420 FIND v(dout0_32) AT=215.025n

.meas tran vdout0_33ck420 FIND v(dout0_33) AT=215.025n

.meas tran vdout0_34ck420 FIND v(dout0_34) AT=215.025n

.meas tran vdout0_35ck420 FIND v(dout0_35) AT=215.025n

.meas tran vdout0_36ck420 FIND v(dout0_36) AT=215.025n

.meas tran vdout0_37ck420 FIND v(dout0_37) AT=215.025n

.meas tran vdout0_38ck420 FIND v(dout0_38) AT=215.025n

.meas tran vdout0_39ck420 FIND v(dout0_39) AT=215.025n

.meas tran vdout0_40ck420 FIND v(dout0_40) AT=215.025n

.meas tran vdout0_41ck420 FIND v(dout0_41) AT=215.025n

.meas tran vdout0_42ck420 FIND v(dout0_42) AT=215.025n

.meas tran vdout0_43ck420 FIND v(dout0_43) AT=215.025n

.meas tran vdout0_44ck420 FIND v(dout0_44) AT=215.025n

.meas tran vdout0_45ck420 FIND v(dout0_45) AT=215.025n

.meas tran vdout0_46ck420 FIND v(dout0_46) AT=215.025n

.meas tran vdout0_47ck420 FIND v(dout0_47) AT=215.025n

.meas tran vdout0_48ck420 FIND v(dout0_48) AT=215.025n

.meas tran vdout0_49ck420 FIND v(dout0_49) AT=215.025n

.meas tran vdout0_50ck420 FIND v(dout0_50) AT=215.025n

.meas tran vdout0_51ck420 FIND v(dout0_51) AT=215.025n

.meas tran vdout0_52ck420 FIND v(dout0_52) AT=215.025n

.meas tran vdout0_53ck420 FIND v(dout0_53) AT=215.025n

.meas tran vdout0_54ck420 FIND v(dout0_54) AT=215.025n

.meas tran vdout0_55ck420 FIND v(dout0_55) AT=215.025n

.meas tran vdout0_56ck420 FIND v(dout0_56) AT=215.025n

.meas tran vdout0_57ck420 FIND v(dout0_57) AT=215.025n

.meas tran vdout0_58ck420 FIND v(dout0_58) AT=215.025n

.meas tran vdout0_59ck420 FIND v(dout0_59) AT=215.025n

.meas tran vdout0_60ck420 FIND v(dout0_60) AT=215.025n

.meas tran vdout0_61ck420 FIND v(dout0_61) AT=215.025n

.meas tran vdout0_62ck420 FIND v(dout0_62) AT=215.025n

.meas tran vdout0_63ck420 FIND v(dout0_63) AT=215.025n

.meas tran vdout0_64ck420 FIND v(dout0_64) AT=215.025n

.meas tran vdout0_65ck420 FIND v(dout0_65) AT=215.025n

.meas tran vdout0_66ck420 FIND v(dout0_66) AT=215.025n

.meas tran vdout0_67ck420 FIND v(dout0_67) AT=215.025n

.meas tran vdout0_68ck420 FIND v(dout0_68) AT=215.025n

.meas tran vdout0_69ck420 FIND v(dout0_69) AT=215.025n

.meas tran vdout0_70ck420 FIND v(dout0_70) AT=215.025n

.meas tran vdout0_71ck420 FIND v(dout0_71) AT=215.025n

.meas tran vdout0_72ck420 FIND v(dout0_72) AT=215.025n

.meas tran vdout0_73ck420 FIND v(dout0_73) AT=215.025n

.meas tran vdout0_74ck420 FIND v(dout0_74) AT=215.025n

.meas tran vdout0_75ck420 FIND v(dout0_75) AT=215.025n

.meas tran vdout0_76ck420 FIND v(dout0_76) AT=215.025n

.meas tran vdout0_77ck420 FIND v(dout0_77) AT=215.025n

.meas tran vdout0_78ck420 FIND v(dout0_78) AT=215.025n

.meas tran vdout0_79ck420 FIND v(dout0_79) AT=215.025n

.meas tran vdout0_80ck420 FIND v(dout0_80) AT=215.025n

.meas tran vdout0_81ck420 FIND v(dout0_81) AT=215.025n

.meas tran vdout0_82ck420 FIND v(dout0_82) AT=215.025n

.meas tran vdout0_83ck420 FIND v(dout0_83) AT=215.025n

.meas tran vdout0_84ck420 FIND v(dout0_84) AT=215.025n

.meas tran vdout0_85ck420 FIND v(dout0_85) AT=215.025n

.meas tran vdout0_86ck420 FIND v(dout0_86) AT=215.025n

.meas tran vdout0_87ck420 FIND v(dout0_87) AT=215.025n

.meas tran vdout0_88ck420 FIND v(dout0_88) AT=215.025n

.meas tran vdout0_89ck420 FIND v(dout0_89) AT=215.025n

.meas tran vdout0_90ck420 FIND v(dout0_90) AT=215.025n

.meas tran vdout0_91ck420 FIND v(dout0_91) AT=215.025n

.meas tran vdout0_92ck420 FIND v(dout0_92) AT=215.025n

.meas tran vdout0_93ck420 FIND v(dout0_93) AT=215.025n

.meas tran vdout0_94ck420 FIND v(dout0_94) AT=215.025n

.meas tran vdout0_95ck420 FIND v(dout0_95) AT=215.025n

.meas tran vdout0_96ck420 FIND v(dout0_96) AT=215.025n

.meas tran vdout0_97ck420 FIND v(dout0_97) AT=215.025n

.meas tran vdout0_98ck420 FIND v(dout0_98) AT=215.025n

.meas tran vdout0_99ck420 FIND v(dout0_99) AT=215.025n

.meas tran vdout0_100ck420 FIND v(dout0_100) AT=215.025n

.meas tran vdout0_101ck420 FIND v(dout0_101) AT=215.025n

.meas tran vdout0_102ck420 FIND v(dout0_102) AT=215.025n

.meas tran vdout0_103ck420 FIND v(dout0_103) AT=215.025n

.meas tran vdout0_104ck420 FIND v(dout0_104) AT=215.025n

.meas tran vdout0_105ck420 FIND v(dout0_105) AT=215.025n

.meas tran vdout0_106ck420 FIND v(dout0_106) AT=215.025n

.meas tran vdout0_107ck420 FIND v(dout0_107) AT=215.025n

.meas tran vdout0_108ck420 FIND v(dout0_108) AT=215.025n

.meas tran vdout0_109ck420 FIND v(dout0_109) AT=215.025n

.meas tran vdout0_110ck420 FIND v(dout0_110) AT=215.025n

.meas tran vdout0_111ck420 FIND v(dout0_111) AT=215.025n

.meas tran vdout0_112ck420 FIND v(dout0_112) AT=215.025n

.meas tran vdout0_113ck420 FIND v(dout0_113) AT=215.025n

.meas tran vdout0_114ck420 FIND v(dout0_114) AT=215.025n

.meas tran vdout0_115ck420 FIND v(dout0_115) AT=215.025n

.meas tran vdout0_116ck420 FIND v(dout0_116) AT=215.025n

.meas tran vdout0_117ck420 FIND v(dout0_117) AT=215.025n

.meas tran vdout0_118ck420 FIND v(dout0_118) AT=215.025n

.meas tran vdout0_119ck420 FIND v(dout0_119) AT=215.025n

.meas tran vdout0_120ck420 FIND v(dout0_120) AT=215.025n

.meas tran vdout0_121ck420 FIND v(dout0_121) AT=215.025n

.meas tran vdout0_122ck420 FIND v(dout0_122) AT=215.025n

.meas tran vdout0_123ck420 FIND v(dout0_123) AT=215.025n

.meas tran vdout0_124ck420 FIND v(dout0_124) AT=215.025n

.meas tran vdout0_125ck420 FIND v(dout0_125) AT=215.025n

.meas tran vdout0_126ck420 FIND v(dout0_126) AT=215.025n

.meas tran vdout0_127ck420 FIND v(dout0_127) AT=215.025n

.meas tran vdout0_128ck420 FIND v(dout0_128) AT=215.025n

.meas tran vdout0_129ck420 FIND v(dout0_129) AT=215.025n

.meas tran vdout0_130ck420 FIND v(dout0_130) AT=215.025n

.meas tran vdout0_131ck420 FIND v(dout0_131) AT=215.025n

.meas tran vdout0_132ck420 FIND v(dout0_132) AT=215.025n

.meas tran vdout0_133ck420 FIND v(dout0_133) AT=215.025n

.meas tran vdout0_134ck420 FIND v(dout0_134) AT=215.025n

.meas tran vdout0_135ck420 FIND v(dout0_135) AT=215.025n

.meas tran vdout0_136ck420 FIND v(dout0_136) AT=215.025n

.meas tran vdout0_137ck420 FIND v(dout0_137) AT=215.025n

.meas tran vdout0_138ck420 FIND v(dout0_138) AT=215.025n

.meas tran vdout0_139ck420 FIND v(dout0_139) AT=215.025n

.meas tran vdout0_140ck420 FIND v(dout0_140) AT=215.025n

.meas tran vdout0_141ck420 FIND v(dout0_141) AT=215.025n

.meas tran vdout0_142ck420 FIND v(dout0_142) AT=215.025n

.meas tran vdout0_143ck420 FIND v(dout0_143) AT=215.025n

.meas tran vdout0_144ck420 FIND v(dout0_144) AT=215.025n

.meas tran vdout0_145ck420 FIND v(dout0_145) AT=215.025n

.meas tran vdout0_146ck420 FIND v(dout0_146) AT=215.025n

.meas tran vdout0_147ck420 FIND v(dout0_147) AT=215.025n

.meas tran vdout0_148ck420 FIND v(dout0_148) AT=215.025n

.meas tran vdout0_149ck420 FIND v(dout0_149) AT=215.025n

.meas tran vdout0_0ck430 FIND v(dout0_0) AT=220.025n

.meas tran vdout0_1ck430 FIND v(dout0_1) AT=220.025n

.meas tran vdout0_2ck430 FIND v(dout0_2) AT=220.025n

.meas tran vdout0_3ck430 FIND v(dout0_3) AT=220.025n

.meas tran vdout0_4ck430 FIND v(dout0_4) AT=220.025n

.meas tran vdout0_5ck430 FIND v(dout0_5) AT=220.025n

.meas tran vdout0_6ck430 FIND v(dout0_6) AT=220.025n

.meas tran vdout0_7ck430 FIND v(dout0_7) AT=220.025n

.meas tran vdout0_8ck430 FIND v(dout0_8) AT=220.025n

.meas tran vdout0_9ck430 FIND v(dout0_9) AT=220.025n

.meas tran vdout0_10ck430 FIND v(dout0_10) AT=220.025n

.meas tran vdout0_11ck430 FIND v(dout0_11) AT=220.025n

.meas tran vdout0_12ck430 FIND v(dout0_12) AT=220.025n

.meas tran vdout0_13ck430 FIND v(dout0_13) AT=220.025n

.meas tran vdout0_14ck430 FIND v(dout0_14) AT=220.025n

.meas tran vdout0_15ck430 FIND v(dout0_15) AT=220.025n

.meas tran vdout0_16ck430 FIND v(dout0_16) AT=220.025n

.meas tran vdout0_17ck430 FIND v(dout0_17) AT=220.025n

.meas tran vdout0_18ck430 FIND v(dout0_18) AT=220.025n

.meas tran vdout0_19ck430 FIND v(dout0_19) AT=220.025n

.meas tran vdout0_20ck430 FIND v(dout0_20) AT=220.025n

.meas tran vdout0_21ck430 FIND v(dout0_21) AT=220.025n

.meas tran vdout0_22ck430 FIND v(dout0_22) AT=220.025n

.meas tran vdout0_23ck430 FIND v(dout0_23) AT=220.025n

.meas tran vdout0_24ck430 FIND v(dout0_24) AT=220.025n

.meas tran vdout0_25ck430 FIND v(dout0_25) AT=220.025n

.meas tran vdout0_26ck430 FIND v(dout0_26) AT=220.025n

.meas tran vdout0_27ck430 FIND v(dout0_27) AT=220.025n

.meas tran vdout0_28ck430 FIND v(dout0_28) AT=220.025n

.meas tran vdout0_29ck430 FIND v(dout0_29) AT=220.025n

.meas tran vdout0_30ck430 FIND v(dout0_30) AT=220.025n

.meas tran vdout0_31ck430 FIND v(dout0_31) AT=220.025n

.meas tran vdout0_32ck430 FIND v(dout0_32) AT=220.025n

.meas tran vdout0_33ck430 FIND v(dout0_33) AT=220.025n

.meas tran vdout0_34ck430 FIND v(dout0_34) AT=220.025n

.meas tran vdout0_35ck430 FIND v(dout0_35) AT=220.025n

.meas tran vdout0_36ck430 FIND v(dout0_36) AT=220.025n

.meas tran vdout0_37ck430 FIND v(dout0_37) AT=220.025n

.meas tran vdout0_38ck430 FIND v(dout0_38) AT=220.025n

.meas tran vdout0_39ck430 FIND v(dout0_39) AT=220.025n

.meas tran vdout0_40ck430 FIND v(dout0_40) AT=220.025n

.meas tran vdout0_41ck430 FIND v(dout0_41) AT=220.025n

.meas tran vdout0_42ck430 FIND v(dout0_42) AT=220.025n

.meas tran vdout0_43ck430 FIND v(dout0_43) AT=220.025n

.meas tran vdout0_44ck430 FIND v(dout0_44) AT=220.025n

.meas tran vdout0_45ck430 FIND v(dout0_45) AT=220.025n

.meas tran vdout0_46ck430 FIND v(dout0_46) AT=220.025n

.meas tran vdout0_47ck430 FIND v(dout0_47) AT=220.025n

.meas tran vdout0_48ck430 FIND v(dout0_48) AT=220.025n

.meas tran vdout0_49ck430 FIND v(dout0_49) AT=220.025n

.meas tran vdout0_50ck430 FIND v(dout0_50) AT=220.025n

.meas tran vdout0_51ck430 FIND v(dout0_51) AT=220.025n

.meas tran vdout0_52ck430 FIND v(dout0_52) AT=220.025n

.meas tran vdout0_53ck430 FIND v(dout0_53) AT=220.025n

.meas tran vdout0_54ck430 FIND v(dout0_54) AT=220.025n

.meas tran vdout0_55ck430 FIND v(dout0_55) AT=220.025n

.meas tran vdout0_56ck430 FIND v(dout0_56) AT=220.025n

.meas tran vdout0_57ck430 FIND v(dout0_57) AT=220.025n

.meas tran vdout0_58ck430 FIND v(dout0_58) AT=220.025n

.meas tran vdout0_59ck430 FIND v(dout0_59) AT=220.025n

.meas tran vdout0_60ck430 FIND v(dout0_60) AT=220.025n

.meas tran vdout0_61ck430 FIND v(dout0_61) AT=220.025n

.meas tran vdout0_62ck430 FIND v(dout0_62) AT=220.025n

.meas tran vdout0_63ck430 FIND v(dout0_63) AT=220.025n

.meas tran vdout0_64ck430 FIND v(dout0_64) AT=220.025n

.meas tran vdout0_65ck430 FIND v(dout0_65) AT=220.025n

.meas tran vdout0_66ck430 FIND v(dout0_66) AT=220.025n

.meas tran vdout0_67ck430 FIND v(dout0_67) AT=220.025n

.meas tran vdout0_68ck430 FIND v(dout0_68) AT=220.025n

.meas tran vdout0_69ck430 FIND v(dout0_69) AT=220.025n

.meas tran vdout0_70ck430 FIND v(dout0_70) AT=220.025n

.meas tran vdout0_71ck430 FIND v(dout0_71) AT=220.025n

.meas tran vdout0_72ck430 FIND v(dout0_72) AT=220.025n

.meas tran vdout0_73ck430 FIND v(dout0_73) AT=220.025n

.meas tran vdout0_74ck430 FIND v(dout0_74) AT=220.025n

.meas tran vdout0_75ck430 FIND v(dout0_75) AT=220.025n

.meas tran vdout0_76ck430 FIND v(dout0_76) AT=220.025n

.meas tran vdout0_77ck430 FIND v(dout0_77) AT=220.025n

.meas tran vdout0_78ck430 FIND v(dout0_78) AT=220.025n

.meas tran vdout0_79ck430 FIND v(dout0_79) AT=220.025n

.meas tran vdout0_80ck430 FIND v(dout0_80) AT=220.025n

.meas tran vdout0_81ck430 FIND v(dout0_81) AT=220.025n

.meas tran vdout0_82ck430 FIND v(dout0_82) AT=220.025n

.meas tran vdout0_83ck430 FIND v(dout0_83) AT=220.025n

.meas tran vdout0_84ck430 FIND v(dout0_84) AT=220.025n

.meas tran vdout0_85ck430 FIND v(dout0_85) AT=220.025n

.meas tran vdout0_86ck430 FIND v(dout0_86) AT=220.025n

.meas tran vdout0_87ck430 FIND v(dout0_87) AT=220.025n

.meas tran vdout0_88ck430 FIND v(dout0_88) AT=220.025n

.meas tran vdout0_89ck430 FIND v(dout0_89) AT=220.025n

.meas tran vdout0_90ck430 FIND v(dout0_90) AT=220.025n

.meas tran vdout0_91ck430 FIND v(dout0_91) AT=220.025n

.meas tran vdout0_92ck430 FIND v(dout0_92) AT=220.025n

.meas tran vdout0_93ck430 FIND v(dout0_93) AT=220.025n

.meas tran vdout0_94ck430 FIND v(dout0_94) AT=220.025n

.meas tran vdout0_95ck430 FIND v(dout0_95) AT=220.025n

.meas tran vdout0_96ck430 FIND v(dout0_96) AT=220.025n

.meas tran vdout0_97ck430 FIND v(dout0_97) AT=220.025n

.meas tran vdout0_98ck430 FIND v(dout0_98) AT=220.025n

.meas tran vdout0_99ck430 FIND v(dout0_99) AT=220.025n

.meas tran vdout0_100ck430 FIND v(dout0_100) AT=220.025n

.meas tran vdout0_101ck430 FIND v(dout0_101) AT=220.025n

.meas tran vdout0_102ck430 FIND v(dout0_102) AT=220.025n

.meas tran vdout0_103ck430 FIND v(dout0_103) AT=220.025n

.meas tran vdout0_104ck430 FIND v(dout0_104) AT=220.025n

.meas tran vdout0_105ck430 FIND v(dout0_105) AT=220.025n

.meas tran vdout0_106ck430 FIND v(dout0_106) AT=220.025n

.meas tran vdout0_107ck430 FIND v(dout0_107) AT=220.025n

.meas tran vdout0_108ck430 FIND v(dout0_108) AT=220.025n

.meas tran vdout0_109ck430 FIND v(dout0_109) AT=220.025n

.meas tran vdout0_110ck430 FIND v(dout0_110) AT=220.025n

.meas tran vdout0_111ck430 FIND v(dout0_111) AT=220.025n

.meas tran vdout0_112ck430 FIND v(dout0_112) AT=220.025n

.meas tran vdout0_113ck430 FIND v(dout0_113) AT=220.025n

.meas tran vdout0_114ck430 FIND v(dout0_114) AT=220.025n

.meas tran vdout0_115ck430 FIND v(dout0_115) AT=220.025n

.meas tran vdout0_116ck430 FIND v(dout0_116) AT=220.025n

.meas tran vdout0_117ck430 FIND v(dout0_117) AT=220.025n

.meas tran vdout0_118ck430 FIND v(dout0_118) AT=220.025n

.meas tran vdout0_119ck430 FIND v(dout0_119) AT=220.025n

.meas tran vdout0_120ck430 FIND v(dout0_120) AT=220.025n

.meas tran vdout0_121ck430 FIND v(dout0_121) AT=220.025n

.meas tran vdout0_122ck430 FIND v(dout0_122) AT=220.025n

.meas tran vdout0_123ck430 FIND v(dout0_123) AT=220.025n

.meas tran vdout0_124ck430 FIND v(dout0_124) AT=220.025n

.meas tran vdout0_125ck430 FIND v(dout0_125) AT=220.025n

.meas tran vdout0_126ck430 FIND v(dout0_126) AT=220.025n

.meas tran vdout0_127ck430 FIND v(dout0_127) AT=220.025n

.meas tran vdout0_128ck430 FIND v(dout0_128) AT=220.025n

.meas tran vdout0_129ck430 FIND v(dout0_129) AT=220.025n

.meas tran vdout0_130ck430 FIND v(dout0_130) AT=220.025n

.meas tran vdout0_131ck430 FIND v(dout0_131) AT=220.025n

.meas tran vdout0_132ck430 FIND v(dout0_132) AT=220.025n

.meas tran vdout0_133ck430 FIND v(dout0_133) AT=220.025n

.meas tran vdout0_134ck430 FIND v(dout0_134) AT=220.025n

.meas tran vdout0_135ck430 FIND v(dout0_135) AT=220.025n

.meas tran vdout0_136ck430 FIND v(dout0_136) AT=220.025n

.meas tran vdout0_137ck430 FIND v(dout0_137) AT=220.025n

.meas tran vdout0_138ck430 FIND v(dout0_138) AT=220.025n

.meas tran vdout0_139ck430 FIND v(dout0_139) AT=220.025n

.meas tran vdout0_140ck430 FIND v(dout0_140) AT=220.025n

.meas tran vdout0_141ck430 FIND v(dout0_141) AT=220.025n

.meas tran vdout0_142ck430 FIND v(dout0_142) AT=220.025n

.meas tran vdout0_143ck430 FIND v(dout0_143) AT=220.025n

.meas tran vdout0_144ck430 FIND v(dout0_144) AT=220.025n

.meas tran vdout0_145ck430 FIND v(dout0_145) AT=220.025n

.meas tran vdout0_146ck430 FIND v(dout0_146) AT=220.025n

.meas tran vdout0_147ck430 FIND v(dout0_147) AT=220.025n

.meas tran vdout0_148ck430 FIND v(dout0_148) AT=220.025n

.meas tran vdout0_149ck430 FIND v(dout0_149) AT=220.025n

.meas tran vdout0_0ck450 FIND v(dout0_0) AT=230.025n

.meas tran vdout0_1ck450 FIND v(dout0_1) AT=230.025n

.meas tran vdout0_2ck450 FIND v(dout0_2) AT=230.025n

.meas tran vdout0_3ck450 FIND v(dout0_3) AT=230.025n

.meas tran vdout0_4ck450 FIND v(dout0_4) AT=230.025n

.meas tran vdout0_5ck450 FIND v(dout0_5) AT=230.025n

.meas tran vdout0_6ck450 FIND v(dout0_6) AT=230.025n

.meas tran vdout0_7ck450 FIND v(dout0_7) AT=230.025n

.meas tran vdout0_8ck450 FIND v(dout0_8) AT=230.025n

.meas tran vdout0_9ck450 FIND v(dout0_9) AT=230.025n

.meas tran vdout0_10ck450 FIND v(dout0_10) AT=230.025n

.meas tran vdout0_11ck450 FIND v(dout0_11) AT=230.025n

.meas tran vdout0_12ck450 FIND v(dout0_12) AT=230.025n

.meas tran vdout0_13ck450 FIND v(dout0_13) AT=230.025n

.meas tran vdout0_14ck450 FIND v(dout0_14) AT=230.025n

.meas tran vdout0_15ck450 FIND v(dout0_15) AT=230.025n

.meas tran vdout0_16ck450 FIND v(dout0_16) AT=230.025n

.meas tran vdout0_17ck450 FIND v(dout0_17) AT=230.025n

.meas tran vdout0_18ck450 FIND v(dout0_18) AT=230.025n

.meas tran vdout0_19ck450 FIND v(dout0_19) AT=230.025n

.meas tran vdout0_20ck450 FIND v(dout0_20) AT=230.025n

.meas tran vdout0_21ck450 FIND v(dout0_21) AT=230.025n

.meas tran vdout0_22ck450 FIND v(dout0_22) AT=230.025n

.meas tran vdout0_23ck450 FIND v(dout0_23) AT=230.025n

.meas tran vdout0_24ck450 FIND v(dout0_24) AT=230.025n

.meas tran vdout0_25ck450 FIND v(dout0_25) AT=230.025n

.meas tran vdout0_26ck450 FIND v(dout0_26) AT=230.025n

.meas tran vdout0_27ck450 FIND v(dout0_27) AT=230.025n

.meas tran vdout0_28ck450 FIND v(dout0_28) AT=230.025n

.meas tran vdout0_29ck450 FIND v(dout0_29) AT=230.025n

.meas tran vdout0_30ck450 FIND v(dout0_30) AT=230.025n

.meas tran vdout0_31ck450 FIND v(dout0_31) AT=230.025n

.meas tran vdout0_32ck450 FIND v(dout0_32) AT=230.025n

.meas tran vdout0_33ck450 FIND v(dout0_33) AT=230.025n

.meas tran vdout0_34ck450 FIND v(dout0_34) AT=230.025n

.meas tran vdout0_35ck450 FIND v(dout0_35) AT=230.025n

.meas tran vdout0_36ck450 FIND v(dout0_36) AT=230.025n

.meas tran vdout0_37ck450 FIND v(dout0_37) AT=230.025n

.meas tran vdout0_38ck450 FIND v(dout0_38) AT=230.025n

.meas tran vdout0_39ck450 FIND v(dout0_39) AT=230.025n

.meas tran vdout0_40ck450 FIND v(dout0_40) AT=230.025n

.meas tran vdout0_41ck450 FIND v(dout0_41) AT=230.025n

.meas tran vdout0_42ck450 FIND v(dout0_42) AT=230.025n

.meas tran vdout0_43ck450 FIND v(dout0_43) AT=230.025n

.meas tran vdout0_44ck450 FIND v(dout0_44) AT=230.025n

.meas tran vdout0_45ck450 FIND v(dout0_45) AT=230.025n

.meas tran vdout0_46ck450 FIND v(dout0_46) AT=230.025n

.meas tran vdout0_47ck450 FIND v(dout0_47) AT=230.025n

.meas tran vdout0_48ck450 FIND v(dout0_48) AT=230.025n

.meas tran vdout0_49ck450 FIND v(dout0_49) AT=230.025n

.meas tran vdout0_50ck450 FIND v(dout0_50) AT=230.025n

.meas tran vdout0_51ck450 FIND v(dout0_51) AT=230.025n

.meas tran vdout0_52ck450 FIND v(dout0_52) AT=230.025n

.meas tran vdout0_53ck450 FIND v(dout0_53) AT=230.025n

.meas tran vdout0_54ck450 FIND v(dout0_54) AT=230.025n

.meas tran vdout0_55ck450 FIND v(dout0_55) AT=230.025n

.meas tran vdout0_56ck450 FIND v(dout0_56) AT=230.025n

.meas tran vdout0_57ck450 FIND v(dout0_57) AT=230.025n

.meas tran vdout0_58ck450 FIND v(dout0_58) AT=230.025n

.meas tran vdout0_59ck450 FIND v(dout0_59) AT=230.025n

.meas tran vdout0_60ck450 FIND v(dout0_60) AT=230.025n

.meas tran vdout0_61ck450 FIND v(dout0_61) AT=230.025n

.meas tran vdout0_62ck450 FIND v(dout0_62) AT=230.025n

.meas tran vdout0_63ck450 FIND v(dout0_63) AT=230.025n

.meas tran vdout0_64ck450 FIND v(dout0_64) AT=230.025n

.meas tran vdout0_65ck450 FIND v(dout0_65) AT=230.025n

.meas tran vdout0_66ck450 FIND v(dout0_66) AT=230.025n

.meas tran vdout0_67ck450 FIND v(dout0_67) AT=230.025n

.meas tran vdout0_68ck450 FIND v(dout0_68) AT=230.025n

.meas tran vdout0_69ck450 FIND v(dout0_69) AT=230.025n

.meas tran vdout0_70ck450 FIND v(dout0_70) AT=230.025n

.meas tran vdout0_71ck450 FIND v(dout0_71) AT=230.025n

.meas tran vdout0_72ck450 FIND v(dout0_72) AT=230.025n

.meas tran vdout0_73ck450 FIND v(dout0_73) AT=230.025n

.meas tran vdout0_74ck450 FIND v(dout0_74) AT=230.025n

.meas tran vdout0_75ck450 FIND v(dout0_75) AT=230.025n

.meas tran vdout0_76ck450 FIND v(dout0_76) AT=230.025n

.meas tran vdout0_77ck450 FIND v(dout0_77) AT=230.025n

.meas tran vdout0_78ck450 FIND v(dout0_78) AT=230.025n

.meas tran vdout0_79ck450 FIND v(dout0_79) AT=230.025n

.meas tran vdout0_80ck450 FIND v(dout0_80) AT=230.025n

.meas tran vdout0_81ck450 FIND v(dout0_81) AT=230.025n

.meas tran vdout0_82ck450 FIND v(dout0_82) AT=230.025n

.meas tran vdout0_83ck450 FIND v(dout0_83) AT=230.025n

.meas tran vdout0_84ck450 FIND v(dout0_84) AT=230.025n

.meas tran vdout0_85ck450 FIND v(dout0_85) AT=230.025n

.meas tran vdout0_86ck450 FIND v(dout0_86) AT=230.025n

.meas tran vdout0_87ck450 FIND v(dout0_87) AT=230.025n

.meas tran vdout0_88ck450 FIND v(dout0_88) AT=230.025n

.meas tran vdout0_89ck450 FIND v(dout0_89) AT=230.025n

.meas tran vdout0_90ck450 FIND v(dout0_90) AT=230.025n

.meas tran vdout0_91ck450 FIND v(dout0_91) AT=230.025n

.meas tran vdout0_92ck450 FIND v(dout0_92) AT=230.025n

.meas tran vdout0_93ck450 FIND v(dout0_93) AT=230.025n

.meas tran vdout0_94ck450 FIND v(dout0_94) AT=230.025n

.meas tran vdout0_95ck450 FIND v(dout0_95) AT=230.025n

.meas tran vdout0_96ck450 FIND v(dout0_96) AT=230.025n

.meas tran vdout0_97ck450 FIND v(dout0_97) AT=230.025n

.meas tran vdout0_98ck450 FIND v(dout0_98) AT=230.025n

.meas tran vdout0_99ck450 FIND v(dout0_99) AT=230.025n

.meas tran vdout0_100ck450 FIND v(dout0_100) AT=230.025n

.meas tran vdout0_101ck450 FIND v(dout0_101) AT=230.025n

.meas tran vdout0_102ck450 FIND v(dout0_102) AT=230.025n

.meas tran vdout0_103ck450 FIND v(dout0_103) AT=230.025n

.meas tran vdout0_104ck450 FIND v(dout0_104) AT=230.025n

.meas tran vdout0_105ck450 FIND v(dout0_105) AT=230.025n

.meas tran vdout0_106ck450 FIND v(dout0_106) AT=230.025n

.meas tran vdout0_107ck450 FIND v(dout0_107) AT=230.025n

.meas tran vdout0_108ck450 FIND v(dout0_108) AT=230.025n

.meas tran vdout0_109ck450 FIND v(dout0_109) AT=230.025n

.meas tran vdout0_110ck450 FIND v(dout0_110) AT=230.025n

.meas tran vdout0_111ck450 FIND v(dout0_111) AT=230.025n

.meas tran vdout0_112ck450 FIND v(dout0_112) AT=230.025n

.meas tran vdout0_113ck450 FIND v(dout0_113) AT=230.025n

.meas tran vdout0_114ck450 FIND v(dout0_114) AT=230.025n

.meas tran vdout0_115ck450 FIND v(dout0_115) AT=230.025n

.meas tran vdout0_116ck450 FIND v(dout0_116) AT=230.025n

.meas tran vdout0_117ck450 FIND v(dout0_117) AT=230.025n

.meas tran vdout0_118ck450 FIND v(dout0_118) AT=230.025n

.meas tran vdout0_119ck450 FIND v(dout0_119) AT=230.025n

.meas tran vdout0_120ck450 FIND v(dout0_120) AT=230.025n

.meas tran vdout0_121ck450 FIND v(dout0_121) AT=230.025n

.meas tran vdout0_122ck450 FIND v(dout0_122) AT=230.025n

.meas tran vdout0_123ck450 FIND v(dout0_123) AT=230.025n

.meas tran vdout0_124ck450 FIND v(dout0_124) AT=230.025n

.meas tran vdout0_125ck450 FIND v(dout0_125) AT=230.025n

.meas tran vdout0_126ck450 FIND v(dout0_126) AT=230.025n

.meas tran vdout0_127ck450 FIND v(dout0_127) AT=230.025n

.meas tran vdout0_128ck450 FIND v(dout0_128) AT=230.025n

.meas tran vdout0_129ck450 FIND v(dout0_129) AT=230.025n

.meas tran vdout0_130ck450 FIND v(dout0_130) AT=230.025n

.meas tran vdout0_131ck450 FIND v(dout0_131) AT=230.025n

.meas tran vdout0_132ck450 FIND v(dout0_132) AT=230.025n

.meas tran vdout0_133ck450 FIND v(dout0_133) AT=230.025n

.meas tran vdout0_134ck450 FIND v(dout0_134) AT=230.025n

.meas tran vdout0_135ck450 FIND v(dout0_135) AT=230.025n

.meas tran vdout0_136ck450 FIND v(dout0_136) AT=230.025n

.meas tran vdout0_137ck450 FIND v(dout0_137) AT=230.025n

.meas tran vdout0_138ck450 FIND v(dout0_138) AT=230.025n

.meas tran vdout0_139ck450 FIND v(dout0_139) AT=230.025n

.meas tran vdout0_140ck450 FIND v(dout0_140) AT=230.025n

.meas tran vdout0_141ck450 FIND v(dout0_141) AT=230.025n

.meas tran vdout0_142ck450 FIND v(dout0_142) AT=230.025n

.meas tran vdout0_143ck450 FIND v(dout0_143) AT=230.025n

.meas tran vdout0_144ck450 FIND v(dout0_144) AT=230.025n

.meas tran vdout0_145ck450 FIND v(dout0_145) AT=230.025n

.meas tran vdout0_146ck450 FIND v(dout0_146) AT=230.025n

.meas tran vdout0_147ck450 FIND v(dout0_147) AT=230.025n

.meas tran vdout0_148ck450 FIND v(dout0_148) AT=230.025n

.meas tran vdout0_149ck450 FIND v(dout0_149) AT=230.025n

.meas tran vdout0_0ck470 FIND v(dout0_0) AT=240.025n

.meas tran vdout0_1ck470 FIND v(dout0_1) AT=240.025n

.meas tran vdout0_2ck470 FIND v(dout0_2) AT=240.025n

.meas tran vdout0_3ck470 FIND v(dout0_3) AT=240.025n

.meas tran vdout0_4ck470 FIND v(dout0_4) AT=240.025n

.meas tran vdout0_5ck470 FIND v(dout0_5) AT=240.025n

.meas tran vdout0_6ck470 FIND v(dout0_6) AT=240.025n

.meas tran vdout0_7ck470 FIND v(dout0_7) AT=240.025n

.meas tran vdout0_8ck470 FIND v(dout0_8) AT=240.025n

.meas tran vdout0_9ck470 FIND v(dout0_9) AT=240.025n

.meas tran vdout0_10ck470 FIND v(dout0_10) AT=240.025n

.meas tran vdout0_11ck470 FIND v(dout0_11) AT=240.025n

.meas tran vdout0_12ck470 FIND v(dout0_12) AT=240.025n

.meas tran vdout0_13ck470 FIND v(dout0_13) AT=240.025n

.meas tran vdout0_14ck470 FIND v(dout0_14) AT=240.025n

.meas tran vdout0_15ck470 FIND v(dout0_15) AT=240.025n

.meas tran vdout0_16ck470 FIND v(dout0_16) AT=240.025n

.meas tran vdout0_17ck470 FIND v(dout0_17) AT=240.025n

.meas tran vdout0_18ck470 FIND v(dout0_18) AT=240.025n

.meas tran vdout0_19ck470 FIND v(dout0_19) AT=240.025n

.meas tran vdout0_20ck470 FIND v(dout0_20) AT=240.025n

.meas tran vdout0_21ck470 FIND v(dout0_21) AT=240.025n

.meas tran vdout0_22ck470 FIND v(dout0_22) AT=240.025n

.meas tran vdout0_23ck470 FIND v(dout0_23) AT=240.025n

.meas tran vdout0_24ck470 FIND v(dout0_24) AT=240.025n

.meas tran vdout0_25ck470 FIND v(dout0_25) AT=240.025n

.meas tran vdout0_26ck470 FIND v(dout0_26) AT=240.025n

.meas tran vdout0_27ck470 FIND v(dout0_27) AT=240.025n

.meas tran vdout0_28ck470 FIND v(dout0_28) AT=240.025n

.meas tran vdout0_29ck470 FIND v(dout0_29) AT=240.025n

.meas tran vdout0_30ck470 FIND v(dout0_30) AT=240.025n

.meas tran vdout0_31ck470 FIND v(dout0_31) AT=240.025n

.meas tran vdout0_32ck470 FIND v(dout0_32) AT=240.025n

.meas tran vdout0_33ck470 FIND v(dout0_33) AT=240.025n

.meas tran vdout0_34ck470 FIND v(dout0_34) AT=240.025n

.meas tran vdout0_35ck470 FIND v(dout0_35) AT=240.025n

.meas tran vdout0_36ck470 FIND v(dout0_36) AT=240.025n

.meas tran vdout0_37ck470 FIND v(dout0_37) AT=240.025n

.meas tran vdout0_38ck470 FIND v(dout0_38) AT=240.025n

.meas tran vdout0_39ck470 FIND v(dout0_39) AT=240.025n

.meas tran vdout0_40ck470 FIND v(dout0_40) AT=240.025n

.meas tran vdout0_41ck470 FIND v(dout0_41) AT=240.025n

.meas tran vdout0_42ck470 FIND v(dout0_42) AT=240.025n

.meas tran vdout0_43ck470 FIND v(dout0_43) AT=240.025n

.meas tran vdout0_44ck470 FIND v(dout0_44) AT=240.025n

.meas tran vdout0_45ck470 FIND v(dout0_45) AT=240.025n

.meas tran vdout0_46ck470 FIND v(dout0_46) AT=240.025n

.meas tran vdout0_47ck470 FIND v(dout0_47) AT=240.025n

.meas tran vdout0_48ck470 FIND v(dout0_48) AT=240.025n

.meas tran vdout0_49ck470 FIND v(dout0_49) AT=240.025n

.meas tran vdout0_50ck470 FIND v(dout0_50) AT=240.025n

.meas tran vdout0_51ck470 FIND v(dout0_51) AT=240.025n

.meas tran vdout0_52ck470 FIND v(dout0_52) AT=240.025n

.meas tran vdout0_53ck470 FIND v(dout0_53) AT=240.025n

.meas tran vdout0_54ck470 FIND v(dout0_54) AT=240.025n

.meas tran vdout0_55ck470 FIND v(dout0_55) AT=240.025n

.meas tran vdout0_56ck470 FIND v(dout0_56) AT=240.025n

.meas tran vdout0_57ck470 FIND v(dout0_57) AT=240.025n

.meas tran vdout0_58ck470 FIND v(dout0_58) AT=240.025n

.meas tran vdout0_59ck470 FIND v(dout0_59) AT=240.025n

.meas tran vdout0_60ck470 FIND v(dout0_60) AT=240.025n

.meas tran vdout0_61ck470 FIND v(dout0_61) AT=240.025n

.meas tran vdout0_62ck470 FIND v(dout0_62) AT=240.025n

.meas tran vdout0_63ck470 FIND v(dout0_63) AT=240.025n

.meas tran vdout0_64ck470 FIND v(dout0_64) AT=240.025n

.meas tran vdout0_65ck470 FIND v(dout0_65) AT=240.025n

.meas tran vdout0_66ck470 FIND v(dout0_66) AT=240.025n

.meas tran vdout0_67ck470 FIND v(dout0_67) AT=240.025n

.meas tran vdout0_68ck470 FIND v(dout0_68) AT=240.025n

.meas tran vdout0_69ck470 FIND v(dout0_69) AT=240.025n

.meas tran vdout0_70ck470 FIND v(dout0_70) AT=240.025n

.meas tran vdout0_71ck470 FIND v(dout0_71) AT=240.025n

.meas tran vdout0_72ck470 FIND v(dout0_72) AT=240.025n

.meas tran vdout0_73ck470 FIND v(dout0_73) AT=240.025n

.meas tran vdout0_74ck470 FIND v(dout0_74) AT=240.025n

.meas tran vdout0_75ck470 FIND v(dout0_75) AT=240.025n

.meas tran vdout0_76ck470 FIND v(dout0_76) AT=240.025n

.meas tran vdout0_77ck470 FIND v(dout0_77) AT=240.025n

.meas tran vdout0_78ck470 FIND v(dout0_78) AT=240.025n

.meas tran vdout0_79ck470 FIND v(dout0_79) AT=240.025n

.meas tran vdout0_80ck470 FIND v(dout0_80) AT=240.025n

.meas tran vdout0_81ck470 FIND v(dout0_81) AT=240.025n

.meas tran vdout0_82ck470 FIND v(dout0_82) AT=240.025n

.meas tran vdout0_83ck470 FIND v(dout0_83) AT=240.025n

.meas tran vdout0_84ck470 FIND v(dout0_84) AT=240.025n

.meas tran vdout0_85ck470 FIND v(dout0_85) AT=240.025n

.meas tran vdout0_86ck470 FIND v(dout0_86) AT=240.025n

.meas tran vdout0_87ck470 FIND v(dout0_87) AT=240.025n

.meas tran vdout0_88ck470 FIND v(dout0_88) AT=240.025n

.meas tran vdout0_89ck470 FIND v(dout0_89) AT=240.025n

.meas tran vdout0_90ck470 FIND v(dout0_90) AT=240.025n

.meas tran vdout0_91ck470 FIND v(dout0_91) AT=240.025n

.meas tran vdout0_92ck470 FIND v(dout0_92) AT=240.025n

.meas tran vdout0_93ck470 FIND v(dout0_93) AT=240.025n

.meas tran vdout0_94ck470 FIND v(dout0_94) AT=240.025n

.meas tran vdout0_95ck470 FIND v(dout0_95) AT=240.025n

.meas tran vdout0_96ck470 FIND v(dout0_96) AT=240.025n

.meas tran vdout0_97ck470 FIND v(dout0_97) AT=240.025n

.meas tran vdout0_98ck470 FIND v(dout0_98) AT=240.025n

.meas tran vdout0_99ck470 FIND v(dout0_99) AT=240.025n

.meas tran vdout0_100ck470 FIND v(dout0_100) AT=240.025n

.meas tran vdout0_101ck470 FIND v(dout0_101) AT=240.025n

.meas tran vdout0_102ck470 FIND v(dout0_102) AT=240.025n

.meas tran vdout0_103ck470 FIND v(dout0_103) AT=240.025n

.meas tran vdout0_104ck470 FIND v(dout0_104) AT=240.025n

.meas tran vdout0_105ck470 FIND v(dout0_105) AT=240.025n

.meas tran vdout0_106ck470 FIND v(dout0_106) AT=240.025n

.meas tran vdout0_107ck470 FIND v(dout0_107) AT=240.025n

.meas tran vdout0_108ck470 FIND v(dout0_108) AT=240.025n

.meas tran vdout0_109ck470 FIND v(dout0_109) AT=240.025n

.meas tran vdout0_110ck470 FIND v(dout0_110) AT=240.025n

.meas tran vdout0_111ck470 FIND v(dout0_111) AT=240.025n

.meas tran vdout0_112ck470 FIND v(dout0_112) AT=240.025n

.meas tran vdout0_113ck470 FIND v(dout0_113) AT=240.025n

.meas tran vdout0_114ck470 FIND v(dout0_114) AT=240.025n

.meas tran vdout0_115ck470 FIND v(dout0_115) AT=240.025n

.meas tran vdout0_116ck470 FIND v(dout0_116) AT=240.025n

.meas tran vdout0_117ck470 FIND v(dout0_117) AT=240.025n

.meas tran vdout0_118ck470 FIND v(dout0_118) AT=240.025n

.meas tran vdout0_119ck470 FIND v(dout0_119) AT=240.025n

.meas tran vdout0_120ck470 FIND v(dout0_120) AT=240.025n

.meas tran vdout0_121ck470 FIND v(dout0_121) AT=240.025n

.meas tran vdout0_122ck470 FIND v(dout0_122) AT=240.025n

.meas tran vdout0_123ck470 FIND v(dout0_123) AT=240.025n

.meas tran vdout0_124ck470 FIND v(dout0_124) AT=240.025n

.meas tran vdout0_125ck470 FIND v(dout0_125) AT=240.025n

.meas tran vdout0_126ck470 FIND v(dout0_126) AT=240.025n

.meas tran vdout0_127ck470 FIND v(dout0_127) AT=240.025n

.meas tran vdout0_128ck470 FIND v(dout0_128) AT=240.025n

.meas tran vdout0_129ck470 FIND v(dout0_129) AT=240.025n

.meas tran vdout0_130ck470 FIND v(dout0_130) AT=240.025n

.meas tran vdout0_131ck470 FIND v(dout0_131) AT=240.025n

.meas tran vdout0_132ck470 FIND v(dout0_132) AT=240.025n

.meas tran vdout0_133ck470 FIND v(dout0_133) AT=240.025n

.meas tran vdout0_134ck470 FIND v(dout0_134) AT=240.025n

.meas tran vdout0_135ck470 FIND v(dout0_135) AT=240.025n

.meas tran vdout0_136ck470 FIND v(dout0_136) AT=240.025n

.meas tran vdout0_137ck470 FIND v(dout0_137) AT=240.025n

.meas tran vdout0_138ck470 FIND v(dout0_138) AT=240.025n

.meas tran vdout0_139ck470 FIND v(dout0_139) AT=240.025n

.meas tran vdout0_140ck470 FIND v(dout0_140) AT=240.025n

.meas tran vdout0_141ck470 FIND v(dout0_141) AT=240.025n

.meas tran vdout0_142ck470 FIND v(dout0_142) AT=240.025n

.meas tran vdout0_143ck470 FIND v(dout0_143) AT=240.025n

.meas tran vdout0_144ck470 FIND v(dout0_144) AT=240.025n

.meas tran vdout0_145ck470 FIND v(dout0_145) AT=240.025n

.meas tran vdout0_146ck470 FIND v(dout0_146) AT=240.025n

.meas tran vdout0_147ck470 FIND v(dout0_147) AT=240.025n

.meas tran vdout0_148ck470 FIND v(dout0_148) AT=240.025n

.meas tran vdout0_149ck470 FIND v(dout0_149) AT=240.025n

.meas tran vdout0_0ck480 FIND v(dout0_0) AT=245.025n

.meas tran vdout0_1ck480 FIND v(dout0_1) AT=245.025n

.meas tran vdout0_2ck480 FIND v(dout0_2) AT=245.025n

.meas tran vdout0_3ck480 FIND v(dout0_3) AT=245.025n

.meas tran vdout0_4ck480 FIND v(dout0_4) AT=245.025n

.meas tran vdout0_5ck480 FIND v(dout0_5) AT=245.025n

.meas tran vdout0_6ck480 FIND v(dout0_6) AT=245.025n

.meas tran vdout0_7ck480 FIND v(dout0_7) AT=245.025n

.meas tran vdout0_8ck480 FIND v(dout0_8) AT=245.025n

.meas tran vdout0_9ck480 FIND v(dout0_9) AT=245.025n

.meas tran vdout0_10ck480 FIND v(dout0_10) AT=245.025n

.meas tran vdout0_11ck480 FIND v(dout0_11) AT=245.025n

.meas tran vdout0_12ck480 FIND v(dout0_12) AT=245.025n

.meas tran vdout0_13ck480 FIND v(dout0_13) AT=245.025n

.meas tran vdout0_14ck480 FIND v(dout0_14) AT=245.025n

.meas tran vdout0_15ck480 FIND v(dout0_15) AT=245.025n

.meas tran vdout0_16ck480 FIND v(dout0_16) AT=245.025n

.meas tran vdout0_17ck480 FIND v(dout0_17) AT=245.025n

.meas tran vdout0_18ck480 FIND v(dout0_18) AT=245.025n

.meas tran vdout0_19ck480 FIND v(dout0_19) AT=245.025n

.meas tran vdout0_20ck480 FIND v(dout0_20) AT=245.025n

.meas tran vdout0_21ck480 FIND v(dout0_21) AT=245.025n

.meas tran vdout0_22ck480 FIND v(dout0_22) AT=245.025n

.meas tran vdout0_23ck480 FIND v(dout0_23) AT=245.025n

.meas tran vdout0_24ck480 FIND v(dout0_24) AT=245.025n

.meas tran vdout0_25ck480 FIND v(dout0_25) AT=245.025n

.meas tran vdout0_26ck480 FIND v(dout0_26) AT=245.025n

.meas tran vdout0_27ck480 FIND v(dout0_27) AT=245.025n

.meas tran vdout0_28ck480 FIND v(dout0_28) AT=245.025n

.meas tran vdout0_29ck480 FIND v(dout0_29) AT=245.025n

.meas tran vdout0_30ck480 FIND v(dout0_30) AT=245.025n

.meas tran vdout0_31ck480 FIND v(dout0_31) AT=245.025n

.meas tran vdout0_32ck480 FIND v(dout0_32) AT=245.025n

.meas tran vdout0_33ck480 FIND v(dout0_33) AT=245.025n

.meas tran vdout0_34ck480 FIND v(dout0_34) AT=245.025n

.meas tran vdout0_35ck480 FIND v(dout0_35) AT=245.025n

.meas tran vdout0_36ck480 FIND v(dout0_36) AT=245.025n

.meas tran vdout0_37ck480 FIND v(dout0_37) AT=245.025n

.meas tran vdout0_38ck480 FIND v(dout0_38) AT=245.025n

.meas tran vdout0_39ck480 FIND v(dout0_39) AT=245.025n

.meas tran vdout0_40ck480 FIND v(dout0_40) AT=245.025n

.meas tran vdout0_41ck480 FIND v(dout0_41) AT=245.025n

.meas tran vdout0_42ck480 FIND v(dout0_42) AT=245.025n

.meas tran vdout0_43ck480 FIND v(dout0_43) AT=245.025n

.meas tran vdout0_44ck480 FIND v(dout0_44) AT=245.025n

.meas tran vdout0_45ck480 FIND v(dout0_45) AT=245.025n

.meas tran vdout0_46ck480 FIND v(dout0_46) AT=245.025n

.meas tran vdout0_47ck480 FIND v(dout0_47) AT=245.025n

.meas tran vdout0_48ck480 FIND v(dout0_48) AT=245.025n

.meas tran vdout0_49ck480 FIND v(dout0_49) AT=245.025n

.meas tran vdout0_50ck480 FIND v(dout0_50) AT=245.025n

.meas tran vdout0_51ck480 FIND v(dout0_51) AT=245.025n

.meas tran vdout0_52ck480 FIND v(dout0_52) AT=245.025n

.meas tran vdout0_53ck480 FIND v(dout0_53) AT=245.025n

.meas tran vdout0_54ck480 FIND v(dout0_54) AT=245.025n

.meas tran vdout0_55ck480 FIND v(dout0_55) AT=245.025n

.meas tran vdout0_56ck480 FIND v(dout0_56) AT=245.025n

.meas tran vdout0_57ck480 FIND v(dout0_57) AT=245.025n

.meas tran vdout0_58ck480 FIND v(dout0_58) AT=245.025n

.meas tran vdout0_59ck480 FIND v(dout0_59) AT=245.025n

.meas tran vdout0_60ck480 FIND v(dout0_60) AT=245.025n

.meas tran vdout0_61ck480 FIND v(dout0_61) AT=245.025n

.meas tran vdout0_62ck480 FIND v(dout0_62) AT=245.025n

.meas tran vdout0_63ck480 FIND v(dout0_63) AT=245.025n

.meas tran vdout0_64ck480 FIND v(dout0_64) AT=245.025n

.meas tran vdout0_65ck480 FIND v(dout0_65) AT=245.025n

.meas tran vdout0_66ck480 FIND v(dout0_66) AT=245.025n

.meas tran vdout0_67ck480 FIND v(dout0_67) AT=245.025n

.meas tran vdout0_68ck480 FIND v(dout0_68) AT=245.025n

.meas tran vdout0_69ck480 FIND v(dout0_69) AT=245.025n

.meas tran vdout0_70ck480 FIND v(dout0_70) AT=245.025n

.meas tran vdout0_71ck480 FIND v(dout0_71) AT=245.025n

.meas tran vdout0_72ck480 FIND v(dout0_72) AT=245.025n

.meas tran vdout0_73ck480 FIND v(dout0_73) AT=245.025n

.meas tran vdout0_74ck480 FIND v(dout0_74) AT=245.025n

.meas tran vdout0_75ck480 FIND v(dout0_75) AT=245.025n

.meas tran vdout0_76ck480 FIND v(dout0_76) AT=245.025n

.meas tran vdout0_77ck480 FIND v(dout0_77) AT=245.025n

.meas tran vdout0_78ck480 FIND v(dout0_78) AT=245.025n

.meas tran vdout0_79ck480 FIND v(dout0_79) AT=245.025n

.meas tran vdout0_80ck480 FIND v(dout0_80) AT=245.025n

.meas tran vdout0_81ck480 FIND v(dout0_81) AT=245.025n

.meas tran vdout0_82ck480 FIND v(dout0_82) AT=245.025n

.meas tran vdout0_83ck480 FIND v(dout0_83) AT=245.025n

.meas tran vdout0_84ck480 FIND v(dout0_84) AT=245.025n

.meas tran vdout0_85ck480 FIND v(dout0_85) AT=245.025n

.meas tran vdout0_86ck480 FIND v(dout0_86) AT=245.025n

.meas tran vdout0_87ck480 FIND v(dout0_87) AT=245.025n

.meas tran vdout0_88ck480 FIND v(dout0_88) AT=245.025n

.meas tran vdout0_89ck480 FIND v(dout0_89) AT=245.025n

.meas tran vdout0_90ck480 FIND v(dout0_90) AT=245.025n

.meas tran vdout0_91ck480 FIND v(dout0_91) AT=245.025n

.meas tran vdout0_92ck480 FIND v(dout0_92) AT=245.025n

.meas tran vdout0_93ck480 FIND v(dout0_93) AT=245.025n

.meas tran vdout0_94ck480 FIND v(dout0_94) AT=245.025n

.meas tran vdout0_95ck480 FIND v(dout0_95) AT=245.025n

.meas tran vdout0_96ck480 FIND v(dout0_96) AT=245.025n

.meas tran vdout0_97ck480 FIND v(dout0_97) AT=245.025n

.meas tran vdout0_98ck480 FIND v(dout0_98) AT=245.025n

.meas tran vdout0_99ck480 FIND v(dout0_99) AT=245.025n

.meas tran vdout0_100ck480 FIND v(dout0_100) AT=245.025n

.meas tran vdout0_101ck480 FIND v(dout0_101) AT=245.025n

.meas tran vdout0_102ck480 FIND v(dout0_102) AT=245.025n

.meas tran vdout0_103ck480 FIND v(dout0_103) AT=245.025n

.meas tran vdout0_104ck480 FIND v(dout0_104) AT=245.025n

.meas tran vdout0_105ck480 FIND v(dout0_105) AT=245.025n

.meas tran vdout0_106ck480 FIND v(dout0_106) AT=245.025n

.meas tran vdout0_107ck480 FIND v(dout0_107) AT=245.025n

.meas tran vdout0_108ck480 FIND v(dout0_108) AT=245.025n

.meas tran vdout0_109ck480 FIND v(dout0_109) AT=245.025n

.meas tran vdout0_110ck480 FIND v(dout0_110) AT=245.025n

.meas tran vdout0_111ck480 FIND v(dout0_111) AT=245.025n

.meas tran vdout0_112ck480 FIND v(dout0_112) AT=245.025n

.meas tran vdout0_113ck480 FIND v(dout0_113) AT=245.025n

.meas tran vdout0_114ck480 FIND v(dout0_114) AT=245.025n

.meas tran vdout0_115ck480 FIND v(dout0_115) AT=245.025n

.meas tran vdout0_116ck480 FIND v(dout0_116) AT=245.025n

.meas tran vdout0_117ck480 FIND v(dout0_117) AT=245.025n

.meas tran vdout0_118ck480 FIND v(dout0_118) AT=245.025n

.meas tran vdout0_119ck480 FIND v(dout0_119) AT=245.025n

.meas tran vdout0_120ck480 FIND v(dout0_120) AT=245.025n

.meas tran vdout0_121ck480 FIND v(dout0_121) AT=245.025n

.meas tran vdout0_122ck480 FIND v(dout0_122) AT=245.025n

.meas tran vdout0_123ck480 FIND v(dout0_123) AT=245.025n

.meas tran vdout0_124ck480 FIND v(dout0_124) AT=245.025n

.meas tran vdout0_125ck480 FIND v(dout0_125) AT=245.025n

.meas tran vdout0_126ck480 FIND v(dout0_126) AT=245.025n

.meas tran vdout0_127ck480 FIND v(dout0_127) AT=245.025n

.meas tran vdout0_128ck480 FIND v(dout0_128) AT=245.025n

.meas tran vdout0_129ck480 FIND v(dout0_129) AT=245.025n

.meas tran vdout0_130ck480 FIND v(dout0_130) AT=245.025n

.meas tran vdout0_131ck480 FIND v(dout0_131) AT=245.025n

.meas tran vdout0_132ck480 FIND v(dout0_132) AT=245.025n

.meas tran vdout0_133ck480 FIND v(dout0_133) AT=245.025n

.meas tran vdout0_134ck480 FIND v(dout0_134) AT=245.025n

.meas tran vdout0_135ck480 FIND v(dout0_135) AT=245.025n

.meas tran vdout0_136ck480 FIND v(dout0_136) AT=245.025n

.meas tran vdout0_137ck480 FIND v(dout0_137) AT=245.025n

.meas tran vdout0_138ck480 FIND v(dout0_138) AT=245.025n

.meas tran vdout0_139ck480 FIND v(dout0_139) AT=245.025n

.meas tran vdout0_140ck480 FIND v(dout0_140) AT=245.025n

.meas tran vdout0_141ck480 FIND v(dout0_141) AT=245.025n

.meas tran vdout0_142ck480 FIND v(dout0_142) AT=245.025n

.meas tran vdout0_143ck480 FIND v(dout0_143) AT=245.025n

.meas tran vdout0_144ck480 FIND v(dout0_144) AT=245.025n

.meas tran vdout0_145ck480 FIND v(dout0_145) AT=245.025n

.meas tran vdout0_146ck480 FIND v(dout0_146) AT=245.025n

.meas tran vdout0_147ck480 FIND v(dout0_147) AT=245.025n

.meas tran vdout0_148ck480 FIND v(dout0_148) AT=245.025n

.meas tran vdout0_149ck480 FIND v(dout0_149) AT=245.025n

.meas tran vdout0_0ck490 FIND v(dout0_0) AT=250.025n

.meas tran vdout0_1ck490 FIND v(dout0_1) AT=250.025n

.meas tran vdout0_2ck490 FIND v(dout0_2) AT=250.025n

.meas tran vdout0_3ck490 FIND v(dout0_3) AT=250.025n

.meas tran vdout0_4ck490 FIND v(dout0_4) AT=250.025n

.meas tran vdout0_5ck490 FIND v(dout0_5) AT=250.025n

.meas tran vdout0_6ck490 FIND v(dout0_6) AT=250.025n

.meas tran vdout0_7ck490 FIND v(dout0_7) AT=250.025n

.meas tran vdout0_8ck490 FIND v(dout0_8) AT=250.025n

.meas tran vdout0_9ck490 FIND v(dout0_9) AT=250.025n

.meas tran vdout0_10ck490 FIND v(dout0_10) AT=250.025n

.meas tran vdout0_11ck490 FIND v(dout0_11) AT=250.025n

.meas tran vdout0_12ck490 FIND v(dout0_12) AT=250.025n

.meas tran vdout0_13ck490 FIND v(dout0_13) AT=250.025n

.meas tran vdout0_14ck490 FIND v(dout0_14) AT=250.025n

.meas tran vdout0_15ck490 FIND v(dout0_15) AT=250.025n

.meas tran vdout0_16ck490 FIND v(dout0_16) AT=250.025n

.meas tran vdout0_17ck490 FIND v(dout0_17) AT=250.025n

.meas tran vdout0_18ck490 FIND v(dout0_18) AT=250.025n

.meas tran vdout0_19ck490 FIND v(dout0_19) AT=250.025n

.meas tran vdout0_20ck490 FIND v(dout0_20) AT=250.025n

.meas tran vdout0_21ck490 FIND v(dout0_21) AT=250.025n

.meas tran vdout0_22ck490 FIND v(dout0_22) AT=250.025n

.meas tran vdout0_23ck490 FIND v(dout0_23) AT=250.025n

.meas tran vdout0_24ck490 FIND v(dout0_24) AT=250.025n

.meas tran vdout0_25ck490 FIND v(dout0_25) AT=250.025n

.meas tran vdout0_26ck490 FIND v(dout0_26) AT=250.025n

.meas tran vdout0_27ck490 FIND v(dout0_27) AT=250.025n

.meas tran vdout0_28ck490 FIND v(dout0_28) AT=250.025n

.meas tran vdout0_29ck490 FIND v(dout0_29) AT=250.025n

.meas tran vdout0_30ck490 FIND v(dout0_30) AT=250.025n

.meas tran vdout0_31ck490 FIND v(dout0_31) AT=250.025n

.meas tran vdout0_32ck490 FIND v(dout0_32) AT=250.025n

.meas tran vdout0_33ck490 FIND v(dout0_33) AT=250.025n

.meas tran vdout0_34ck490 FIND v(dout0_34) AT=250.025n

.meas tran vdout0_35ck490 FIND v(dout0_35) AT=250.025n

.meas tran vdout0_36ck490 FIND v(dout0_36) AT=250.025n

.meas tran vdout0_37ck490 FIND v(dout0_37) AT=250.025n

.meas tran vdout0_38ck490 FIND v(dout0_38) AT=250.025n

.meas tran vdout0_39ck490 FIND v(dout0_39) AT=250.025n

.meas tran vdout0_40ck490 FIND v(dout0_40) AT=250.025n

.meas tran vdout0_41ck490 FIND v(dout0_41) AT=250.025n

.meas tran vdout0_42ck490 FIND v(dout0_42) AT=250.025n

.meas tran vdout0_43ck490 FIND v(dout0_43) AT=250.025n

.meas tran vdout0_44ck490 FIND v(dout0_44) AT=250.025n

.meas tran vdout0_45ck490 FIND v(dout0_45) AT=250.025n

.meas tran vdout0_46ck490 FIND v(dout0_46) AT=250.025n

.meas tran vdout0_47ck490 FIND v(dout0_47) AT=250.025n

.meas tran vdout0_48ck490 FIND v(dout0_48) AT=250.025n

.meas tran vdout0_49ck490 FIND v(dout0_49) AT=250.025n

.meas tran vdout0_50ck490 FIND v(dout0_50) AT=250.025n

.meas tran vdout0_51ck490 FIND v(dout0_51) AT=250.025n

.meas tran vdout0_52ck490 FIND v(dout0_52) AT=250.025n

.meas tran vdout0_53ck490 FIND v(dout0_53) AT=250.025n

.meas tran vdout0_54ck490 FIND v(dout0_54) AT=250.025n

.meas tran vdout0_55ck490 FIND v(dout0_55) AT=250.025n

.meas tran vdout0_56ck490 FIND v(dout0_56) AT=250.025n

.meas tran vdout0_57ck490 FIND v(dout0_57) AT=250.025n

.meas tran vdout0_58ck490 FIND v(dout0_58) AT=250.025n

.meas tran vdout0_59ck490 FIND v(dout0_59) AT=250.025n

.meas tran vdout0_60ck490 FIND v(dout0_60) AT=250.025n

.meas tran vdout0_61ck490 FIND v(dout0_61) AT=250.025n

.meas tran vdout0_62ck490 FIND v(dout0_62) AT=250.025n

.meas tran vdout0_63ck490 FIND v(dout0_63) AT=250.025n

.meas tran vdout0_64ck490 FIND v(dout0_64) AT=250.025n

.meas tran vdout0_65ck490 FIND v(dout0_65) AT=250.025n

.meas tran vdout0_66ck490 FIND v(dout0_66) AT=250.025n

.meas tran vdout0_67ck490 FIND v(dout0_67) AT=250.025n

.meas tran vdout0_68ck490 FIND v(dout0_68) AT=250.025n

.meas tran vdout0_69ck490 FIND v(dout0_69) AT=250.025n

.meas tran vdout0_70ck490 FIND v(dout0_70) AT=250.025n

.meas tran vdout0_71ck490 FIND v(dout0_71) AT=250.025n

.meas tran vdout0_72ck490 FIND v(dout0_72) AT=250.025n

.meas tran vdout0_73ck490 FIND v(dout0_73) AT=250.025n

.meas tran vdout0_74ck490 FIND v(dout0_74) AT=250.025n

.meas tran vdout0_75ck490 FIND v(dout0_75) AT=250.025n

.meas tran vdout0_76ck490 FIND v(dout0_76) AT=250.025n

.meas tran vdout0_77ck490 FIND v(dout0_77) AT=250.025n

.meas tran vdout0_78ck490 FIND v(dout0_78) AT=250.025n

.meas tran vdout0_79ck490 FIND v(dout0_79) AT=250.025n

.meas tran vdout0_80ck490 FIND v(dout0_80) AT=250.025n

.meas tran vdout0_81ck490 FIND v(dout0_81) AT=250.025n

.meas tran vdout0_82ck490 FIND v(dout0_82) AT=250.025n

.meas tran vdout0_83ck490 FIND v(dout0_83) AT=250.025n

.meas tran vdout0_84ck490 FIND v(dout0_84) AT=250.025n

.meas tran vdout0_85ck490 FIND v(dout0_85) AT=250.025n

.meas tran vdout0_86ck490 FIND v(dout0_86) AT=250.025n

.meas tran vdout0_87ck490 FIND v(dout0_87) AT=250.025n

.meas tran vdout0_88ck490 FIND v(dout0_88) AT=250.025n

.meas tran vdout0_89ck490 FIND v(dout0_89) AT=250.025n

.meas tran vdout0_90ck490 FIND v(dout0_90) AT=250.025n

.meas tran vdout0_91ck490 FIND v(dout0_91) AT=250.025n

.meas tran vdout0_92ck490 FIND v(dout0_92) AT=250.025n

.meas tran vdout0_93ck490 FIND v(dout0_93) AT=250.025n

.meas tran vdout0_94ck490 FIND v(dout0_94) AT=250.025n

.meas tran vdout0_95ck490 FIND v(dout0_95) AT=250.025n

.meas tran vdout0_96ck490 FIND v(dout0_96) AT=250.025n

.meas tran vdout0_97ck490 FIND v(dout0_97) AT=250.025n

.meas tran vdout0_98ck490 FIND v(dout0_98) AT=250.025n

.meas tran vdout0_99ck490 FIND v(dout0_99) AT=250.025n

.meas tran vdout0_100ck490 FIND v(dout0_100) AT=250.025n

.meas tran vdout0_101ck490 FIND v(dout0_101) AT=250.025n

.meas tran vdout0_102ck490 FIND v(dout0_102) AT=250.025n

.meas tran vdout0_103ck490 FIND v(dout0_103) AT=250.025n

.meas tran vdout0_104ck490 FIND v(dout0_104) AT=250.025n

.meas tran vdout0_105ck490 FIND v(dout0_105) AT=250.025n

.meas tran vdout0_106ck490 FIND v(dout0_106) AT=250.025n

.meas tran vdout0_107ck490 FIND v(dout0_107) AT=250.025n

.meas tran vdout0_108ck490 FIND v(dout0_108) AT=250.025n

.meas tran vdout0_109ck490 FIND v(dout0_109) AT=250.025n

.meas tran vdout0_110ck490 FIND v(dout0_110) AT=250.025n

.meas tran vdout0_111ck490 FIND v(dout0_111) AT=250.025n

.meas tran vdout0_112ck490 FIND v(dout0_112) AT=250.025n

.meas tran vdout0_113ck490 FIND v(dout0_113) AT=250.025n

.meas tran vdout0_114ck490 FIND v(dout0_114) AT=250.025n

.meas tran vdout0_115ck490 FIND v(dout0_115) AT=250.025n

.meas tran vdout0_116ck490 FIND v(dout0_116) AT=250.025n

.meas tran vdout0_117ck490 FIND v(dout0_117) AT=250.025n

.meas tran vdout0_118ck490 FIND v(dout0_118) AT=250.025n

.meas tran vdout0_119ck490 FIND v(dout0_119) AT=250.025n

.meas tran vdout0_120ck490 FIND v(dout0_120) AT=250.025n

.meas tran vdout0_121ck490 FIND v(dout0_121) AT=250.025n

.meas tran vdout0_122ck490 FIND v(dout0_122) AT=250.025n

.meas tran vdout0_123ck490 FIND v(dout0_123) AT=250.025n

.meas tran vdout0_124ck490 FIND v(dout0_124) AT=250.025n

.meas tran vdout0_125ck490 FIND v(dout0_125) AT=250.025n

.meas tran vdout0_126ck490 FIND v(dout0_126) AT=250.025n

.meas tran vdout0_127ck490 FIND v(dout0_127) AT=250.025n

.meas tran vdout0_128ck490 FIND v(dout0_128) AT=250.025n

.meas tran vdout0_129ck490 FIND v(dout0_129) AT=250.025n

.meas tran vdout0_130ck490 FIND v(dout0_130) AT=250.025n

.meas tran vdout0_131ck490 FIND v(dout0_131) AT=250.025n

.meas tran vdout0_132ck490 FIND v(dout0_132) AT=250.025n

.meas tran vdout0_133ck490 FIND v(dout0_133) AT=250.025n

.meas tran vdout0_134ck490 FIND v(dout0_134) AT=250.025n

.meas tran vdout0_135ck490 FIND v(dout0_135) AT=250.025n

.meas tran vdout0_136ck490 FIND v(dout0_136) AT=250.025n

.meas tran vdout0_137ck490 FIND v(dout0_137) AT=250.025n

.meas tran vdout0_138ck490 FIND v(dout0_138) AT=250.025n

.meas tran vdout0_139ck490 FIND v(dout0_139) AT=250.025n

.meas tran vdout0_140ck490 FIND v(dout0_140) AT=250.025n

.meas tran vdout0_141ck490 FIND v(dout0_141) AT=250.025n

.meas tran vdout0_142ck490 FIND v(dout0_142) AT=250.025n

.meas tran vdout0_143ck490 FIND v(dout0_143) AT=250.025n

.meas tran vdout0_144ck490 FIND v(dout0_144) AT=250.025n

.meas tran vdout0_145ck490 FIND v(dout0_145) AT=250.025n

.meas tran vdout0_146ck490 FIND v(dout0_146) AT=250.025n

.meas tran vdout0_147ck490 FIND v(dout0_147) AT=250.025n

.meas tran vdout0_148ck490 FIND v(dout0_148) AT=250.025n

.meas tran vdout0_149ck490 FIND v(dout0_149) AT=250.025n

.meas tran vdout0_0ck520 FIND v(dout0_0) AT=265.025n

.meas tran vdout0_1ck520 FIND v(dout0_1) AT=265.025n

.meas tran vdout0_2ck520 FIND v(dout0_2) AT=265.025n

.meas tran vdout0_3ck520 FIND v(dout0_3) AT=265.025n

.meas tran vdout0_4ck520 FIND v(dout0_4) AT=265.025n

.meas tran vdout0_5ck520 FIND v(dout0_5) AT=265.025n

.meas tran vdout0_6ck520 FIND v(dout0_6) AT=265.025n

.meas tran vdout0_7ck520 FIND v(dout0_7) AT=265.025n

.meas tran vdout0_8ck520 FIND v(dout0_8) AT=265.025n

.meas tran vdout0_9ck520 FIND v(dout0_9) AT=265.025n

.meas tran vdout0_10ck520 FIND v(dout0_10) AT=265.025n

.meas tran vdout0_11ck520 FIND v(dout0_11) AT=265.025n

.meas tran vdout0_12ck520 FIND v(dout0_12) AT=265.025n

.meas tran vdout0_13ck520 FIND v(dout0_13) AT=265.025n

.meas tran vdout0_14ck520 FIND v(dout0_14) AT=265.025n

.meas tran vdout0_15ck520 FIND v(dout0_15) AT=265.025n

.meas tran vdout0_16ck520 FIND v(dout0_16) AT=265.025n

.meas tran vdout0_17ck520 FIND v(dout0_17) AT=265.025n

.meas tran vdout0_18ck520 FIND v(dout0_18) AT=265.025n

.meas tran vdout0_19ck520 FIND v(dout0_19) AT=265.025n

.meas tran vdout0_20ck520 FIND v(dout0_20) AT=265.025n

.meas tran vdout0_21ck520 FIND v(dout0_21) AT=265.025n

.meas tran vdout0_22ck520 FIND v(dout0_22) AT=265.025n

.meas tran vdout0_23ck520 FIND v(dout0_23) AT=265.025n

.meas tran vdout0_24ck520 FIND v(dout0_24) AT=265.025n

.meas tran vdout0_25ck520 FIND v(dout0_25) AT=265.025n

.meas tran vdout0_26ck520 FIND v(dout0_26) AT=265.025n

.meas tran vdout0_27ck520 FIND v(dout0_27) AT=265.025n

.meas tran vdout0_28ck520 FIND v(dout0_28) AT=265.025n

.meas tran vdout0_29ck520 FIND v(dout0_29) AT=265.025n

.meas tran vdout0_30ck520 FIND v(dout0_30) AT=265.025n

.meas tran vdout0_31ck520 FIND v(dout0_31) AT=265.025n

.meas tran vdout0_32ck520 FIND v(dout0_32) AT=265.025n

.meas tran vdout0_33ck520 FIND v(dout0_33) AT=265.025n

.meas tran vdout0_34ck520 FIND v(dout0_34) AT=265.025n

.meas tran vdout0_35ck520 FIND v(dout0_35) AT=265.025n

.meas tran vdout0_36ck520 FIND v(dout0_36) AT=265.025n

.meas tran vdout0_37ck520 FIND v(dout0_37) AT=265.025n

.meas tran vdout0_38ck520 FIND v(dout0_38) AT=265.025n

.meas tran vdout0_39ck520 FIND v(dout0_39) AT=265.025n

.meas tran vdout0_40ck520 FIND v(dout0_40) AT=265.025n

.meas tran vdout0_41ck520 FIND v(dout0_41) AT=265.025n

.meas tran vdout0_42ck520 FIND v(dout0_42) AT=265.025n

.meas tran vdout0_43ck520 FIND v(dout0_43) AT=265.025n

.meas tran vdout0_44ck520 FIND v(dout0_44) AT=265.025n

.meas tran vdout0_45ck520 FIND v(dout0_45) AT=265.025n

.meas tran vdout0_46ck520 FIND v(dout0_46) AT=265.025n

.meas tran vdout0_47ck520 FIND v(dout0_47) AT=265.025n

.meas tran vdout0_48ck520 FIND v(dout0_48) AT=265.025n

.meas tran vdout0_49ck520 FIND v(dout0_49) AT=265.025n

.meas tran vdout0_50ck520 FIND v(dout0_50) AT=265.025n

.meas tran vdout0_51ck520 FIND v(dout0_51) AT=265.025n

.meas tran vdout0_52ck520 FIND v(dout0_52) AT=265.025n

.meas tran vdout0_53ck520 FIND v(dout0_53) AT=265.025n

.meas tran vdout0_54ck520 FIND v(dout0_54) AT=265.025n

.meas tran vdout0_55ck520 FIND v(dout0_55) AT=265.025n

.meas tran vdout0_56ck520 FIND v(dout0_56) AT=265.025n

.meas tran vdout0_57ck520 FIND v(dout0_57) AT=265.025n

.meas tran vdout0_58ck520 FIND v(dout0_58) AT=265.025n

.meas tran vdout0_59ck520 FIND v(dout0_59) AT=265.025n

.meas tran vdout0_60ck520 FIND v(dout0_60) AT=265.025n

.meas tran vdout0_61ck520 FIND v(dout0_61) AT=265.025n

.meas tran vdout0_62ck520 FIND v(dout0_62) AT=265.025n

.meas tran vdout0_63ck520 FIND v(dout0_63) AT=265.025n

.meas tran vdout0_64ck520 FIND v(dout0_64) AT=265.025n

.meas tran vdout0_65ck520 FIND v(dout0_65) AT=265.025n

.meas tran vdout0_66ck520 FIND v(dout0_66) AT=265.025n

.meas tran vdout0_67ck520 FIND v(dout0_67) AT=265.025n

.meas tran vdout0_68ck520 FIND v(dout0_68) AT=265.025n

.meas tran vdout0_69ck520 FIND v(dout0_69) AT=265.025n

.meas tran vdout0_70ck520 FIND v(dout0_70) AT=265.025n

.meas tran vdout0_71ck520 FIND v(dout0_71) AT=265.025n

.meas tran vdout0_72ck520 FIND v(dout0_72) AT=265.025n

.meas tran vdout0_73ck520 FIND v(dout0_73) AT=265.025n

.meas tran vdout0_74ck520 FIND v(dout0_74) AT=265.025n

.meas tran vdout0_75ck520 FIND v(dout0_75) AT=265.025n

.meas tran vdout0_76ck520 FIND v(dout0_76) AT=265.025n

.meas tran vdout0_77ck520 FIND v(dout0_77) AT=265.025n

.meas tran vdout0_78ck520 FIND v(dout0_78) AT=265.025n

.meas tran vdout0_79ck520 FIND v(dout0_79) AT=265.025n

.meas tran vdout0_80ck520 FIND v(dout0_80) AT=265.025n

.meas tran vdout0_81ck520 FIND v(dout0_81) AT=265.025n

.meas tran vdout0_82ck520 FIND v(dout0_82) AT=265.025n

.meas tran vdout0_83ck520 FIND v(dout0_83) AT=265.025n

.meas tran vdout0_84ck520 FIND v(dout0_84) AT=265.025n

.meas tran vdout0_85ck520 FIND v(dout0_85) AT=265.025n

.meas tran vdout0_86ck520 FIND v(dout0_86) AT=265.025n

.meas tran vdout0_87ck520 FIND v(dout0_87) AT=265.025n

.meas tran vdout0_88ck520 FIND v(dout0_88) AT=265.025n

.meas tran vdout0_89ck520 FIND v(dout0_89) AT=265.025n

.meas tran vdout0_90ck520 FIND v(dout0_90) AT=265.025n

.meas tran vdout0_91ck520 FIND v(dout0_91) AT=265.025n

.meas tran vdout0_92ck520 FIND v(dout0_92) AT=265.025n

.meas tran vdout0_93ck520 FIND v(dout0_93) AT=265.025n

.meas tran vdout0_94ck520 FIND v(dout0_94) AT=265.025n

.meas tran vdout0_95ck520 FIND v(dout0_95) AT=265.025n

.meas tran vdout0_96ck520 FIND v(dout0_96) AT=265.025n

.meas tran vdout0_97ck520 FIND v(dout0_97) AT=265.025n

.meas tran vdout0_98ck520 FIND v(dout0_98) AT=265.025n

.meas tran vdout0_99ck520 FIND v(dout0_99) AT=265.025n

.meas tran vdout0_100ck520 FIND v(dout0_100) AT=265.025n

.meas tran vdout0_101ck520 FIND v(dout0_101) AT=265.025n

.meas tran vdout0_102ck520 FIND v(dout0_102) AT=265.025n

.meas tran vdout0_103ck520 FIND v(dout0_103) AT=265.025n

.meas tran vdout0_104ck520 FIND v(dout0_104) AT=265.025n

.meas tran vdout0_105ck520 FIND v(dout0_105) AT=265.025n

.meas tran vdout0_106ck520 FIND v(dout0_106) AT=265.025n

.meas tran vdout0_107ck520 FIND v(dout0_107) AT=265.025n

.meas tran vdout0_108ck520 FIND v(dout0_108) AT=265.025n

.meas tran vdout0_109ck520 FIND v(dout0_109) AT=265.025n

.meas tran vdout0_110ck520 FIND v(dout0_110) AT=265.025n

.meas tran vdout0_111ck520 FIND v(dout0_111) AT=265.025n

.meas tran vdout0_112ck520 FIND v(dout0_112) AT=265.025n

.meas tran vdout0_113ck520 FIND v(dout0_113) AT=265.025n

.meas tran vdout0_114ck520 FIND v(dout0_114) AT=265.025n

.meas tran vdout0_115ck520 FIND v(dout0_115) AT=265.025n

.meas tran vdout0_116ck520 FIND v(dout0_116) AT=265.025n

.meas tran vdout0_117ck520 FIND v(dout0_117) AT=265.025n

.meas tran vdout0_118ck520 FIND v(dout0_118) AT=265.025n

.meas tran vdout0_119ck520 FIND v(dout0_119) AT=265.025n

.meas tran vdout0_120ck520 FIND v(dout0_120) AT=265.025n

.meas tran vdout0_121ck520 FIND v(dout0_121) AT=265.025n

.meas tran vdout0_122ck520 FIND v(dout0_122) AT=265.025n

.meas tran vdout0_123ck520 FIND v(dout0_123) AT=265.025n

.meas tran vdout0_124ck520 FIND v(dout0_124) AT=265.025n

.meas tran vdout0_125ck520 FIND v(dout0_125) AT=265.025n

.meas tran vdout0_126ck520 FIND v(dout0_126) AT=265.025n

.meas tran vdout0_127ck520 FIND v(dout0_127) AT=265.025n

.meas tran vdout0_128ck520 FIND v(dout0_128) AT=265.025n

.meas tran vdout0_129ck520 FIND v(dout0_129) AT=265.025n

.meas tran vdout0_130ck520 FIND v(dout0_130) AT=265.025n

.meas tran vdout0_131ck520 FIND v(dout0_131) AT=265.025n

.meas tran vdout0_132ck520 FIND v(dout0_132) AT=265.025n

.meas tran vdout0_133ck520 FIND v(dout0_133) AT=265.025n

.meas tran vdout0_134ck520 FIND v(dout0_134) AT=265.025n

.meas tran vdout0_135ck520 FIND v(dout0_135) AT=265.025n

.meas tran vdout0_136ck520 FIND v(dout0_136) AT=265.025n

.meas tran vdout0_137ck520 FIND v(dout0_137) AT=265.025n

.meas tran vdout0_138ck520 FIND v(dout0_138) AT=265.025n

.meas tran vdout0_139ck520 FIND v(dout0_139) AT=265.025n

.meas tran vdout0_140ck520 FIND v(dout0_140) AT=265.025n

.meas tran vdout0_141ck520 FIND v(dout0_141) AT=265.025n

.meas tran vdout0_142ck520 FIND v(dout0_142) AT=265.025n

.meas tran vdout0_143ck520 FIND v(dout0_143) AT=265.025n

.meas tran vdout0_144ck520 FIND v(dout0_144) AT=265.025n

.meas tran vdout0_145ck520 FIND v(dout0_145) AT=265.025n

.meas tran vdout0_146ck520 FIND v(dout0_146) AT=265.025n

.meas tran vdout0_147ck520 FIND v(dout0_147) AT=265.025n

.meas tran vdout0_148ck520 FIND v(dout0_148) AT=265.025n

.meas tran vdout0_149ck520 FIND v(dout0_149) AT=265.025n

.meas tran vdout0_0ck530 FIND v(dout0_0) AT=270.025n

.meas tran vdout0_1ck530 FIND v(dout0_1) AT=270.025n

.meas tran vdout0_2ck530 FIND v(dout0_2) AT=270.025n

.meas tran vdout0_3ck530 FIND v(dout0_3) AT=270.025n

.meas tran vdout0_4ck530 FIND v(dout0_4) AT=270.025n

.meas tran vdout0_5ck530 FIND v(dout0_5) AT=270.025n

.meas tran vdout0_6ck530 FIND v(dout0_6) AT=270.025n

.meas tran vdout0_7ck530 FIND v(dout0_7) AT=270.025n

.meas tran vdout0_8ck530 FIND v(dout0_8) AT=270.025n

.meas tran vdout0_9ck530 FIND v(dout0_9) AT=270.025n

.meas tran vdout0_10ck530 FIND v(dout0_10) AT=270.025n

.meas tran vdout0_11ck530 FIND v(dout0_11) AT=270.025n

.meas tran vdout0_12ck530 FIND v(dout0_12) AT=270.025n

.meas tran vdout0_13ck530 FIND v(dout0_13) AT=270.025n

.meas tran vdout0_14ck530 FIND v(dout0_14) AT=270.025n

.meas tran vdout0_15ck530 FIND v(dout0_15) AT=270.025n

.meas tran vdout0_16ck530 FIND v(dout0_16) AT=270.025n

.meas tran vdout0_17ck530 FIND v(dout0_17) AT=270.025n

.meas tran vdout0_18ck530 FIND v(dout0_18) AT=270.025n

.meas tran vdout0_19ck530 FIND v(dout0_19) AT=270.025n

.meas tran vdout0_20ck530 FIND v(dout0_20) AT=270.025n

.meas tran vdout0_21ck530 FIND v(dout0_21) AT=270.025n

.meas tran vdout0_22ck530 FIND v(dout0_22) AT=270.025n

.meas tran vdout0_23ck530 FIND v(dout0_23) AT=270.025n

.meas tran vdout0_24ck530 FIND v(dout0_24) AT=270.025n

.meas tran vdout0_25ck530 FIND v(dout0_25) AT=270.025n

.meas tran vdout0_26ck530 FIND v(dout0_26) AT=270.025n

.meas tran vdout0_27ck530 FIND v(dout0_27) AT=270.025n

.meas tran vdout0_28ck530 FIND v(dout0_28) AT=270.025n

.meas tran vdout0_29ck530 FIND v(dout0_29) AT=270.025n

.meas tran vdout0_30ck530 FIND v(dout0_30) AT=270.025n

.meas tran vdout0_31ck530 FIND v(dout0_31) AT=270.025n

.meas tran vdout0_32ck530 FIND v(dout0_32) AT=270.025n

.meas tran vdout0_33ck530 FIND v(dout0_33) AT=270.025n

.meas tran vdout0_34ck530 FIND v(dout0_34) AT=270.025n

.meas tran vdout0_35ck530 FIND v(dout0_35) AT=270.025n

.meas tran vdout0_36ck530 FIND v(dout0_36) AT=270.025n

.meas tran vdout0_37ck530 FIND v(dout0_37) AT=270.025n

.meas tran vdout0_38ck530 FIND v(dout0_38) AT=270.025n

.meas tran vdout0_39ck530 FIND v(dout0_39) AT=270.025n

.meas tran vdout0_40ck530 FIND v(dout0_40) AT=270.025n

.meas tran vdout0_41ck530 FIND v(dout0_41) AT=270.025n

.meas tran vdout0_42ck530 FIND v(dout0_42) AT=270.025n

.meas tran vdout0_43ck530 FIND v(dout0_43) AT=270.025n

.meas tran vdout0_44ck530 FIND v(dout0_44) AT=270.025n

.meas tran vdout0_45ck530 FIND v(dout0_45) AT=270.025n

.meas tran vdout0_46ck530 FIND v(dout0_46) AT=270.025n

.meas tran vdout0_47ck530 FIND v(dout0_47) AT=270.025n

.meas tran vdout0_48ck530 FIND v(dout0_48) AT=270.025n

.meas tran vdout0_49ck530 FIND v(dout0_49) AT=270.025n

.meas tran vdout0_50ck530 FIND v(dout0_50) AT=270.025n

.meas tran vdout0_51ck530 FIND v(dout0_51) AT=270.025n

.meas tran vdout0_52ck530 FIND v(dout0_52) AT=270.025n

.meas tran vdout0_53ck530 FIND v(dout0_53) AT=270.025n

.meas tran vdout0_54ck530 FIND v(dout0_54) AT=270.025n

.meas tran vdout0_55ck530 FIND v(dout0_55) AT=270.025n

.meas tran vdout0_56ck530 FIND v(dout0_56) AT=270.025n

.meas tran vdout0_57ck530 FIND v(dout0_57) AT=270.025n

.meas tran vdout0_58ck530 FIND v(dout0_58) AT=270.025n

.meas tran vdout0_59ck530 FIND v(dout0_59) AT=270.025n

.meas tran vdout0_60ck530 FIND v(dout0_60) AT=270.025n

.meas tran vdout0_61ck530 FIND v(dout0_61) AT=270.025n

.meas tran vdout0_62ck530 FIND v(dout0_62) AT=270.025n

.meas tran vdout0_63ck530 FIND v(dout0_63) AT=270.025n

.meas tran vdout0_64ck530 FIND v(dout0_64) AT=270.025n

.meas tran vdout0_65ck530 FIND v(dout0_65) AT=270.025n

.meas tran vdout0_66ck530 FIND v(dout0_66) AT=270.025n

.meas tran vdout0_67ck530 FIND v(dout0_67) AT=270.025n

.meas tran vdout0_68ck530 FIND v(dout0_68) AT=270.025n

.meas tran vdout0_69ck530 FIND v(dout0_69) AT=270.025n

.meas tran vdout0_70ck530 FIND v(dout0_70) AT=270.025n

.meas tran vdout0_71ck530 FIND v(dout0_71) AT=270.025n

.meas tran vdout0_72ck530 FIND v(dout0_72) AT=270.025n

.meas tran vdout0_73ck530 FIND v(dout0_73) AT=270.025n

.meas tran vdout0_74ck530 FIND v(dout0_74) AT=270.025n

.meas tran vdout0_75ck530 FIND v(dout0_75) AT=270.025n

.meas tran vdout0_76ck530 FIND v(dout0_76) AT=270.025n

.meas tran vdout0_77ck530 FIND v(dout0_77) AT=270.025n

.meas tran vdout0_78ck530 FIND v(dout0_78) AT=270.025n

.meas tran vdout0_79ck530 FIND v(dout0_79) AT=270.025n

.meas tran vdout0_80ck530 FIND v(dout0_80) AT=270.025n

.meas tran vdout0_81ck530 FIND v(dout0_81) AT=270.025n

.meas tran vdout0_82ck530 FIND v(dout0_82) AT=270.025n

.meas tran vdout0_83ck530 FIND v(dout0_83) AT=270.025n

.meas tran vdout0_84ck530 FIND v(dout0_84) AT=270.025n

.meas tran vdout0_85ck530 FIND v(dout0_85) AT=270.025n

.meas tran vdout0_86ck530 FIND v(dout0_86) AT=270.025n

.meas tran vdout0_87ck530 FIND v(dout0_87) AT=270.025n

.meas tran vdout0_88ck530 FIND v(dout0_88) AT=270.025n

.meas tran vdout0_89ck530 FIND v(dout0_89) AT=270.025n

.meas tran vdout0_90ck530 FIND v(dout0_90) AT=270.025n

.meas tran vdout0_91ck530 FIND v(dout0_91) AT=270.025n

.meas tran vdout0_92ck530 FIND v(dout0_92) AT=270.025n

.meas tran vdout0_93ck530 FIND v(dout0_93) AT=270.025n

.meas tran vdout0_94ck530 FIND v(dout0_94) AT=270.025n

.meas tran vdout0_95ck530 FIND v(dout0_95) AT=270.025n

.meas tran vdout0_96ck530 FIND v(dout0_96) AT=270.025n

.meas tran vdout0_97ck530 FIND v(dout0_97) AT=270.025n

.meas tran vdout0_98ck530 FIND v(dout0_98) AT=270.025n

.meas tran vdout0_99ck530 FIND v(dout0_99) AT=270.025n

.meas tran vdout0_100ck530 FIND v(dout0_100) AT=270.025n

.meas tran vdout0_101ck530 FIND v(dout0_101) AT=270.025n

.meas tran vdout0_102ck530 FIND v(dout0_102) AT=270.025n

.meas tran vdout0_103ck530 FIND v(dout0_103) AT=270.025n

.meas tran vdout0_104ck530 FIND v(dout0_104) AT=270.025n

.meas tran vdout0_105ck530 FIND v(dout0_105) AT=270.025n

.meas tran vdout0_106ck530 FIND v(dout0_106) AT=270.025n

.meas tran vdout0_107ck530 FIND v(dout0_107) AT=270.025n

.meas tran vdout0_108ck530 FIND v(dout0_108) AT=270.025n

.meas tran vdout0_109ck530 FIND v(dout0_109) AT=270.025n

.meas tran vdout0_110ck530 FIND v(dout0_110) AT=270.025n

.meas tran vdout0_111ck530 FIND v(dout0_111) AT=270.025n

.meas tran vdout0_112ck530 FIND v(dout0_112) AT=270.025n

.meas tran vdout0_113ck530 FIND v(dout0_113) AT=270.025n

.meas tran vdout0_114ck530 FIND v(dout0_114) AT=270.025n

.meas tran vdout0_115ck530 FIND v(dout0_115) AT=270.025n

.meas tran vdout0_116ck530 FIND v(dout0_116) AT=270.025n

.meas tran vdout0_117ck530 FIND v(dout0_117) AT=270.025n

.meas tran vdout0_118ck530 FIND v(dout0_118) AT=270.025n

.meas tran vdout0_119ck530 FIND v(dout0_119) AT=270.025n

.meas tran vdout0_120ck530 FIND v(dout0_120) AT=270.025n

.meas tran vdout0_121ck530 FIND v(dout0_121) AT=270.025n

.meas tran vdout0_122ck530 FIND v(dout0_122) AT=270.025n

.meas tran vdout0_123ck530 FIND v(dout0_123) AT=270.025n

.meas tran vdout0_124ck530 FIND v(dout0_124) AT=270.025n

.meas tran vdout0_125ck530 FIND v(dout0_125) AT=270.025n

.meas tran vdout0_126ck530 FIND v(dout0_126) AT=270.025n

.meas tran vdout0_127ck530 FIND v(dout0_127) AT=270.025n

.meas tran vdout0_128ck530 FIND v(dout0_128) AT=270.025n

.meas tran vdout0_129ck530 FIND v(dout0_129) AT=270.025n

.meas tran vdout0_130ck530 FIND v(dout0_130) AT=270.025n

.meas tran vdout0_131ck530 FIND v(dout0_131) AT=270.025n

.meas tran vdout0_132ck530 FIND v(dout0_132) AT=270.025n

.meas tran vdout0_133ck530 FIND v(dout0_133) AT=270.025n

.meas tran vdout0_134ck530 FIND v(dout0_134) AT=270.025n

.meas tran vdout0_135ck530 FIND v(dout0_135) AT=270.025n

.meas tran vdout0_136ck530 FIND v(dout0_136) AT=270.025n

.meas tran vdout0_137ck530 FIND v(dout0_137) AT=270.025n

.meas tran vdout0_138ck530 FIND v(dout0_138) AT=270.025n

.meas tran vdout0_139ck530 FIND v(dout0_139) AT=270.025n

.meas tran vdout0_140ck530 FIND v(dout0_140) AT=270.025n

.meas tran vdout0_141ck530 FIND v(dout0_141) AT=270.025n

.meas tran vdout0_142ck530 FIND v(dout0_142) AT=270.025n

.meas tran vdout0_143ck530 FIND v(dout0_143) AT=270.025n

.meas tran vdout0_144ck530 FIND v(dout0_144) AT=270.025n

.meas tran vdout0_145ck530 FIND v(dout0_145) AT=270.025n

.meas tran vdout0_146ck530 FIND v(dout0_146) AT=270.025n

.meas tran vdout0_147ck530 FIND v(dout0_147) AT=270.025n

.meas tran vdout0_148ck530 FIND v(dout0_148) AT=270.025n

.meas tran vdout0_149ck530 FIND v(dout0_149) AT=270.025n

.meas tran vdout0_0ck550 FIND v(dout0_0) AT=280.025n

.meas tran vdout0_1ck550 FIND v(dout0_1) AT=280.025n

.meas tran vdout0_2ck550 FIND v(dout0_2) AT=280.025n

.meas tran vdout0_3ck550 FIND v(dout0_3) AT=280.025n

.meas tran vdout0_4ck550 FIND v(dout0_4) AT=280.025n

.meas tran vdout0_5ck550 FIND v(dout0_5) AT=280.025n

.meas tran vdout0_6ck550 FIND v(dout0_6) AT=280.025n

.meas tran vdout0_7ck550 FIND v(dout0_7) AT=280.025n

.meas tran vdout0_8ck550 FIND v(dout0_8) AT=280.025n

.meas tran vdout0_9ck550 FIND v(dout0_9) AT=280.025n

.meas tran vdout0_10ck550 FIND v(dout0_10) AT=280.025n

.meas tran vdout0_11ck550 FIND v(dout0_11) AT=280.025n

.meas tran vdout0_12ck550 FIND v(dout0_12) AT=280.025n

.meas tran vdout0_13ck550 FIND v(dout0_13) AT=280.025n

.meas tran vdout0_14ck550 FIND v(dout0_14) AT=280.025n

.meas tran vdout0_15ck550 FIND v(dout0_15) AT=280.025n

.meas tran vdout0_16ck550 FIND v(dout0_16) AT=280.025n

.meas tran vdout0_17ck550 FIND v(dout0_17) AT=280.025n

.meas tran vdout0_18ck550 FIND v(dout0_18) AT=280.025n

.meas tran vdout0_19ck550 FIND v(dout0_19) AT=280.025n

.meas tran vdout0_20ck550 FIND v(dout0_20) AT=280.025n

.meas tran vdout0_21ck550 FIND v(dout0_21) AT=280.025n

.meas tran vdout0_22ck550 FIND v(dout0_22) AT=280.025n

.meas tran vdout0_23ck550 FIND v(dout0_23) AT=280.025n

.meas tran vdout0_24ck550 FIND v(dout0_24) AT=280.025n

.meas tran vdout0_25ck550 FIND v(dout0_25) AT=280.025n

.meas tran vdout0_26ck550 FIND v(dout0_26) AT=280.025n

.meas tran vdout0_27ck550 FIND v(dout0_27) AT=280.025n

.meas tran vdout0_28ck550 FIND v(dout0_28) AT=280.025n

.meas tran vdout0_29ck550 FIND v(dout0_29) AT=280.025n

.meas tran vdout0_30ck550 FIND v(dout0_30) AT=280.025n

.meas tran vdout0_31ck550 FIND v(dout0_31) AT=280.025n

.meas tran vdout0_32ck550 FIND v(dout0_32) AT=280.025n

.meas tran vdout0_33ck550 FIND v(dout0_33) AT=280.025n

.meas tran vdout0_34ck550 FIND v(dout0_34) AT=280.025n

.meas tran vdout0_35ck550 FIND v(dout0_35) AT=280.025n

.meas tran vdout0_36ck550 FIND v(dout0_36) AT=280.025n

.meas tran vdout0_37ck550 FIND v(dout0_37) AT=280.025n

.meas tran vdout0_38ck550 FIND v(dout0_38) AT=280.025n

.meas tran vdout0_39ck550 FIND v(dout0_39) AT=280.025n

.meas tran vdout0_40ck550 FIND v(dout0_40) AT=280.025n

.meas tran vdout0_41ck550 FIND v(dout0_41) AT=280.025n

.meas tran vdout0_42ck550 FIND v(dout0_42) AT=280.025n

.meas tran vdout0_43ck550 FIND v(dout0_43) AT=280.025n

.meas tran vdout0_44ck550 FIND v(dout0_44) AT=280.025n

.meas tran vdout0_45ck550 FIND v(dout0_45) AT=280.025n

.meas tran vdout0_46ck550 FIND v(dout0_46) AT=280.025n

.meas tran vdout0_47ck550 FIND v(dout0_47) AT=280.025n

.meas tran vdout0_48ck550 FIND v(dout0_48) AT=280.025n

.meas tran vdout0_49ck550 FIND v(dout0_49) AT=280.025n

.meas tran vdout0_50ck550 FIND v(dout0_50) AT=280.025n

.meas tran vdout0_51ck550 FIND v(dout0_51) AT=280.025n

.meas tran vdout0_52ck550 FIND v(dout0_52) AT=280.025n

.meas tran vdout0_53ck550 FIND v(dout0_53) AT=280.025n

.meas tran vdout0_54ck550 FIND v(dout0_54) AT=280.025n

.meas tran vdout0_55ck550 FIND v(dout0_55) AT=280.025n

.meas tran vdout0_56ck550 FIND v(dout0_56) AT=280.025n

.meas tran vdout0_57ck550 FIND v(dout0_57) AT=280.025n

.meas tran vdout0_58ck550 FIND v(dout0_58) AT=280.025n

.meas tran vdout0_59ck550 FIND v(dout0_59) AT=280.025n

.meas tran vdout0_60ck550 FIND v(dout0_60) AT=280.025n

.meas tran vdout0_61ck550 FIND v(dout0_61) AT=280.025n

.meas tran vdout0_62ck550 FIND v(dout0_62) AT=280.025n

.meas tran vdout0_63ck550 FIND v(dout0_63) AT=280.025n

.meas tran vdout0_64ck550 FIND v(dout0_64) AT=280.025n

.meas tran vdout0_65ck550 FIND v(dout0_65) AT=280.025n

.meas tran vdout0_66ck550 FIND v(dout0_66) AT=280.025n

.meas tran vdout0_67ck550 FIND v(dout0_67) AT=280.025n

.meas tran vdout0_68ck550 FIND v(dout0_68) AT=280.025n

.meas tran vdout0_69ck550 FIND v(dout0_69) AT=280.025n

.meas tran vdout0_70ck550 FIND v(dout0_70) AT=280.025n

.meas tran vdout0_71ck550 FIND v(dout0_71) AT=280.025n

.meas tran vdout0_72ck550 FIND v(dout0_72) AT=280.025n

.meas tran vdout0_73ck550 FIND v(dout0_73) AT=280.025n

.meas tran vdout0_74ck550 FIND v(dout0_74) AT=280.025n

.meas tran vdout0_75ck550 FIND v(dout0_75) AT=280.025n

.meas tran vdout0_76ck550 FIND v(dout0_76) AT=280.025n

.meas tran vdout0_77ck550 FIND v(dout0_77) AT=280.025n

.meas tran vdout0_78ck550 FIND v(dout0_78) AT=280.025n

.meas tran vdout0_79ck550 FIND v(dout0_79) AT=280.025n

.meas tran vdout0_80ck550 FIND v(dout0_80) AT=280.025n

.meas tran vdout0_81ck550 FIND v(dout0_81) AT=280.025n

.meas tran vdout0_82ck550 FIND v(dout0_82) AT=280.025n

.meas tran vdout0_83ck550 FIND v(dout0_83) AT=280.025n

.meas tran vdout0_84ck550 FIND v(dout0_84) AT=280.025n

.meas tran vdout0_85ck550 FIND v(dout0_85) AT=280.025n

.meas tran vdout0_86ck550 FIND v(dout0_86) AT=280.025n

.meas tran vdout0_87ck550 FIND v(dout0_87) AT=280.025n

.meas tran vdout0_88ck550 FIND v(dout0_88) AT=280.025n

.meas tran vdout0_89ck550 FIND v(dout0_89) AT=280.025n

.meas tran vdout0_90ck550 FIND v(dout0_90) AT=280.025n

.meas tran vdout0_91ck550 FIND v(dout0_91) AT=280.025n

.meas tran vdout0_92ck550 FIND v(dout0_92) AT=280.025n

.meas tran vdout0_93ck550 FIND v(dout0_93) AT=280.025n

.meas tran vdout0_94ck550 FIND v(dout0_94) AT=280.025n

.meas tran vdout0_95ck550 FIND v(dout0_95) AT=280.025n

.meas tran vdout0_96ck550 FIND v(dout0_96) AT=280.025n

.meas tran vdout0_97ck550 FIND v(dout0_97) AT=280.025n

.meas tran vdout0_98ck550 FIND v(dout0_98) AT=280.025n

.meas tran vdout0_99ck550 FIND v(dout0_99) AT=280.025n

.meas tran vdout0_100ck550 FIND v(dout0_100) AT=280.025n

.meas tran vdout0_101ck550 FIND v(dout0_101) AT=280.025n

.meas tran vdout0_102ck550 FIND v(dout0_102) AT=280.025n

.meas tran vdout0_103ck550 FIND v(dout0_103) AT=280.025n

.meas tran vdout0_104ck550 FIND v(dout0_104) AT=280.025n

.meas tran vdout0_105ck550 FIND v(dout0_105) AT=280.025n

.meas tran vdout0_106ck550 FIND v(dout0_106) AT=280.025n

.meas tran vdout0_107ck550 FIND v(dout0_107) AT=280.025n

.meas tran vdout0_108ck550 FIND v(dout0_108) AT=280.025n

.meas tran vdout0_109ck550 FIND v(dout0_109) AT=280.025n

.meas tran vdout0_110ck550 FIND v(dout0_110) AT=280.025n

.meas tran vdout0_111ck550 FIND v(dout0_111) AT=280.025n

.meas tran vdout0_112ck550 FIND v(dout0_112) AT=280.025n

.meas tran vdout0_113ck550 FIND v(dout0_113) AT=280.025n

.meas tran vdout0_114ck550 FIND v(dout0_114) AT=280.025n

.meas tran vdout0_115ck550 FIND v(dout0_115) AT=280.025n

.meas tran vdout0_116ck550 FIND v(dout0_116) AT=280.025n

.meas tran vdout0_117ck550 FIND v(dout0_117) AT=280.025n

.meas tran vdout0_118ck550 FIND v(dout0_118) AT=280.025n

.meas tran vdout0_119ck550 FIND v(dout0_119) AT=280.025n

.meas tran vdout0_120ck550 FIND v(dout0_120) AT=280.025n

.meas tran vdout0_121ck550 FIND v(dout0_121) AT=280.025n

.meas tran vdout0_122ck550 FIND v(dout0_122) AT=280.025n

.meas tran vdout0_123ck550 FIND v(dout0_123) AT=280.025n

.meas tran vdout0_124ck550 FIND v(dout0_124) AT=280.025n

.meas tran vdout0_125ck550 FIND v(dout0_125) AT=280.025n

.meas tran vdout0_126ck550 FIND v(dout0_126) AT=280.025n

.meas tran vdout0_127ck550 FIND v(dout0_127) AT=280.025n

.meas tran vdout0_128ck550 FIND v(dout0_128) AT=280.025n

.meas tran vdout0_129ck550 FIND v(dout0_129) AT=280.025n

.meas tran vdout0_130ck550 FIND v(dout0_130) AT=280.025n

.meas tran vdout0_131ck550 FIND v(dout0_131) AT=280.025n

.meas tran vdout0_132ck550 FIND v(dout0_132) AT=280.025n

.meas tran vdout0_133ck550 FIND v(dout0_133) AT=280.025n

.meas tran vdout0_134ck550 FIND v(dout0_134) AT=280.025n

.meas tran vdout0_135ck550 FIND v(dout0_135) AT=280.025n

.meas tran vdout0_136ck550 FIND v(dout0_136) AT=280.025n

.meas tran vdout0_137ck550 FIND v(dout0_137) AT=280.025n

.meas tran vdout0_138ck550 FIND v(dout0_138) AT=280.025n

.meas tran vdout0_139ck550 FIND v(dout0_139) AT=280.025n

.meas tran vdout0_140ck550 FIND v(dout0_140) AT=280.025n

.meas tran vdout0_141ck550 FIND v(dout0_141) AT=280.025n

.meas tran vdout0_142ck550 FIND v(dout0_142) AT=280.025n

.meas tran vdout0_143ck550 FIND v(dout0_143) AT=280.025n

.meas tran vdout0_144ck550 FIND v(dout0_144) AT=280.025n

.meas tran vdout0_145ck550 FIND v(dout0_145) AT=280.025n

.meas tran vdout0_146ck550 FIND v(dout0_146) AT=280.025n

.meas tran vdout0_147ck550 FIND v(dout0_147) AT=280.025n

.meas tran vdout0_148ck550 FIND v(dout0_148) AT=280.025n

.meas tran vdout0_149ck550 FIND v(dout0_149) AT=280.025n

.meas tran vdout0_0ck570 FIND v(dout0_0) AT=290.025n

.meas tran vdout0_1ck570 FIND v(dout0_1) AT=290.025n

.meas tran vdout0_2ck570 FIND v(dout0_2) AT=290.025n

.meas tran vdout0_3ck570 FIND v(dout0_3) AT=290.025n

.meas tran vdout0_4ck570 FIND v(dout0_4) AT=290.025n

.meas tran vdout0_5ck570 FIND v(dout0_5) AT=290.025n

.meas tran vdout0_6ck570 FIND v(dout0_6) AT=290.025n

.meas tran vdout0_7ck570 FIND v(dout0_7) AT=290.025n

.meas tran vdout0_8ck570 FIND v(dout0_8) AT=290.025n

.meas tran vdout0_9ck570 FIND v(dout0_9) AT=290.025n

.meas tran vdout0_10ck570 FIND v(dout0_10) AT=290.025n

.meas tran vdout0_11ck570 FIND v(dout0_11) AT=290.025n

.meas tran vdout0_12ck570 FIND v(dout0_12) AT=290.025n

.meas tran vdout0_13ck570 FIND v(dout0_13) AT=290.025n

.meas tran vdout0_14ck570 FIND v(dout0_14) AT=290.025n

.meas tran vdout0_15ck570 FIND v(dout0_15) AT=290.025n

.meas tran vdout0_16ck570 FIND v(dout0_16) AT=290.025n

.meas tran vdout0_17ck570 FIND v(dout0_17) AT=290.025n

.meas tran vdout0_18ck570 FIND v(dout0_18) AT=290.025n

.meas tran vdout0_19ck570 FIND v(dout0_19) AT=290.025n

.meas tran vdout0_20ck570 FIND v(dout0_20) AT=290.025n

.meas tran vdout0_21ck570 FIND v(dout0_21) AT=290.025n

.meas tran vdout0_22ck570 FIND v(dout0_22) AT=290.025n

.meas tran vdout0_23ck570 FIND v(dout0_23) AT=290.025n

.meas tran vdout0_24ck570 FIND v(dout0_24) AT=290.025n

.meas tran vdout0_25ck570 FIND v(dout0_25) AT=290.025n

.meas tran vdout0_26ck570 FIND v(dout0_26) AT=290.025n

.meas tran vdout0_27ck570 FIND v(dout0_27) AT=290.025n

.meas tran vdout0_28ck570 FIND v(dout0_28) AT=290.025n

.meas tran vdout0_29ck570 FIND v(dout0_29) AT=290.025n

.meas tran vdout0_30ck570 FIND v(dout0_30) AT=290.025n

.meas tran vdout0_31ck570 FIND v(dout0_31) AT=290.025n

.meas tran vdout0_32ck570 FIND v(dout0_32) AT=290.025n

.meas tran vdout0_33ck570 FIND v(dout0_33) AT=290.025n

.meas tran vdout0_34ck570 FIND v(dout0_34) AT=290.025n

.meas tran vdout0_35ck570 FIND v(dout0_35) AT=290.025n

.meas tran vdout0_36ck570 FIND v(dout0_36) AT=290.025n

.meas tran vdout0_37ck570 FIND v(dout0_37) AT=290.025n

.meas tran vdout0_38ck570 FIND v(dout0_38) AT=290.025n

.meas tran vdout0_39ck570 FIND v(dout0_39) AT=290.025n

.meas tran vdout0_40ck570 FIND v(dout0_40) AT=290.025n

.meas tran vdout0_41ck570 FIND v(dout0_41) AT=290.025n

.meas tran vdout0_42ck570 FIND v(dout0_42) AT=290.025n

.meas tran vdout0_43ck570 FIND v(dout0_43) AT=290.025n

.meas tran vdout0_44ck570 FIND v(dout0_44) AT=290.025n

.meas tran vdout0_45ck570 FIND v(dout0_45) AT=290.025n

.meas tran vdout0_46ck570 FIND v(dout0_46) AT=290.025n

.meas tran vdout0_47ck570 FIND v(dout0_47) AT=290.025n

.meas tran vdout0_48ck570 FIND v(dout0_48) AT=290.025n

.meas tran vdout0_49ck570 FIND v(dout0_49) AT=290.025n

.meas tran vdout0_50ck570 FIND v(dout0_50) AT=290.025n

.meas tran vdout0_51ck570 FIND v(dout0_51) AT=290.025n

.meas tran vdout0_52ck570 FIND v(dout0_52) AT=290.025n

.meas tran vdout0_53ck570 FIND v(dout0_53) AT=290.025n

.meas tran vdout0_54ck570 FIND v(dout0_54) AT=290.025n

.meas tran vdout0_55ck570 FIND v(dout0_55) AT=290.025n

.meas tran vdout0_56ck570 FIND v(dout0_56) AT=290.025n

.meas tran vdout0_57ck570 FIND v(dout0_57) AT=290.025n

.meas tran vdout0_58ck570 FIND v(dout0_58) AT=290.025n

.meas tran vdout0_59ck570 FIND v(dout0_59) AT=290.025n

.meas tran vdout0_60ck570 FIND v(dout0_60) AT=290.025n

.meas tran vdout0_61ck570 FIND v(dout0_61) AT=290.025n

.meas tran vdout0_62ck570 FIND v(dout0_62) AT=290.025n

.meas tran vdout0_63ck570 FIND v(dout0_63) AT=290.025n

.meas tran vdout0_64ck570 FIND v(dout0_64) AT=290.025n

.meas tran vdout0_65ck570 FIND v(dout0_65) AT=290.025n

.meas tran vdout0_66ck570 FIND v(dout0_66) AT=290.025n

.meas tran vdout0_67ck570 FIND v(dout0_67) AT=290.025n

.meas tran vdout0_68ck570 FIND v(dout0_68) AT=290.025n

.meas tran vdout0_69ck570 FIND v(dout0_69) AT=290.025n

.meas tran vdout0_70ck570 FIND v(dout0_70) AT=290.025n

.meas tran vdout0_71ck570 FIND v(dout0_71) AT=290.025n

.meas tran vdout0_72ck570 FIND v(dout0_72) AT=290.025n

.meas tran vdout0_73ck570 FIND v(dout0_73) AT=290.025n

.meas tran vdout0_74ck570 FIND v(dout0_74) AT=290.025n

.meas tran vdout0_75ck570 FIND v(dout0_75) AT=290.025n

.meas tran vdout0_76ck570 FIND v(dout0_76) AT=290.025n

.meas tran vdout0_77ck570 FIND v(dout0_77) AT=290.025n

.meas tran vdout0_78ck570 FIND v(dout0_78) AT=290.025n

.meas tran vdout0_79ck570 FIND v(dout0_79) AT=290.025n

.meas tran vdout0_80ck570 FIND v(dout0_80) AT=290.025n

.meas tran vdout0_81ck570 FIND v(dout0_81) AT=290.025n

.meas tran vdout0_82ck570 FIND v(dout0_82) AT=290.025n

.meas tran vdout0_83ck570 FIND v(dout0_83) AT=290.025n

.meas tran vdout0_84ck570 FIND v(dout0_84) AT=290.025n

.meas tran vdout0_85ck570 FIND v(dout0_85) AT=290.025n

.meas tran vdout0_86ck570 FIND v(dout0_86) AT=290.025n

.meas tran vdout0_87ck570 FIND v(dout0_87) AT=290.025n

.meas tran vdout0_88ck570 FIND v(dout0_88) AT=290.025n

.meas tran vdout0_89ck570 FIND v(dout0_89) AT=290.025n

.meas tran vdout0_90ck570 FIND v(dout0_90) AT=290.025n

.meas tran vdout0_91ck570 FIND v(dout0_91) AT=290.025n

.meas tran vdout0_92ck570 FIND v(dout0_92) AT=290.025n

.meas tran vdout0_93ck570 FIND v(dout0_93) AT=290.025n

.meas tran vdout0_94ck570 FIND v(dout0_94) AT=290.025n

.meas tran vdout0_95ck570 FIND v(dout0_95) AT=290.025n

.meas tran vdout0_96ck570 FIND v(dout0_96) AT=290.025n

.meas tran vdout0_97ck570 FIND v(dout0_97) AT=290.025n

.meas tran vdout0_98ck570 FIND v(dout0_98) AT=290.025n

.meas tran vdout0_99ck570 FIND v(dout0_99) AT=290.025n

.meas tran vdout0_100ck570 FIND v(dout0_100) AT=290.025n

.meas tran vdout0_101ck570 FIND v(dout0_101) AT=290.025n

.meas tran vdout0_102ck570 FIND v(dout0_102) AT=290.025n

.meas tran vdout0_103ck570 FIND v(dout0_103) AT=290.025n

.meas tran vdout0_104ck570 FIND v(dout0_104) AT=290.025n

.meas tran vdout0_105ck570 FIND v(dout0_105) AT=290.025n

.meas tran vdout0_106ck570 FIND v(dout0_106) AT=290.025n

.meas tran vdout0_107ck570 FIND v(dout0_107) AT=290.025n

.meas tran vdout0_108ck570 FIND v(dout0_108) AT=290.025n

.meas tran vdout0_109ck570 FIND v(dout0_109) AT=290.025n

.meas tran vdout0_110ck570 FIND v(dout0_110) AT=290.025n

.meas tran vdout0_111ck570 FIND v(dout0_111) AT=290.025n

.meas tran vdout0_112ck570 FIND v(dout0_112) AT=290.025n

.meas tran vdout0_113ck570 FIND v(dout0_113) AT=290.025n

.meas tran vdout0_114ck570 FIND v(dout0_114) AT=290.025n

.meas tran vdout0_115ck570 FIND v(dout0_115) AT=290.025n

.meas tran vdout0_116ck570 FIND v(dout0_116) AT=290.025n

.meas tran vdout0_117ck570 FIND v(dout0_117) AT=290.025n

.meas tran vdout0_118ck570 FIND v(dout0_118) AT=290.025n

.meas tran vdout0_119ck570 FIND v(dout0_119) AT=290.025n

.meas tran vdout0_120ck570 FIND v(dout0_120) AT=290.025n

.meas tran vdout0_121ck570 FIND v(dout0_121) AT=290.025n

.meas tran vdout0_122ck570 FIND v(dout0_122) AT=290.025n

.meas tran vdout0_123ck570 FIND v(dout0_123) AT=290.025n

.meas tran vdout0_124ck570 FIND v(dout0_124) AT=290.025n

.meas tran vdout0_125ck570 FIND v(dout0_125) AT=290.025n

.meas tran vdout0_126ck570 FIND v(dout0_126) AT=290.025n

.meas tran vdout0_127ck570 FIND v(dout0_127) AT=290.025n

.meas tran vdout0_128ck570 FIND v(dout0_128) AT=290.025n

.meas tran vdout0_129ck570 FIND v(dout0_129) AT=290.025n

.meas tran vdout0_130ck570 FIND v(dout0_130) AT=290.025n

.meas tran vdout0_131ck570 FIND v(dout0_131) AT=290.025n

.meas tran vdout0_132ck570 FIND v(dout0_132) AT=290.025n

.meas tran vdout0_133ck570 FIND v(dout0_133) AT=290.025n

.meas tran vdout0_134ck570 FIND v(dout0_134) AT=290.025n

.meas tran vdout0_135ck570 FIND v(dout0_135) AT=290.025n

.meas tran vdout0_136ck570 FIND v(dout0_136) AT=290.025n

.meas tran vdout0_137ck570 FIND v(dout0_137) AT=290.025n

.meas tran vdout0_138ck570 FIND v(dout0_138) AT=290.025n

.meas tran vdout0_139ck570 FIND v(dout0_139) AT=290.025n

.meas tran vdout0_140ck570 FIND v(dout0_140) AT=290.025n

.meas tran vdout0_141ck570 FIND v(dout0_141) AT=290.025n

.meas tran vdout0_142ck570 FIND v(dout0_142) AT=290.025n

.meas tran vdout0_143ck570 FIND v(dout0_143) AT=290.025n

.meas tran vdout0_144ck570 FIND v(dout0_144) AT=290.025n

.meas tran vdout0_145ck570 FIND v(dout0_145) AT=290.025n

.meas tran vdout0_146ck570 FIND v(dout0_146) AT=290.025n

.meas tran vdout0_147ck570 FIND v(dout0_147) AT=290.025n

.meas tran vdout0_148ck570 FIND v(dout0_148) AT=290.025n

.meas tran vdout0_149ck570 FIND v(dout0_149) AT=290.025n

.meas tran vdout0_0ck600 FIND v(dout0_0) AT=305.025n

.meas tran vdout0_1ck600 FIND v(dout0_1) AT=305.025n

.meas tran vdout0_2ck600 FIND v(dout0_2) AT=305.025n

.meas tran vdout0_3ck600 FIND v(dout0_3) AT=305.025n

.meas tran vdout0_4ck600 FIND v(dout0_4) AT=305.025n

.meas tran vdout0_5ck600 FIND v(dout0_5) AT=305.025n

.meas tran vdout0_6ck600 FIND v(dout0_6) AT=305.025n

.meas tran vdout0_7ck600 FIND v(dout0_7) AT=305.025n

.meas tran vdout0_8ck600 FIND v(dout0_8) AT=305.025n

.meas tran vdout0_9ck600 FIND v(dout0_9) AT=305.025n

.meas tran vdout0_10ck600 FIND v(dout0_10) AT=305.025n

.meas tran vdout0_11ck600 FIND v(dout0_11) AT=305.025n

.meas tran vdout0_12ck600 FIND v(dout0_12) AT=305.025n

.meas tran vdout0_13ck600 FIND v(dout0_13) AT=305.025n

.meas tran vdout0_14ck600 FIND v(dout0_14) AT=305.025n

.meas tran vdout0_15ck600 FIND v(dout0_15) AT=305.025n

.meas tran vdout0_16ck600 FIND v(dout0_16) AT=305.025n

.meas tran vdout0_17ck600 FIND v(dout0_17) AT=305.025n

.meas tran vdout0_18ck600 FIND v(dout0_18) AT=305.025n

.meas tran vdout0_19ck600 FIND v(dout0_19) AT=305.025n

.meas tran vdout0_20ck600 FIND v(dout0_20) AT=305.025n

.meas tran vdout0_21ck600 FIND v(dout0_21) AT=305.025n

.meas tran vdout0_22ck600 FIND v(dout0_22) AT=305.025n

.meas tran vdout0_23ck600 FIND v(dout0_23) AT=305.025n

.meas tran vdout0_24ck600 FIND v(dout0_24) AT=305.025n

.meas tran vdout0_25ck600 FIND v(dout0_25) AT=305.025n

.meas tran vdout0_26ck600 FIND v(dout0_26) AT=305.025n

.meas tran vdout0_27ck600 FIND v(dout0_27) AT=305.025n

.meas tran vdout0_28ck600 FIND v(dout0_28) AT=305.025n

.meas tran vdout0_29ck600 FIND v(dout0_29) AT=305.025n

.meas tran vdout0_30ck600 FIND v(dout0_30) AT=305.025n

.meas tran vdout0_31ck600 FIND v(dout0_31) AT=305.025n

.meas tran vdout0_32ck600 FIND v(dout0_32) AT=305.025n

.meas tran vdout0_33ck600 FIND v(dout0_33) AT=305.025n

.meas tran vdout0_34ck600 FIND v(dout0_34) AT=305.025n

.meas tran vdout0_35ck600 FIND v(dout0_35) AT=305.025n

.meas tran vdout0_36ck600 FIND v(dout0_36) AT=305.025n

.meas tran vdout0_37ck600 FIND v(dout0_37) AT=305.025n

.meas tran vdout0_38ck600 FIND v(dout0_38) AT=305.025n

.meas tran vdout0_39ck600 FIND v(dout0_39) AT=305.025n

.meas tran vdout0_40ck600 FIND v(dout0_40) AT=305.025n

.meas tran vdout0_41ck600 FIND v(dout0_41) AT=305.025n

.meas tran vdout0_42ck600 FIND v(dout0_42) AT=305.025n

.meas tran vdout0_43ck600 FIND v(dout0_43) AT=305.025n

.meas tran vdout0_44ck600 FIND v(dout0_44) AT=305.025n

.meas tran vdout0_45ck600 FIND v(dout0_45) AT=305.025n

.meas tran vdout0_46ck600 FIND v(dout0_46) AT=305.025n

.meas tran vdout0_47ck600 FIND v(dout0_47) AT=305.025n

.meas tran vdout0_48ck600 FIND v(dout0_48) AT=305.025n

.meas tran vdout0_49ck600 FIND v(dout0_49) AT=305.025n

.meas tran vdout0_50ck600 FIND v(dout0_50) AT=305.025n

.meas tran vdout0_51ck600 FIND v(dout0_51) AT=305.025n

.meas tran vdout0_52ck600 FIND v(dout0_52) AT=305.025n

.meas tran vdout0_53ck600 FIND v(dout0_53) AT=305.025n

.meas tran vdout0_54ck600 FIND v(dout0_54) AT=305.025n

.meas tran vdout0_55ck600 FIND v(dout0_55) AT=305.025n

.meas tran vdout0_56ck600 FIND v(dout0_56) AT=305.025n

.meas tran vdout0_57ck600 FIND v(dout0_57) AT=305.025n

.meas tran vdout0_58ck600 FIND v(dout0_58) AT=305.025n

.meas tran vdout0_59ck600 FIND v(dout0_59) AT=305.025n

.meas tran vdout0_60ck600 FIND v(dout0_60) AT=305.025n

.meas tran vdout0_61ck600 FIND v(dout0_61) AT=305.025n

.meas tran vdout0_62ck600 FIND v(dout0_62) AT=305.025n

.meas tran vdout0_63ck600 FIND v(dout0_63) AT=305.025n

.meas tran vdout0_64ck600 FIND v(dout0_64) AT=305.025n

.meas tran vdout0_65ck600 FIND v(dout0_65) AT=305.025n

.meas tran vdout0_66ck600 FIND v(dout0_66) AT=305.025n

.meas tran vdout0_67ck600 FIND v(dout0_67) AT=305.025n

.meas tran vdout0_68ck600 FIND v(dout0_68) AT=305.025n

.meas tran vdout0_69ck600 FIND v(dout0_69) AT=305.025n

.meas tran vdout0_70ck600 FIND v(dout0_70) AT=305.025n

.meas tran vdout0_71ck600 FIND v(dout0_71) AT=305.025n

.meas tran vdout0_72ck600 FIND v(dout0_72) AT=305.025n

.meas tran vdout0_73ck600 FIND v(dout0_73) AT=305.025n

.meas tran vdout0_74ck600 FIND v(dout0_74) AT=305.025n

.meas tran vdout0_75ck600 FIND v(dout0_75) AT=305.025n

.meas tran vdout0_76ck600 FIND v(dout0_76) AT=305.025n

.meas tran vdout0_77ck600 FIND v(dout0_77) AT=305.025n

.meas tran vdout0_78ck600 FIND v(dout0_78) AT=305.025n

.meas tran vdout0_79ck600 FIND v(dout0_79) AT=305.025n

.meas tran vdout0_80ck600 FIND v(dout0_80) AT=305.025n

.meas tran vdout0_81ck600 FIND v(dout0_81) AT=305.025n

.meas tran vdout0_82ck600 FIND v(dout0_82) AT=305.025n

.meas tran vdout0_83ck600 FIND v(dout0_83) AT=305.025n

.meas tran vdout0_84ck600 FIND v(dout0_84) AT=305.025n

.meas tran vdout0_85ck600 FIND v(dout0_85) AT=305.025n

.meas tran vdout0_86ck600 FIND v(dout0_86) AT=305.025n

.meas tran vdout0_87ck600 FIND v(dout0_87) AT=305.025n

.meas tran vdout0_88ck600 FIND v(dout0_88) AT=305.025n

.meas tran vdout0_89ck600 FIND v(dout0_89) AT=305.025n

.meas tran vdout0_90ck600 FIND v(dout0_90) AT=305.025n

.meas tran vdout0_91ck600 FIND v(dout0_91) AT=305.025n

.meas tran vdout0_92ck600 FIND v(dout0_92) AT=305.025n

.meas tran vdout0_93ck600 FIND v(dout0_93) AT=305.025n

.meas tran vdout0_94ck600 FIND v(dout0_94) AT=305.025n

.meas tran vdout0_95ck600 FIND v(dout0_95) AT=305.025n

.meas tran vdout0_96ck600 FIND v(dout0_96) AT=305.025n

.meas tran vdout0_97ck600 FIND v(dout0_97) AT=305.025n

.meas tran vdout0_98ck600 FIND v(dout0_98) AT=305.025n

.meas tran vdout0_99ck600 FIND v(dout0_99) AT=305.025n

.meas tran vdout0_100ck600 FIND v(dout0_100) AT=305.025n

.meas tran vdout0_101ck600 FIND v(dout0_101) AT=305.025n

.meas tran vdout0_102ck600 FIND v(dout0_102) AT=305.025n

.meas tran vdout0_103ck600 FIND v(dout0_103) AT=305.025n

.meas tran vdout0_104ck600 FIND v(dout0_104) AT=305.025n

.meas tran vdout0_105ck600 FIND v(dout0_105) AT=305.025n

.meas tran vdout0_106ck600 FIND v(dout0_106) AT=305.025n

.meas tran vdout0_107ck600 FIND v(dout0_107) AT=305.025n

.meas tran vdout0_108ck600 FIND v(dout0_108) AT=305.025n

.meas tran vdout0_109ck600 FIND v(dout0_109) AT=305.025n

.meas tran vdout0_110ck600 FIND v(dout0_110) AT=305.025n

.meas tran vdout0_111ck600 FIND v(dout0_111) AT=305.025n

.meas tran vdout0_112ck600 FIND v(dout0_112) AT=305.025n

.meas tran vdout0_113ck600 FIND v(dout0_113) AT=305.025n

.meas tran vdout0_114ck600 FIND v(dout0_114) AT=305.025n

.meas tran vdout0_115ck600 FIND v(dout0_115) AT=305.025n

.meas tran vdout0_116ck600 FIND v(dout0_116) AT=305.025n

.meas tran vdout0_117ck600 FIND v(dout0_117) AT=305.025n

.meas tran vdout0_118ck600 FIND v(dout0_118) AT=305.025n

.meas tran vdout0_119ck600 FIND v(dout0_119) AT=305.025n

.meas tran vdout0_120ck600 FIND v(dout0_120) AT=305.025n

.meas tran vdout0_121ck600 FIND v(dout0_121) AT=305.025n

.meas tran vdout0_122ck600 FIND v(dout0_122) AT=305.025n

.meas tran vdout0_123ck600 FIND v(dout0_123) AT=305.025n

.meas tran vdout0_124ck600 FIND v(dout0_124) AT=305.025n

.meas tran vdout0_125ck600 FIND v(dout0_125) AT=305.025n

.meas tran vdout0_126ck600 FIND v(dout0_126) AT=305.025n

.meas tran vdout0_127ck600 FIND v(dout0_127) AT=305.025n

.meas tran vdout0_128ck600 FIND v(dout0_128) AT=305.025n

.meas tran vdout0_129ck600 FIND v(dout0_129) AT=305.025n

.meas tran vdout0_130ck600 FIND v(dout0_130) AT=305.025n

.meas tran vdout0_131ck600 FIND v(dout0_131) AT=305.025n

.meas tran vdout0_132ck600 FIND v(dout0_132) AT=305.025n

.meas tran vdout0_133ck600 FIND v(dout0_133) AT=305.025n

.meas tran vdout0_134ck600 FIND v(dout0_134) AT=305.025n

.meas tran vdout0_135ck600 FIND v(dout0_135) AT=305.025n

.meas tran vdout0_136ck600 FIND v(dout0_136) AT=305.025n

.meas tran vdout0_137ck600 FIND v(dout0_137) AT=305.025n

.meas tran vdout0_138ck600 FIND v(dout0_138) AT=305.025n

.meas tran vdout0_139ck600 FIND v(dout0_139) AT=305.025n

.meas tran vdout0_140ck600 FIND v(dout0_140) AT=305.025n

.meas tran vdout0_141ck600 FIND v(dout0_141) AT=305.025n

.meas tran vdout0_142ck600 FIND v(dout0_142) AT=305.025n

.meas tran vdout0_143ck600 FIND v(dout0_143) AT=305.025n

.meas tran vdout0_144ck600 FIND v(dout0_144) AT=305.025n

.meas tran vdout0_145ck600 FIND v(dout0_145) AT=305.025n

.meas tran vdout0_146ck600 FIND v(dout0_146) AT=305.025n

.meas tran vdout0_147ck600 FIND v(dout0_147) AT=305.025n

.meas tran vdout0_148ck600 FIND v(dout0_148) AT=305.025n

.meas tran vdout0_149ck600 FIND v(dout0_149) AT=305.025n

.meas tran vdout0_0ck610 FIND v(dout0_0) AT=310.025n

.meas tran vdout0_1ck610 FIND v(dout0_1) AT=310.025n

.meas tran vdout0_2ck610 FIND v(dout0_2) AT=310.025n

.meas tran vdout0_3ck610 FIND v(dout0_3) AT=310.025n

.meas tran vdout0_4ck610 FIND v(dout0_4) AT=310.025n

.meas tran vdout0_5ck610 FIND v(dout0_5) AT=310.025n

.meas tran vdout0_6ck610 FIND v(dout0_6) AT=310.025n

.meas tran vdout0_7ck610 FIND v(dout0_7) AT=310.025n

.meas tran vdout0_8ck610 FIND v(dout0_8) AT=310.025n

.meas tran vdout0_9ck610 FIND v(dout0_9) AT=310.025n

.meas tran vdout0_10ck610 FIND v(dout0_10) AT=310.025n

.meas tran vdout0_11ck610 FIND v(dout0_11) AT=310.025n

.meas tran vdout0_12ck610 FIND v(dout0_12) AT=310.025n

.meas tran vdout0_13ck610 FIND v(dout0_13) AT=310.025n

.meas tran vdout0_14ck610 FIND v(dout0_14) AT=310.025n

.meas tran vdout0_15ck610 FIND v(dout0_15) AT=310.025n

.meas tran vdout0_16ck610 FIND v(dout0_16) AT=310.025n

.meas tran vdout0_17ck610 FIND v(dout0_17) AT=310.025n

.meas tran vdout0_18ck610 FIND v(dout0_18) AT=310.025n

.meas tran vdout0_19ck610 FIND v(dout0_19) AT=310.025n

.meas tran vdout0_20ck610 FIND v(dout0_20) AT=310.025n

.meas tran vdout0_21ck610 FIND v(dout0_21) AT=310.025n

.meas tran vdout0_22ck610 FIND v(dout0_22) AT=310.025n

.meas tran vdout0_23ck610 FIND v(dout0_23) AT=310.025n

.meas tran vdout0_24ck610 FIND v(dout0_24) AT=310.025n

.meas tran vdout0_25ck610 FIND v(dout0_25) AT=310.025n

.meas tran vdout0_26ck610 FIND v(dout0_26) AT=310.025n

.meas tran vdout0_27ck610 FIND v(dout0_27) AT=310.025n

.meas tran vdout0_28ck610 FIND v(dout0_28) AT=310.025n

.meas tran vdout0_29ck610 FIND v(dout0_29) AT=310.025n

.meas tran vdout0_30ck610 FIND v(dout0_30) AT=310.025n

.meas tran vdout0_31ck610 FIND v(dout0_31) AT=310.025n

.meas tran vdout0_32ck610 FIND v(dout0_32) AT=310.025n

.meas tran vdout0_33ck610 FIND v(dout0_33) AT=310.025n

.meas tran vdout0_34ck610 FIND v(dout0_34) AT=310.025n

.meas tran vdout0_35ck610 FIND v(dout0_35) AT=310.025n

.meas tran vdout0_36ck610 FIND v(dout0_36) AT=310.025n

.meas tran vdout0_37ck610 FIND v(dout0_37) AT=310.025n

.meas tran vdout0_38ck610 FIND v(dout0_38) AT=310.025n

.meas tran vdout0_39ck610 FIND v(dout0_39) AT=310.025n

.meas tran vdout0_40ck610 FIND v(dout0_40) AT=310.025n

.meas tran vdout0_41ck610 FIND v(dout0_41) AT=310.025n

.meas tran vdout0_42ck610 FIND v(dout0_42) AT=310.025n

.meas tran vdout0_43ck610 FIND v(dout0_43) AT=310.025n

.meas tran vdout0_44ck610 FIND v(dout0_44) AT=310.025n

.meas tran vdout0_45ck610 FIND v(dout0_45) AT=310.025n

.meas tran vdout0_46ck610 FIND v(dout0_46) AT=310.025n

.meas tran vdout0_47ck610 FIND v(dout0_47) AT=310.025n

.meas tran vdout0_48ck610 FIND v(dout0_48) AT=310.025n

.meas tran vdout0_49ck610 FIND v(dout0_49) AT=310.025n

.meas tran vdout0_50ck610 FIND v(dout0_50) AT=310.025n

.meas tran vdout0_51ck610 FIND v(dout0_51) AT=310.025n

.meas tran vdout0_52ck610 FIND v(dout0_52) AT=310.025n

.meas tran vdout0_53ck610 FIND v(dout0_53) AT=310.025n

.meas tran vdout0_54ck610 FIND v(dout0_54) AT=310.025n

.meas tran vdout0_55ck610 FIND v(dout0_55) AT=310.025n

.meas tran vdout0_56ck610 FIND v(dout0_56) AT=310.025n

.meas tran vdout0_57ck610 FIND v(dout0_57) AT=310.025n

.meas tran vdout0_58ck610 FIND v(dout0_58) AT=310.025n

.meas tran vdout0_59ck610 FIND v(dout0_59) AT=310.025n

.meas tran vdout0_60ck610 FIND v(dout0_60) AT=310.025n

.meas tran vdout0_61ck610 FIND v(dout0_61) AT=310.025n

.meas tran vdout0_62ck610 FIND v(dout0_62) AT=310.025n

.meas tran vdout0_63ck610 FIND v(dout0_63) AT=310.025n

.meas tran vdout0_64ck610 FIND v(dout0_64) AT=310.025n

.meas tran vdout0_65ck610 FIND v(dout0_65) AT=310.025n

.meas tran vdout0_66ck610 FIND v(dout0_66) AT=310.025n

.meas tran vdout0_67ck610 FIND v(dout0_67) AT=310.025n

.meas tran vdout0_68ck610 FIND v(dout0_68) AT=310.025n

.meas tran vdout0_69ck610 FIND v(dout0_69) AT=310.025n

.meas tran vdout0_70ck610 FIND v(dout0_70) AT=310.025n

.meas tran vdout0_71ck610 FIND v(dout0_71) AT=310.025n

.meas tran vdout0_72ck610 FIND v(dout0_72) AT=310.025n

.meas tran vdout0_73ck610 FIND v(dout0_73) AT=310.025n

.meas tran vdout0_74ck610 FIND v(dout0_74) AT=310.025n

.meas tran vdout0_75ck610 FIND v(dout0_75) AT=310.025n

.meas tran vdout0_76ck610 FIND v(dout0_76) AT=310.025n

.meas tran vdout0_77ck610 FIND v(dout0_77) AT=310.025n

.meas tran vdout0_78ck610 FIND v(dout0_78) AT=310.025n

.meas tran vdout0_79ck610 FIND v(dout0_79) AT=310.025n

.meas tran vdout0_80ck610 FIND v(dout0_80) AT=310.025n

.meas tran vdout0_81ck610 FIND v(dout0_81) AT=310.025n

.meas tran vdout0_82ck610 FIND v(dout0_82) AT=310.025n

.meas tran vdout0_83ck610 FIND v(dout0_83) AT=310.025n

.meas tran vdout0_84ck610 FIND v(dout0_84) AT=310.025n

.meas tran vdout0_85ck610 FIND v(dout0_85) AT=310.025n

.meas tran vdout0_86ck610 FIND v(dout0_86) AT=310.025n

.meas tran vdout0_87ck610 FIND v(dout0_87) AT=310.025n

.meas tran vdout0_88ck610 FIND v(dout0_88) AT=310.025n

.meas tran vdout0_89ck610 FIND v(dout0_89) AT=310.025n

.meas tran vdout0_90ck610 FIND v(dout0_90) AT=310.025n

.meas tran vdout0_91ck610 FIND v(dout0_91) AT=310.025n

.meas tran vdout0_92ck610 FIND v(dout0_92) AT=310.025n

.meas tran vdout0_93ck610 FIND v(dout0_93) AT=310.025n

.meas tran vdout0_94ck610 FIND v(dout0_94) AT=310.025n

.meas tran vdout0_95ck610 FIND v(dout0_95) AT=310.025n

.meas tran vdout0_96ck610 FIND v(dout0_96) AT=310.025n

.meas tran vdout0_97ck610 FIND v(dout0_97) AT=310.025n

.meas tran vdout0_98ck610 FIND v(dout0_98) AT=310.025n

.meas tran vdout0_99ck610 FIND v(dout0_99) AT=310.025n

.meas tran vdout0_100ck610 FIND v(dout0_100) AT=310.025n

.meas tran vdout0_101ck610 FIND v(dout0_101) AT=310.025n

.meas tran vdout0_102ck610 FIND v(dout0_102) AT=310.025n

.meas tran vdout0_103ck610 FIND v(dout0_103) AT=310.025n

.meas tran vdout0_104ck610 FIND v(dout0_104) AT=310.025n

.meas tran vdout0_105ck610 FIND v(dout0_105) AT=310.025n

.meas tran vdout0_106ck610 FIND v(dout0_106) AT=310.025n

.meas tran vdout0_107ck610 FIND v(dout0_107) AT=310.025n

.meas tran vdout0_108ck610 FIND v(dout0_108) AT=310.025n

.meas tran vdout0_109ck610 FIND v(dout0_109) AT=310.025n

.meas tran vdout0_110ck610 FIND v(dout0_110) AT=310.025n

.meas tran vdout0_111ck610 FIND v(dout0_111) AT=310.025n

.meas tran vdout0_112ck610 FIND v(dout0_112) AT=310.025n

.meas tran vdout0_113ck610 FIND v(dout0_113) AT=310.025n

.meas tran vdout0_114ck610 FIND v(dout0_114) AT=310.025n

.meas tran vdout0_115ck610 FIND v(dout0_115) AT=310.025n

.meas tran vdout0_116ck610 FIND v(dout0_116) AT=310.025n

.meas tran vdout0_117ck610 FIND v(dout0_117) AT=310.025n

.meas tran vdout0_118ck610 FIND v(dout0_118) AT=310.025n

.meas tran vdout0_119ck610 FIND v(dout0_119) AT=310.025n

.meas tran vdout0_120ck610 FIND v(dout0_120) AT=310.025n

.meas tran vdout0_121ck610 FIND v(dout0_121) AT=310.025n

.meas tran vdout0_122ck610 FIND v(dout0_122) AT=310.025n

.meas tran vdout0_123ck610 FIND v(dout0_123) AT=310.025n

.meas tran vdout0_124ck610 FIND v(dout0_124) AT=310.025n

.meas tran vdout0_125ck610 FIND v(dout0_125) AT=310.025n

.meas tran vdout0_126ck610 FIND v(dout0_126) AT=310.025n

.meas tran vdout0_127ck610 FIND v(dout0_127) AT=310.025n

.meas tran vdout0_128ck610 FIND v(dout0_128) AT=310.025n

.meas tran vdout0_129ck610 FIND v(dout0_129) AT=310.025n

.meas tran vdout0_130ck610 FIND v(dout0_130) AT=310.025n

.meas tran vdout0_131ck610 FIND v(dout0_131) AT=310.025n

.meas tran vdout0_132ck610 FIND v(dout0_132) AT=310.025n

.meas tran vdout0_133ck610 FIND v(dout0_133) AT=310.025n

.meas tran vdout0_134ck610 FIND v(dout0_134) AT=310.025n

.meas tran vdout0_135ck610 FIND v(dout0_135) AT=310.025n

.meas tran vdout0_136ck610 FIND v(dout0_136) AT=310.025n

.meas tran vdout0_137ck610 FIND v(dout0_137) AT=310.025n

.meas tran vdout0_138ck610 FIND v(dout0_138) AT=310.025n

.meas tran vdout0_139ck610 FIND v(dout0_139) AT=310.025n

.meas tran vdout0_140ck610 FIND v(dout0_140) AT=310.025n

.meas tran vdout0_141ck610 FIND v(dout0_141) AT=310.025n

.meas tran vdout0_142ck610 FIND v(dout0_142) AT=310.025n

.meas tran vdout0_143ck610 FIND v(dout0_143) AT=310.025n

.meas tran vdout0_144ck610 FIND v(dout0_144) AT=310.025n

.meas tran vdout0_145ck610 FIND v(dout0_145) AT=310.025n

.meas tran vdout0_146ck610 FIND v(dout0_146) AT=310.025n

.meas tran vdout0_147ck610 FIND v(dout0_147) AT=310.025n

.meas tran vdout0_148ck610 FIND v(dout0_148) AT=310.025n

.meas tran vdout0_149ck610 FIND v(dout0_149) AT=310.025n

.meas tran vdout0_0ck640 FIND v(dout0_0) AT=325.025n

.meas tran vdout0_1ck640 FIND v(dout0_1) AT=325.025n

.meas tran vdout0_2ck640 FIND v(dout0_2) AT=325.025n

.meas tran vdout0_3ck640 FIND v(dout0_3) AT=325.025n

.meas tran vdout0_4ck640 FIND v(dout0_4) AT=325.025n

.meas tran vdout0_5ck640 FIND v(dout0_5) AT=325.025n

.meas tran vdout0_6ck640 FIND v(dout0_6) AT=325.025n

.meas tran vdout0_7ck640 FIND v(dout0_7) AT=325.025n

.meas tran vdout0_8ck640 FIND v(dout0_8) AT=325.025n

.meas tran vdout0_9ck640 FIND v(dout0_9) AT=325.025n

.meas tran vdout0_10ck640 FIND v(dout0_10) AT=325.025n

.meas tran vdout0_11ck640 FIND v(dout0_11) AT=325.025n

.meas tran vdout0_12ck640 FIND v(dout0_12) AT=325.025n

.meas tran vdout0_13ck640 FIND v(dout0_13) AT=325.025n

.meas tran vdout0_14ck640 FIND v(dout0_14) AT=325.025n

.meas tran vdout0_15ck640 FIND v(dout0_15) AT=325.025n

.meas tran vdout0_16ck640 FIND v(dout0_16) AT=325.025n

.meas tran vdout0_17ck640 FIND v(dout0_17) AT=325.025n

.meas tran vdout0_18ck640 FIND v(dout0_18) AT=325.025n

.meas tran vdout0_19ck640 FIND v(dout0_19) AT=325.025n

.meas tran vdout0_20ck640 FIND v(dout0_20) AT=325.025n

.meas tran vdout0_21ck640 FIND v(dout0_21) AT=325.025n

.meas tran vdout0_22ck640 FIND v(dout0_22) AT=325.025n

.meas tran vdout0_23ck640 FIND v(dout0_23) AT=325.025n

.meas tran vdout0_24ck640 FIND v(dout0_24) AT=325.025n

.meas tran vdout0_25ck640 FIND v(dout0_25) AT=325.025n

.meas tran vdout0_26ck640 FIND v(dout0_26) AT=325.025n

.meas tran vdout0_27ck640 FIND v(dout0_27) AT=325.025n

.meas tran vdout0_28ck640 FIND v(dout0_28) AT=325.025n

.meas tran vdout0_29ck640 FIND v(dout0_29) AT=325.025n

.meas tran vdout0_30ck640 FIND v(dout0_30) AT=325.025n

.meas tran vdout0_31ck640 FIND v(dout0_31) AT=325.025n

.meas tran vdout0_32ck640 FIND v(dout0_32) AT=325.025n

.meas tran vdout0_33ck640 FIND v(dout0_33) AT=325.025n

.meas tran vdout0_34ck640 FIND v(dout0_34) AT=325.025n

.meas tran vdout0_35ck640 FIND v(dout0_35) AT=325.025n

.meas tran vdout0_36ck640 FIND v(dout0_36) AT=325.025n

.meas tran vdout0_37ck640 FIND v(dout0_37) AT=325.025n

.meas tran vdout0_38ck640 FIND v(dout0_38) AT=325.025n

.meas tran vdout0_39ck640 FIND v(dout0_39) AT=325.025n

.meas tran vdout0_40ck640 FIND v(dout0_40) AT=325.025n

.meas tran vdout0_41ck640 FIND v(dout0_41) AT=325.025n

.meas tran vdout0_42ck640 FIND v(dout0_42) AT=325.025n

.meas tran vdout0_43ck640 FIND v(dout0_43) AT=325.025n

.meas tran vdout0_44ck640 FIND v(dout0_44) AT=325.025n

.meas tran vdout0_45ck640 FIND v(dout0_45) AT=325.025n

.meas tran vdout0_46ck640 FIND v(dout0_46) AT=325.025n

.meas tran vdout0_47ck640 FIND v(dout0_47) AT=325.025n

.meas tran vdout0_48ck640 FIND v(dout0_48) AT=325.025n

.meas tran vdout0_49ck640 FIND v(dout0_49) AT=325.025n

.meas tran vdout0_50ck640 FIND v(dout0_50) AT=325.025n

.meas tran vdout0_51ck640 FIND v(dout0_51) AT=325.025n

.meas tran vdout0_52ck640 FIND v(dout0_52) AT=325.025n

.meas tran vdout0_53ck640 FIND v(dout0_53) AT=325.025n

.meas tran vdout0_54ck640 FIND v(dout0_54) AT=325.025n

.meas tran vdout0_55ck640 FIND v(dout0_55) AT=325.025n

.meas tran vdout0_56ck640 FIND v(dout0_56) AT=325.025n

.meas tran vdout0_57ck640 FIND v(dout0_57) AT=325.025n

.meas tran vdout0_58ck640 FIND v(dout0_58) AT=325.025n

.meas tran vdout0_59ck640 FIND v(dout0_59) AT=325.025n

.meas tran vdout0_60ck640 FIND v(dout0_60) AT=325.025n

.meas tran vdout0_61ck640 FIND v(dout0_61) AT=325.025n

.meas tran vdout0_62ck640 FIND v(dout0_62) AT=325.025n

.meas tran vdout0_63ck640 FIND v(dout0_63) AT=325.025n

.meas tran vdout0_64ck640 FIND v(dout0_64) AT=325.025n

.meas tran vdout0_65ck640 FIND v(dout0_65) AT=325.025n

.meas tran vdout0_66ck640 FIND v(dout0_66) AT=325.025n

.meas tran vdout0_67ck640 FIND v(dout0_67) AT=325.025n

.meas tran vdout0_68ck640 FIND v(dout0_68) AT=325.025n

.meas tran vdout0_69ck640 FIND v(dout0_69) AT=325.025n

.meas tran vdout0_70ck640 FIND v(dout0_70) AT=325.025n

.meas tran vdout0_71ck640 FIND v(dout0_71) AT=325.025n

.meas tran vdout0_72ck640 FIND v(dout0_72) AT=325.025n

.meas tran vdout0_73ck640 FIND v(dout0_73) AT=325.025n

.meas tran vdout0_74ck640 FIND v(dout0_74) AT=325.025n

.meas tran vdout0_75ck640 FIND v(dout0_75) AT=325.025n

.meas tran vdout0_76ck640 FIND v(dout0_76) AT=325.025n

.meas tran vdout0_77ck640 FIND v(dout0_77) AT=325.025n

.meas tran vdout0_78ck640 FIND v(dout0_78) AT=325.025n

.meas tran vdout0_79ck640 FIND v(dout0_79) AT=325.025n

.meas tran vdout0_80ck640 FIND v(dout0_80) AT=325.025n

.meas tran vdout0_81ck640 FIND v(dout0_81) AT=325.025n

.meas tran vdout0_82ck640 FIND v(dout0_82) AT=325.025n

.meas tran vdout0_83ck640 FIND v(dout0_83) AT=325.025n

.meas tran vdout0_84ck640 FIND v(dout0_84) AT=325.025n

.meas tran vdout0_85ck640 FIND v(dout0_85) AT=325.025n

.meas tran vdout0_86ck640 FIND v(dout0_86) AT=325.025n

.meas tran vdout0_87ck640 FIND v(dout0_87) AT=325.025n

.meas tran vdout0_88ck640 FIND v(dout0_88) AT=325.025n

.meas tran vdout0_89ck640 FIND v(dout0_89) AT=325.025n

.meas tran vdout0_90ck640 FIND v(dout0_90) AT=325.025n

.meas tran vdout0_91ck640 FIND v(dout0_91) AT=325.025n

.meas tran vdout0_92ck640 FIND v(dout0_92) AT=325.025n

.meas tran vdout0_93ck640 FIND v(dout0_93) AT=325.025n

.meas tran vdout0_94ck640 FIND v(dout0_94) AT=325.025n

.meas tran vdout0_95ck640 FIND v(dout0_95) AT=325.025n

.meas tran vdout0_96ck640 FIND v(dout0_96) AT=325.025n

.meas tran vdout0_97ck640 FIND v(dout0_97) AT=325.025n

.meas tran vdout0_98ck640 FIND v(dout0_98) AT=325.025n

.meas tran vdout0_99ck640 FIND v(dout0_99) AT=325.025n

.meas tran vdout0_100ck640 FIND v(dout0_100) AT=325.025n

.meas tran vdout0_101ck640 FIND v(dout0_101) AT=325.025n

.meas tran vdout0_102ck640 FIND v(dout0_102) AT=325.025n

.meas tran vdout0_103ck640 FIND v(dout0_103) AT=325.025n

.meas tran vdout0_104ck640 FIND v(dout0_104) AT=325.025n

.meas tran vdout0_105ck640 FIND v(dout0_105) AT=325.025n

.meas tran vdout0_106ck640 FIND v(dout0_106) AT=325.025n

.meas tran vdout0_107ck640 FIND v(dout0_107) AT=325.025n

.meas tran vdout0_108ck640 FIND v(dout0_108) AT=325.025n

.meas tran vdout0_109ck640 FIND v(dout0_109) AT=325.025n

.meas tran vdout0_110ck640 FIND v(dout0_110) AT=325.025n

.meas tran vdout0_111ck640 FIND v(dout0_111) AT=325.025n

.meas tran vdout0_112ck640 FIND v(dout0_112) AT=325.025n

.meas tran vdout0_113ck640 FIND v(dout0_113) AT=325.025n

.meas tran vdout0_114ck640 FIND v(dout0_114) AT=325.025n

.meas tran vdout0_115ck640 FIND v(dout0_115) AT=325.025n

.meas tran vdout0_116ck640 FIND v(dout0_116) AT=325.025n

.meas tran vdout0_117ck640 FIND v(dout0_117) AT=325.025n

.meas tran vdout0_118ck640 FIND v(dout0_118) AT=325.025n

.meas tran vdout0_119ck640 FIND v(dout0_119) AT=325.025n

.meas tran vdout0_120ck640 FIND v(dout0_120) AT=325.025n

.meas tran vdout0_121ck640 FIND v(dout0_121) AT=325.025n

.meas tran vdout0_122ck640 FIND v(dout0_122) AT=325.025n

.meas tran vdout0_123ck640 FIND v(dout0_123) AT=325.025n

.meas tran vdout0_124ck640 FIND v(dout0_124) AT=325.025n

.meas tran vdout0_125ck640 FIND v(dout0_125) AT=325.025n

.meas tran vdout0_126ck640 FIND v(dout0_126) AT=325.025n

.meas tran vdout0_127ck640 FIND v(dout0_127) AT=325.025n

.meas tran vdout0_128ck640 FIND v(dout0_128) AT=325.025n

.meas tran vdout0_129ck640 FIND v(dout0_129) AT=325.025n

.meas tran vdout0_130ck640 FIND v(dout0_130) AT=325.025n

.meas tran vdout0_131ck640 FIND v(dout0_131) AT=325.025n

.meas tran vdout0_132ck640 FIND v(dout0_132) AT=325.025n

.meas tran vdout0_133ck640 FIND v(dout0_133) AT=325.025n

.meas tran vdout0_134ck640 FIND v(dout0_134) AT=325.025n

.meas tran vdout0_135ck640 FIND v(dout0_135) AT=325.025n

.meas tran vdout0_136ck640 FIND v(dout0_136) AT=325.025n

.meas tran vdout0_137ck640 FIND v(dout0_137) AT=325.025n

.meas tran vdout0_138ck640 FIND v(dout0_138) AT=325.025n

.meas tran vdout0_139ck640 FIND v(dout0_139) AT=325.025n

.meas tran vdout0_140ck640 FIND v(dout0_140) AT=325.025n

.meas tran vdout0_141ck640 FIND v(dout0_141) AT=325.025n

.meas tran vdout0_142ck640 FIND v(dout0_142) AT=325.025n

.meas tran vdout0_143ck640 FIND v(dout0_143) AT=325.025n

.meas tran vdout0_144ck640 FIND v(dout0_144) AT=325.025n

.meas tran vdout0_145ck640 FIND v(dout0_145) AT=325.025n

.meas tran vdout0_146ck640 FIND v(dout0_146) AT=325.025n

.meas tran vdout0_147ck640 FIND v(dout0_147) AT=325.025n

.meas tran vdout0_148ck640 FIND v(dout0_148) AT=325.025n

.meas tran vdout0_149ck640 FIND v(dout0_149) AT=325.025n

.meas tran vdout0_0ck650 FIND v(dout0_0) AT=330.025n

.meas tran vdout0_1ck650 FIND v(dout0_1) AT=330.025n

.meas tran vdout0_2ck650 FIND v(dout0_2) AT=330.025n

.meas tran vdout0_3ck650 FIND v(dout0_3) AT=330.025n

.meas tran vdout0_4ck650 FIND v(dout0_4) AT=330.025n

.meas tran vdout0_5ck650 FIND v(dout0_5) AT=330.025n

.meas tran vdout0_6ck650 FIND v(dout0_6) AT=330.025n

.meas tran vdout0_7ck650 FIND v(dout0_7) AT=330.025n

.meas tran vdout0_8ck650 FIND v(dout0_8) AT=330.025n

.meas tran vdout0_9ck650 FIND v(dout0_9) AT=330.025n

.meas tran vdout0_10ck650 FIND v(dout0_10) AT=330.025n

.meas tran vdout0_11ck650 FIND v(dout0_11) AT=330.025n

.meas tran vdout0_12ck650 FIND v(dout0_12) AT=330.025n

.meas tran vdout0_13ck650 FIND v(dout0_13) AT=330.025n

.meas tran vdout0_14ck650 FIND v(dout0_14) AT=330.025n

.meas tran vdout0_15ck650 FIND v(dout0_15) AT=330.025n

.meas tran vdout0_16ck650 FIND v(dout0_16) AT=330.025n

.meas tran vdout0_17ck650 FIND v(dout0_17) AT=330.025n

.meas tran vdout0_18ck650 FIND v(dout0_18) AT=330.025n

.meas tran vdout0_19ck650 FIND v(dout0_19) AT=330.025n

.meas tran vdout0_20ck650 FIND v(dout0_20) AT=330.025n

.meas tran vdout0_21ck650 FIND v(dout0_21) AT=330.025n

.meas tran vdout0_22ck650 FIND v(dout0_22) AT=330.025n

.meas tran vdout0_23ck650 FIND v(dout0_23) AT=330.025n

.meas tran vdout0_24ck650 FIND v(dout0_24) AT=330.025n

.meas tran vdout0_25ck650 FIND v(dout0_25) AT=330.025n

.meas tran vdout0_26ck650 FIND v(dout0_26) AT=330.025n

.meas tran vdout0_27ck650 FIND v(dout0_27) AT=330.025n

.meas tran vdout0_28ck650 FIND v(dout0_28) AT=330.025n

.meas tran vdout0_29ck650 FIND v(dout0_29) AT=330.025n

.meas tran vdout0_30ck650 FIND v(dout0_30) AT=330.025n

.meas tran vdout0_31ck650 FIND v(dout0_31) AT=330.025n

.meas tran vdout0_32ck650 FIND v(dout0_32) AT=330.025n

.meas tran vdout0_33ck650 FIND v(dout0_33) AT=330.025n

.meas tran vdout0_34ck650 FIND v(dout0_34) AT=330.025n

.meas tran vdout0_35ck650 FIND v(dout0_35) AT=330.025n

.meas tran vdout0_36ck650 FIND v(dout0_36) AT=330.025n

.meas tran vdout0_37ck650 FIND v(dout0_37) AT=330.025n

.meas tran vdout0_38ck650 FIND v(dout0_38) AT=330.025n

.meas tran vdout0_39ck650 FIND v(dout0_39) AT=330.025n

.meas tran vdout0_40ck650 FIND v(dout0_40) AT=330.025n

.meas tran vdout0_41ck650 FIND v(dout0_41) AT=330.025n

.meas tran vdout0_42ck650 FIND v(dout0_42) AT=330.025n

.meas tran vdout0_43ck650 FIND v(dout0_43) AT=330.025n

.meas tran vdout0_44ck650 FIND v(dout0_44) AT=330.025n

.meas tran vdout0_45ck650 FIND v(dout0_45) AT=330.025n

.meas tran vdout0_46ck650 FIND v(dout0_46) AT=330.025n

.meas tran vdout0_47ck650 FIND v(dout0_47) AT=330.025n

.meas tran vdout0_48ck650 FIND v(dout0_48) AT=330.025n

.meas tran vdout0_49ck650 FIND v(dout0_49) AT=330.025n

.meas tran vdout0_50ck650 FIND v(dout0_50) AT=330.025n

.meas tran vdout0_51ck650 FIND v(dout0_51) AT=330.025n

.meas tran vdout0_52ck650 FIND v(dout0_52) AT=330.025n

.meas tran vdout0_53ck650 FIND v(dout0_53) AT=330.025n

.meas tran vdout0_54ck650 FIND v(dout0_54) AT=330.025n

.meas tran vdout0_55ck650 FIND v(dout0_55) AT=330.025n

.meas tran vdout0_56ck650 FIND v(dout0_56) AT=330.025n

.meas tran vdout0_57ck650 FIND v(dout0_57) AT=330.025n

.meas tran vdout0_58ck650 FIND v(dout0_58) AT=330.025n

.meas tran vdout0_59ck650 FIND v(dout0_59) AT=330.025n

.meas tran vdout0_60ck650 FIND v(dout0_60) AT=330.025n

.meas tran vdout0_61ck650 FIND v(dout0_61) AT=330.025n

.meas tran vdout0_62ck650 FIND v(dout0_62) AT=330.025n

.meas tran vdout0_63ck650 FIND v(dout0_63) AT=330.025n

.meas tran vdout0_64ck650 FIND v(dout0_64) AT=330.025n

.meas tran vdout0_65ck650 FIND v(dout0_65) AT=330.025n

.meas tran vdout0_66ck650 FIND v(dout0_66) AT=330.025n

.meas tran vdout0_67ck650 FIND v(dout0_67) AT=330.025n

.meas tran vdout0_68ck650 FIND v(dout0_68) AT=330.025n

.meas tran vdout0_69ck650 FIND v(dout0_69) AT=330.025n

.meas tran vdout0_70ck650 FIND v(dout0_70) AT=330.025n

.meas tran vdout0_71ck650 FIND v(dout0_71) AT=330.025n

.meas tran vdout0_72ck650 FIND v(dout0_72) AT=330.025n

.meas tran vdout0_73ck650 FIND v(dout0_73) AT=330.025n

.meas tran vdout0_74ck650 FIND v(dout0_74) AT=330.025n

.meas tran vdout0_75ck650 FIND v(dout0_75) AT=330.025n

.meas tran vdout0_76ck650 FIND v(dout0_76) AT=330.025n

.meas tran vdout0_77ck650 FIND v(dout0_77) AT=330.025n

.meas tran vdout0_78ck650 FIND v(dout0_78) AT=330.025n

.meas tran vdout0_79ck650 FIND v(dout0_79) AT=330.025n

.meas tran vdout0_80ck650 FIND v(dout0_80) AT=330.025n

.meas tran vdout0_81ck650 FIND v(dout0_81) AT=330.025n

.meas tran vdout0_82ck650 FIND v(dout0_82) AT=330.025n

.meas tran vdout0_83ck650 FIND v(dout0_83) AT=330.025n

.meas tran vdout0_84ck650 FIND v(dout0_84) AT=330.025n

.meas tran vdout0_85ck650 FIND v(dout0_85) AT=330.025n

.meas tran vdout0_86ck650 FIND v(dout0_86) AT=330.025n

.meas tran vdout0_87ck650 FIND v(dout0_87) AT=330.025n

.meas tran vdout0_88ck650 FIND v(dout0_88) AT=330.025n

.meas tran vdout0_89ck650 FIND v(dout0_89) AT=330.025n

.meas tran vdout0_90ck650 FIND v(dout0_90) AT=330.025n

.meas tran vdout0_91ck650 FIND v(dout0_91) AT=330.025n

.meas tran vdout0_92ck650 FIND v(dout0_92) AT=330.025n

.meas tran vdout0_93ck650 FIND v(dout0_93) AT=330.025n

.meas tran vdout0_94ck650 FIND v(dout0_94) AT=330.025n

.meas tran vdout0_95ck650 FIND v(dout0_95) AT=330.025n

.meas tran vdout0_96ck650 FIND v(dout0_96) AT=330.025n

.meas tran vdout0_97ck650 FIND v(dout0_97) AT=330.025n

.meas tran vdout0_98ck650 FIND v(dout0_98) AT=330.025n

.meas tran vdout0_99ck650 FIND v(dout0_99) AT=330.025n

.meas tran vdout0_100ck650 FIND v(dout0_100) AT=330.025n

.meas tran vdout0_101ck650 FIND v(dout0_101) AT=330.025n

.meas tran vdout0_102ck650 FIND v(dout0_102) AT=330.025n

.meas tran vdout0_103ck650 FIND v(dout0_103) AT=330.025n

.meas tran vdout0_104ck650 FIND v(dout0_104) AT=330.025n

.meas tran vdout0_105ck650 FIND v(dout0_105) AT=330.025n

.meas tran vdout0_106ck650 FIND v(dout0_106) AT=330.025n

.meas tran vdout0_107ck650 FIND v(dout0_107) AT=330.025n

.meas tran vdout0_108ck650 FIND v(dout0_108) AT=330.025n

.meas tran vdout0_109ck650 FIND v(dout0_109) AT=330.025n

.meas tran vdout0_110ck650 FIND v(dout0_110) AT=330.025n

.meas tran vdout0_111ck650 FIND v(dout0_111) AT=330.025n

.meas tran vdout0_112ck650 FIND v(dout0_112) AT=330.025n

.meas tran vdout0_113ck650 FIND v(dout0_113) AT=330.025n

.meas tran vdout0_114ck650 FIND v(dout0_114) AT=330.025n

.meas tran vdout0_115ck650 FIND v(dout0_115) AT=330.025n

.meas tran vdout0_116ck650 FIND v(dout0_116) AT=330.025n

.meas tran vdout0_117ck650 FIND v(dout0_117) AT=330.025n

.meas tran vdout0_118ck650 FIND v(dout0_118) AT=330.025n

.meas tran vdout0_119ck650 FIND v(dout0_119) AT=330.025n

.meas tran vdout0_120ck650 FIND v(dout0_120) AT=330.025n

.meas tran vdout0_121ck650 FIND v(dout0_121) AT=330.025n

.meas tran vdout0_122ck650 FIND v(dout0_122) AT=330.025n

.meas tran vdout0_123ck650 FIND v(dout0_123) AT=330.025n

.meas tran vdout0_124ck650 FIND v(dout0_124) AT=330.025n

.meas tran vdout0_125ck650 FIND v(dout0_125) AT=330.025n

.meas tran vdout0_126ck650 FIND v(dout0_126) AT=330.025n

.meas tran vdout0_127ck650 FIND v(dout0_127) AT=330.025n

.meas tran vdout0_128ck650 FIND v(dout0_128) AT=330.025n

.meas tran vdout0_129ck650 FIND v(dout0_129) AT=330.025n

.meas tran vdout0_130ck650 FIND v(dout0_130) AT=330.025n

.meas tran vdout0_131ck650 FIND v(dout0_131) AT=330.025n

.meas tran vdout0_132ck650 FIND v(dout0_132) AT=330.025n

.meas tran vdout0_133ck650 FIND v(dout0_133) AT=330.025n

.meas tran vdout0_134ck650 FIND v(dout0_134) AT=330.025n

.meas tran vdout0_135ck650 FIND v(dout0_135) AT=330.025n

.meas tran vdout0_136ck650 FIND v(dout0_136) AT=330.025n

.meas tran vdout0_137ck650 FIND v(dout0_137) AT=330.025n

.meas tran vdout0_138ck650 FIND v(dout0_138) AT=330.025n

.meas tran vdout0_139ck650 FIND v(dout0_139) AT=330.025n

.meas tran vdout0_140ck650 FIND v(dout0_140) AT=330.025n

.meas tran vdout0_141ck650 FIND v(dout0_141) AT=330.025n

.meas tran vdout0_142ck650 FIND v(dout0_142) AT=330.025n

.meas tran vdout0_143ck650 FIND v(dout0_143) AT=330.025n

.meas tran vdout0_144ck650 FIND v(dout0_144) AT=330.025n

.meas tran vdout0_145ck650 FIND v(dout0_145) AT=330.025n

.meas tran vdout0_146ck650 FIND v(dout0_146) AT=330.025n

.meas tran vdout0_147ck650 FIND v(dout0_147) AT=330.025n

.meas tran vdout0_148ck650 FIND v(dout0_148) AT=330.025n

.meas tran vdout0_149ck650 FIND v(dout0_149) AT=330.025n

.meas tran vdout0_0ck670 FIND v(dout0_0) AT=340.025n

.meas tran vdout0_1ck670 FIND v(dout0_1) AT=340.025n

.meas tran vdout0_2ck670 FIND v(dout0_2) AT=340.025n

.meas tran vdout0_3ck670 FIND v(dout0_3) AT=340.025n

.meas tran vdout0_4ck670 FIND v(dout0_4) AT=340.025n

.meas tran vdout0_5ck670 FIND v(dout0_5) AT=340.025n

.meas tran vdout0_6ck670 FIND v(dout0_6) AT=340.025n

.meas tran vdout0_7ck670 FIND v(dout0_7) AT=340.025n

.meas tran vdout0_8ck670 FIND v(dout0_8) AT=340.025n

.meas tran vdout0_9ck670 FIND v(dout0_9) AT=340.025n

.meas tran vdout0_10ck670 FIND v(dout0_10) AT=340.025n

.meas tran vdout0_11ck670 FIND v(dout0_11) AT=340.025n

.meas tran vdout0_12ck670 FIND v(dout0_12) AT=340.025n

.meas tran vdout0_13ck670 FIND v(dout0_13) AT=340.025n

.meas tran vdout0_14ck670 FIND v(dout0_14) AT=340.025n

.meas tran vdout0_15ck670 FIND v(dout0_15) AT=340.025n

.meas tran vdout0_16ck670 FIND v(dout0_16) AT=340.025n

.meas tran vdout0_17ck670 FIND v(dout0_17) AT=340.025n

.meas tran vdout0_18ck670 FIND v(dout0_18) AT=340.025n

.meas tran vdout0_19ck670 FIND v(dout0_19) AT=340.025n

.meas tran vdout0_20ck670 FIND v(dout0_20) AT=340.025n

.meas tran vdout0_21ck670 FIND v(dout0_21) AT=340.025n

.meas tran vdout0_22ck670 FIND v(dout0_22) AT=340.025n

.meas tran vdout0_23ck670 FIND v(dout0_23) AT=340.025n

.meas tran vdout0_24ck670 FIND v(dout0_24) AT=340.025n

.meas tran vdout0_25ck670 FIND v(dout0_25) AT=340.025n

.meas tran vdout0_26ck670 FIND v(dout0_26) AT=340.025n

.meas tran vdout0_27ck670 FIND v(dout0_27) AT=340.025n

.meas tran vdout0_28ck670 FIND v(dout0_28) AT=340.025n

.meas tran vdout0_29ck670 FIND v(dout0_29) AT=340.025n

.meas tran vdout0_30ck670 FIND v(dout0_30) AT=340.025n

.meas tran vdout0_31ck670 FIND v(dout0_31) AT=340.025n

.meas tran vdout0_32ck670 FIND v(dout0_32) AT=340.025n

.meas tran vdout0_33ck670 FIND v(dout0_33) AT=340.025n

.meas tran vdout0_34ck670 FIND v(dout0_34) AT=340.025n

.meas tran vdout0_35ck670 FIND v(dout0_35) AT=340.025n

.meas tran vdout0_36ck670 FIND v(dout0_36) AT=340.025n

.meas tran vdout0_37ck670 FIND v(dout0_37) AT=340.025n

.meas tran vdout0_38ck670 FIND v(dout0_38) AT=340.025n

.meas tran vdout0_39ck670 FIND v(dout0_39) AT=340.025n

.meas tran vdout0_40ck670 FIND v(dout0_40) AT=340.025n

.meas tran vdout0_41ck670 FIND v(dout0_41) AT=340.025n

.meas tran vdout0_42ck670 FIND v(dout0_42) AT=340.025n

.meas tran vdout0_43ck670 FIND v(dout0_43) AT=340.025n

.meas tran vdout0_44ck670 FIND v(dout0_44) AT=340.025n

.meas tran vdout0_45ck670 FIND v(dout0_45) AT=340.025n

.meas tran vdout0_46ck670 FIND v(dout0_46) AT=340.025n

.meas tran vdout0_47ck670 FIND v(dout0_47) AT=340.025n

.meas tran vdout0_48ck670 FIND v(dout0_48) AT=340.025n

.meas tran vdout0_49ck670 FIND v(dout0_49) AT=340.025n

.meas tran vdout0_50ck670 FIND v(dout0_50) AT=340.025n

.meas tran vdout0_51ck670 FIND v(dout0_51) AT=340.025n

.meas tran vdout0_52ck670 FIND v(dout0_52) AT=340.025n

.meas tran vdout0_53ck670 FIND v(dout0_53) AT=340.025n

.meas tran vdout0_54ck670 FIND v(dout0_54) AT=340.025n

.meas tran vdout0_55ck670 FIND v(dout0_55) AT=340.025n

.meas tran vdout0_56ck670 FIND v(dout0_56) AT=340.025n

.meas tran vdout0_57ck670 FIND v(dout0_57) AT=340.025n

.meas tran vdout0_58ck670 FIND v(dout0_58) AT=340.025n

.meas tran vdout0_59ck670 FIND v(dout0_59) AT=340.025n

.meas tran vdout0_60ck670 FIND v(dout0_60) AT=340.025n

.meas tran vdout0_61ck670 FIND v(dout0_61) AT=340.025n

.meas tran vdout0_62ck670 FIND v(dout0_62) AT=340.025n

.meas tran vdout0_63ck670 FIND v(dout0_63) AT=340.025n

.meas tran vdout0_64ck670 FIND v(dout0_64) AT=340.025n

.meas tran vdout0_65ck670 FIND v(dout0_65) AT=340.025n

.meas tran vdout0_66ck670 FIND v(dout0_66) AT=340.025n

.meas tran vdout0_67ck670 FIND v(dout0_67) AT=340.025n

.meas tran vdout0_68ck670 FIND v(dout0_68) AT=340.025n

.meas tran vdout0_69ck670 FIND v(dout0_69) AT=340.025n

.meas tran vdout0_70ck670 FIND v(dout0_70) AT=340.025n

.meas tran vdout0_71ck670 FIND v(dout0_71) AT=340.025n

.meas tran vdout0_72ck670 FIND v(dout0_72) AT=340.025n

.meas tran vdout0_73ck670 FIND v(dout0_73) AT=340.025n

.meas tran vdout0_74ck670 FIND v(dout0_74) AT=340.025n

.meas tran vdout0_75ck670 FIND v(dout0_75) AT=340.025n

.meas tran vdout0_76ck670 FIND v(dout0_76) AT=340.025n

.meas tran vdout0_77ck670 FIND v(dout0_77) AT=340.025n

.meas tran vdout0_78ck670 FIND v(dout0_78) AT=340.025n

.meas tran vdout0_79ck670 FIND v(dout0_79) AT=340.025n

.meas tran vdout0_80ck670 FIND v(dout0_80) AT=340.025n

.meas tran vdout0_81ck670 FIND v(dout0_81) AT=340.025n

.meas tran vdout0_82ck670 FIND v(dout0_82) AT=340.025n

.meas tran vdout0_83ck670 FIND v(dout0_83) AT=340.025n

.meas tran vdout0_84ck670 FIND v(dout0_84) AT=340.025n

.meas tran vdout0_85ck670 FIND v(dout0_85) AT=340.025n

.meas tran vdout0_86ck670 FIND v(dout0_86) AT=340.025n

.meas tran vdout0_87ck670 FIND v(dout0_87) AT=340.025n

.meas tran vdout0_88ck670 FIND v(dout0_88) AT=340.025n

.meas tran vdout0_89ck670 FIND v(dout0_89) AT=340.025n

.meas tran vdout0_90ck670 FIND v(dout0_90) AT=340.025n

.meas tran vdout0_91ck670 FIND v(dout0_91) AT=340.025n

.meas tran vdout0_92ck670 FIND v(dout0_92) AT=340.025n

.meas tran vdout0_93ck670 FIND v(dout0_93) AT=340.025n

.meas tran vdout0_94ck670 FIND v(dout0_94) AT=340.025n

.meas tran vdout0_95ck670 FIND v(dout0_95) AT=340.025n

.meas tran vdout0_96ck670 FIND v(dout0_96) AT=340.025n

.meas tran vdout0_97ck670 FIND v(dout0_97) AT=340.025n

.meas tran vdout0_98ck670 FIND v(dout0_98) AT=340.025n

.meas tran vdout0_99ck670 FIND v(dout0_99) AT=340.025n

.meas tran vdout0_100ck670 FIND v(dout0_100) AT=340.025n

.meas tran vdout0_101ck670 FIND v(dout0_101) AT=340.025n

.meas tran vdout0_102ck670 FIND v(dout0_102) AT=340.025n

.meas tran vdout0_103ck670 FIND v(dout0_103) AT=340.025n

.meas tran vdout0_104ck670 FIND v(dout0_104) AT=340.025n

.meas tran vdout0_105ck670 FIND v(dout0_105) AT=340.025n

.meas tran vdout0_106ck670 FIND v(dout0_106) AT=340.025n

.meas tran vdout0_107ck670 FIND v(dout0_107) AT=340.025n

.meas tran vdout0_108ck670 FIND v(dout0_108) AT=340.025n

.meas tran vdout0_109ck670 FIND v(dout0_109) AT=340.025n

.meas tran vdout0_110ck670 FIND v(dout0_110) AT=340.025n

.meas tran vdout0_111ck670 FIND v(dout0_111) AT=340.025n

.meas tran vdout0_112ck670 FIND v(dout0_112) AT=340.025n

.meas tran vdout0_113ck670 FIND v(dout0_113) AT=340.025n

.meas tran vdout0_114ck670 FIND v(dout0_114) AT=340.025n

.meas tran vdout0_115ck670 FIND v(dout0_115) AT=340.025n

.meas tran vdout0_116ck670 FIND v(dout0_116) AT=340.025n

.meas tran vdout0_117ck670 FIND v(dout0_117) AT=340.025n

.meas tran vdout0_118ck670 FIND v(dout0_118) AT=340.025n

.meas tran vdout0_119ck670 FIND v(dout0_119) AT=340.025n

.meas tran vdout0_120ck670 FIND v(dout0_120) AT=340.025n

.meas tran vdout0_121ck670 FIND v(dout0_121) AT=340.025n

.meas tran vdout0_122ck670 FIND v(dout0_122) AT=340.025n

.meas tran vdout0_123ck670 FIND v(dout0_123) AT=340.025n

.meas tran vdout0_124ck670 FIND v(dout0_124) AT=340.025n

.meas tran vdout0_125ck670 FIND v(dout0_125) AT=340.025n

.meas tran vdout0_126ck670 FIND v(dout0_126) AT=340.025n

.meas tran vdout0_127ck670 FIND v(dout0_127) AT=340.025n

.meas tran vdout0_128ck670 FIND v(dout0_128) AT=340.025n

.meas tran vdout0_129ck670 FIND v(dout0_129) AT=340.025n

.meas tran vdout0_130ck670 FIND v(dout0_130) AT=340.025n

.meas tran vdout0_131ck670 FIND v(dout0_131) AT=340.025n

.meas tran vdout0_132ck670 FIND v(dout0_132) AT=340.025n

.meas tran vdout0_133ck670 FIND v(dout0_133) AT=340.025n

.meas tran vdout0_134ck670 FIND v(dout0_134) AT=340.025n

.meas tran vdout0_135ck670 FIND v(dout0_135) AT=340.025n

.meas tran vdout0_136ck670 FIND v(dout0_136) AT=340.025n

.meas tran vdout0_137ck670 FIND v(dout0_137) AT=340.025n

.meas tran vdout0_138ck670 FIND v(dout0_138) AT=340.025n

.meas tran vdout0_139ck670 FIND v(dout0_139) AT=340.025n

.meas tran vdout0_140ck670 FIND v(dout0_140) AT=340.025n

.meas tran vdout0_141ck670 FIND v(dout0_141) AT=340.025n

.meas tran vdout0_142ck670 FIND v(dout0_142) AT=340.025n

.meas tran vdout0_143ck670 FIND v(dout0_143) AT=340.025n

.meas tran vdout0_144ck670 FIND v(dout0_144) AT=340.025n

.meas tran vdout0_145ck670 FIND v(dout0_145) AT=340.025n

.meas tran vdout0_146ck670 FIND v(dout0_146) AT=340.025n

.meas tran vdout0_147ck670 FIND v(dout0_147) AT=340.025n

.meas tran vdout0_148ck670 FIND v(dout0_148) AT=340.025n

.meas tran vdout0_149ck670 FIND v(dout0_149) AT=340.025n

.meas tran vdout0_0ck710 FIND v(dout0_0) AT=360.025n

.meas tran vdout0_1ck710 FIND v(dout0_1) AT=360.025n

.meas tran vdout0_2ck710 FIND v(dout0_2) AT=360.025n

.meas tran vdout0_3ck710 FIND v(dout0_3) AT=360.025n

.meas tran vdout0_4ck710 FIND v(dout0_4) AT=360.025n

.meas tran vdout0_5ck710 FIND v(dout0_5) AT=360.025n

.meas tran vdout0_6ck710 FIND v(dout0_6) AT=360.025n

.meas tran vdout0_7ck710 FIND v(dout0_7) AT=360.025n

.meas tran vdout0_8ck710 FIND v(dout0_8) AT=360.025n

.meas tran vdout0_9ck710 FIND v(dout0_9) AT=360.025n

.meas tran vdout0_10ck710 FIND v(dout0_10) AT=360.025n

.meas tran vdout0_11ck710 FIND v(dout0_11) AT=360.025n

.meas tran vdout0_12ck710 FIND v(dout0_12) AT=360.025n

.meas tran vdout0_13ck710 FIND v(dout0_13) AT=360.025n

.meas tran vdout0_14ck710 FIND v(dout0_14) AT=360.025n

.meas tran vdout0_15ck710 FIND v(dout0_15) AT=360.025n

.meas tran vdout0_16ck710 FIND v(dout0_16) AT=360.025n

.meas tran vdout0_17ck710 FIND v(dout0_17) AT=360.025n

.meas tran vdout0_18ck710 FIND v(dout0_18) AT=360.025n

.meas tran vdout0_19ck710 FIND v(dout0_19) AT=360.025n

.meas tran vdout0_20ck710 FIND v(dout0_20) AT=360.025n

.meas tran vdout0_21ck710 FIND v(dout0_21) AT=360.025n

.meas tran vdout0_22ck710 FIND v(dout0_22) AT=360.025n

.meas tran vdout0_23ck710 FIND v(dout0_23) AT=360.025n

.meas tran vdout0_24ck710 FIND v(dout0_24) AT=360.025n

.meas tran vdout0_25ck710 FIND v(dout0_25) AT=360.025n

.meas tran vdout0_26ck710 FIND v(dout0_26) AT=360.025n

.meas tran vdout0_27ck710 FIND v(dout0_27) AT=360.025n

.meas tran vdout0_28ck710 FIND v(dout0_28) AT=360.025n

.meas tran vdout0_29ck710 FIND v(dout0_29) AT=360.025n

.meas tran vdout0_30ck710 FIND v(dout0_30) AT=360.025n

.meas tran vdout0_31ck710 FIND v(dout0_31) AT=360.025n

.meas tran vdout0_32ck710 FIND v(dout0_32) AT=360.025n

.meas tran vdout0_33ck710 FIND v(dout0_33) AT=360.025n

.meas tran vdout0_34ck710 FIND v(dout0_34) AT=360.025n

.meas tran vdout0_35ck710 FIND v(dout0_35) AT=360.025n

.meas tran vdout0_36ck710 FIND v(dout0_36) AT=360.025n

.meas tran vdout0_37ck710 FIND v(dout0_37) AT=360.025n

.meas tran vdout0_38ck710 FIND v(dout0_38) AT=360.025n

.meas tran vdout0_39ck710 FIND v(dout0_39) AT=360.025n

.meas tran vdout0_40ck710 FIND v(dout0_40) AT=360.025n

.meas tran vdout0_41ck710 FIND v(dout0_41) AT=360.025n

.meas tran vdout0_42ck710 FIND v(dout0_42) AT=360.025n

.meas tran vdout0_43ck710 FIND v(dout0_43) AT=360.025n

.meas tran vdout0_44ck710 FIND v(dout0_44) AT=360.025n

.meas tran vdout0_45ck710 FIND v(dout0_45) AT=360.025n

.meas tran vdout0_46ck710 FIND v(dout0_46) AT=360.025n

.meas tran vdout0_47ck710 FIND v(dout0_47) AT=360.025n

.meas tran vdout0_48ck710 FIND v(dout0_48) AT=360.025n

.meas tran vdout0_49ck710 FIND v(dout0_49) AT=360.025n

.meas tran vdout0_50ck710 FIND v(dout0_50) AT=360.025n

.meas tran vdout0_51ck710 FIND v(dout0_51) AT=360.025n

.meas tran vdout0_52ck710 FIND v(dout0_52) AT=360.025n

.meas tran vdout0_53ck710 FIND v(dout0_53) AT=360.025n

.meas tran vdout0_54ck710 FIND v(dout0_54) AT=360.025n

.meas tran vdout0_55ck710 FIND v(dout0_55) AT=360.025n

.meas tran vdout0_56ck710 FIND v(dout0_56) AT=360.025n

.meas tran vdout0_57ck710 FIND v(dout0_57) AT=360.025n

.meas tran vdout0_58ck710 FIND v(dout0_58) AT=360.025n

.meas tran vdout0_59ck710 FIND v(dout0_59) AT=360.025n

.meas tran vdout0_60ck710 FIND v(dout0_60) AT=360.025n

.meas tran vdout0_61ck710 FIND v(dout0_61) AT=360.025n

.meas tran vdout0_62ck710 FIND v(dout0_62) AT=360.025n

.meas tran vdout0_63ck710 FIND v(dout0_63) AT=360.025n

.meas tran vdout0_64ck710 FIND v(dout0_64) AT=360.025n

.meas tran vdout0_65ck710 FIND v(dout0_65) AT=360.025n

.meas tran vdout0_66ck710 FIND v(dout0_66) AT=360.025n

.meas tran vdout0_67ck710 FIND v(dout0_67) AT=360.025n

.meas tran vdout0_68ck710 FIND v(dout0_68) AT=360.025n

.meas tran vdout0_69ck710 FIND v(dout0_69) AT=360.025n

.meas tran vdout0_70ck710 FIND v(dout0_70) AT=360.025n

.meas tran vdout0_71ck710 FIND v(dout0_71) AT=360.025n

.meas tran vdout0_72ck710 FIND v(dout0_72) AT=360.025n

.meas tran vdout0_73ck710 FIND v(dout0_73) AT=360.025n

.meas tran vdout0_74ck710 FIND v(dout0_74) AT=360.025n

.meas tran vdout0_75ck710 FIND v(dout0_75) AT=360.025n

.meas tran vdout0_76ck710 FIND v(dout0_76) AT=360.025n

.meas tran vdout0_77ck710 FIND v(dout0_77) AT=360.025n

.meas tran vdout0_78ck710 FIND v(dout0_78) AT=360.025n

.meas tran vdout0_79ck710 FIND v(dout0_79) AT=360.025n

.meas tran vdout0_80ck710 FIND v(dout0_80) AT=360.025n

.meas tran vdout0_81ck710 FIND v(dout0_81) AT=360.025n

.meas tran vdout0_82ck710 FIND v(dout0_82) AT=360.025n

.meas tran vdout0_83ck710 FIND v(dout0_83) AT=360.025n

.meas tran vdout0_84ck710 FIND v(dout0_84) AT=360.025n

.meas tran vdout0_85ck710 FIND v(dout0_85) AT=360.025n

.meas tran vdout0_86ck710 FIND v(dout0_86) AT=360.025n

.meas tran vdout0_87ck710 FIND v(dout0_87) AT=360.025n

.meas tran vdout0_88ck710 FIND v(dout0_88) AT=360.025n

.meas tran vdout0_89ck710 FIND v(dout0_89) AT=360.025n

.meas tran vdout0_90ck710 FIND v(dout0_90) AT=360.025n

.meas tran vdout0_91ck710 FIND v(dout0_91) AT=360.025n

.meas tran vdout0_92ck710 FIND v(dout0_92) AT=360.025n

.meas tran vdout0_93ck710 FIND v(dout0_93) AT=360.025n

.meas tran vdout0_94ck710 FIND v(dout0_94) AT=360.025n

.meas tran vdout0_95ck710 FIND v(dout0_95) AT=360.025n

.meas tran vdout0_96ck710 FIND v(dout0_96) AT=360.025n

.meas tran vdout0_97ck710 FIND v(dout0_97) AT=360.025n

.meas tran vdout0_98ck710 FIND v(dout0_98) AT=360.025n

.meas tran vdout0_99ck710 FIND v(dout0_99) AT=360.025n

.meas tran vdout0_100ck710 FIND v(dout0_100) AT=360.025n

.meas tran vdout0_101ck710 FIND v(dout0_101) AT=360.025n

.meas tran vdout0_102ck710 FIND v(dout0_102) AT=360.025n

.meas tran vdout0_103ck710 FIND v(dout0_103) AT=360.025n

.meas tran vdout0_104ck710 FIND v(dout0_104) AT=360.025n

.meas tran vdout0_105ck710 FIND v(dout0_105) AT=360.025n

.meas tran vdout0_106ck710 FIND v(dout0_106) AT=360.025n

.meas tran vdout0_107ck710 FIND v(dout0_107) AT=360.025n

.meas tran vdout0_108ck710 FIND v(dout0_108) AT=360.025n

.meas tran vdout0_109ck710 FIND v(dout0_109) AT=360.025n

.meas tran vdout0_110ck710 FIND v(dout0_110) AT=360.025n

.meas tran vdout0_111ck710 FIND v(dout0_111) AT=360.025n

.meas tran vdout0_112ck710 FIND v(dout0_112) AT=360.025n

.meas tran vdout0_113ck710 FIND v(dout0_113) AT=360.025n

.meas tran vdout0_114ck710 FIND v(dout0_114) AT=360.025n

.meas tran vdout0_115ck710 FIND v(dout0_115) AT=360.025n

.meas tran vdout0_116ck710 FIND v(dout0_116) AT=360.025n

.meas tran vdout0_117ck710 FIND v(dout0_117) AT=360.025n

.meas tran vdout0_118ck710 FIND v(dout0_118) AT=360.025n

.meas tran vdout0_119ck710 FIND v(dout0_119) AT=360.025n

.meas tran vdout0_120ck710 FIND v(dout0_120) AT=360.025n

.meas tran vdout0_121ck710 FIND v(dout0_121) AT=360.025n

.meas tran vdout0_122ck710 FIND v(dout0_122) AT=360.025n

.meas tran vdout0_123ck710 FIND v(dout0_123) AT=360.025n

.meas tran vdout0_124ck710 FIND v(dout0_124) AT=360.025n

.meas tran vdout0_125ck710 FIND v(dout0_125) AT=360.025n

.meas tran vdout0_126ck710 FIND v(dout0_126) AT=360.025n

.meas tran vdout0_127ck710 FIND v(dout0_127) AT=360.025n

.meas tran vdout0_128ck710 FIND v(dout0_128) AT=360.025n

.meas tran vdout0_129ck710 FIND v(dout0_129) AT=360.025n

.meas tran vdout0_130ck710 FIND v(dout0_130) AT=360.025n

.meas tran vdout0_131ck710 FIND v(dout0_131) AT=360.025n

.meas tran vdout0_132ck710 FIND v(dout0_132) AT=360.025n

.meas tran vdout0_133ck710 FIND v(dout0_133) AT=360.025n

.meas tran vdout0_134ck710 FIND v(dout0_134) AT=360.025n

.meas tran vdout0_135ck710 FIND v(dout0_135) AT=360.025n

.meas tran vdout0_136ck710 FIND v(dout0_136) AT=360.025n

.meas tran vdout0_137ck710 FIND v(dout0_137) AT=360.025n

.meas tran vdout0_138ck710 FIND v(dout0_138) AT=360.025n

.meas tran vdout0_139ck710 FIND v(dout0_139) AT=360.025n

.meas tran vdout0_140ck710 FIND v(dout0_140) AT=360.025n

.meas tran vdout0_141ck710 FIND v(dout0_141) AT=360.025n

.meas tran vdout0_142ck710 FIND v(dout0_142) AT=360.025n

.meas tran vdout0_143ck710 FIND v(dout0_143) AT=360.025n

.meas tran vdout0_144ck710 FIND v(dout0_144) AT=360.025n

.meas tran vdout0_145ck710 FIND v(dout0_145) AT=360.025n

.meas tran vdout0_146ck710 FIND v(dout0_146) AT=360.025n

.meas tran vdout0_147ck710 FIND v(dout0_147) AT=360.025n

.meas tran vdout0_148ck710 FIND v(dout0_148) AT=360.025n

.meas tran vdout0_149ck710 FIND v(dout0_149) AT=360.025n

.meas tran vdout0_0ck740 FIND v(dout0_0) AT=375.025n

.meas tran vdout0_1ck740 FIND v(dout0_1) AT=375.025n

.meas tran vdout0_2ck740 FIND v(dout0_2) AT=375.025n

.meas tran vdout0_3ck740 FIND v(dout0_3) AT=375.025n

.meas tran vdout0_4ck740 FIND v(dout0_4) AT=375.025n

.meas tran vdout0_5ck740 FIND v(dout0_5) AT=375.025n

.meas tran vdout0_6ck740 FIND v(dout0_6) AT=375.025n

.meas tran vdout0_7ck740 FIND v(dout0_7) AT=375.025n

.meas tran vdout0_8ck740 FIND v(dout0_8) AT=375.025n

.meas tran vdout0_9ck740 FIND v(dout0_9) AT=375.025n

.meas tran vdout0_10ck740 FIND v(dout0_10) AT=375.025n

.meas tran vdout0_11ck740 FIND v(dout0_11) AT=375.025n

.meas tran vdout0_12ck740 FIND v(dout0_12) AT=375.025n

.meas tran vdout0_13ck740 FIND v(dout0_13) AT=375.025n

.meas tran vdout0_14ck740 FIND v(dout0_14) AT=375.025n

.meas tran vdout0_15ck740 FIND v(dout0_15) AT=375.025n

.meas tran vdout0_16ck740 FIND v(dout0_16) AT=375.025n

.meas tran vdout0_17ck740 FIND v(dout0_17) AT=375.025n

.meas tran vdout0_18ck740 FIND v(dout0_18) AT=375.025n

.meas tran vdout0_19ck740 FIND v(dout0_19) AT=375.025n

.meas tran vdout0_20ck740 FIND v(dout0_20) AT=375.025n

.meas tran vdout0_21ck740 FIND v(dout0_21) AT=375.025n

.meas tran vdout0_22ck740 FIND v(dout0_22) AT=375.025n

.meas tran vdout0_23ck740 FIND v(dout0_23) AT=375.025n

.meas tran vdout0_24ck740 FIND v(dout0_24) AT=375.025n

.meas tran vdout0_25ck740 FIND v(dout0_25) AT=375.025n

.meas tran vdout0_26ck740 FIND v(dout0_26) AT=375.025n

.meas tran vdout0_27ck740 FIND v(dout0_27) AT=375.025n

.meas tran vdout0_28ck740 FIND v(dout0_28) AT=375.025n

.meas tran vdout0_29ck740 FIND v(dout0_29) AT=375.025n

.meas tran vdout0_30ck740 FIND v(dout0_30) AT=375.025n

.meas tran vdout0_31ck740 FIND v(dout0_31) AT=375.025n

.meas tran vdout0_32ck740 FIND v(dout0_32) AT=375.025n

.meas tran vdout0_33ck740 FIND v(dout0_33) AT=375.025n

.meas tran vdout0_34ck740 FIND v(dout0_34) AT=375.025n

.meas tran vdout0_35ck740 FIND v(dout0_35) AT=375.025n

.meas tran vdout0_36ck740 FIND v(dout0_36) AT=375.025n

.meas tran vdout0_37ck740 FIND v(dout0_37) AT=375.025n

.meas tran vdout0_38ck740 FIND v(dout0_38) AT=375.025n

.meas tran vdout0_39ck740 FIND v(dout0_39) AT=375.025n

.meas tran vdout0_40ck740 FIND v(dout0_40) AT=375.025n

.meas tran vdout0_41ck740 FIND v(dout0_41) AT=375.025n

.meas tran vdout0_42ck740 FIND v(dout0_42) AT=375.025n

.meas tran vdout0_43ck740 FIND v(dout0_43) AT=375.025n

.meas tran vdout0_44ck740 FIND v(dout0_44) AT=375.025n

.meas tran vdout0_45ck740 FIND v(dout0_45) AT=375.025n

.meas tran vdout0_46ck740 FIND v(dout0_46) AT=375.025n

.meas tran vdout0_47ck740 FIND v(dout0_47) AT=375.025n

.meas tran vdout0_48ck740 FIND v(dout0_48) AT=375.025n

.meas tran vdout0_49ck740 FIND v(dout0_49) AT=375.025n

.meas tran vdout0_50ck740 FIND v(dout0_50) AT=375.025n

.meas tran vdout0_51ck740 FIND v(dout0_51) AT=375.025n

.meas tran vdout0_52ck740 FIND v(dout0_52) AT=375.025n

.meas tran vdout0_53ck740 FIND v(dout0_53) AT=375.025n

.meas tran vdout0_54ck740 FIND v(dout0_54) AT=375.025n

.meas tran vdout0_55ck740 FIND v(dout0_55) AT=375.025n

.meas tran vdout0_56ck740 FIND v(dout0_56) AT=375.025n

.meas tran vdout0_57ck740 FIND v(dout0_57) AT=375.025n

.meas tran vdout0_58ck740 FIND v(dout0_58) AT=375.025n

.meas tran vdout0_59ck740 FIND v(dout0_59) AT=375.025n

.meas tran vdout0_60ck740 FIND v(dout0_60) AT=375.025n

.meas tran vdout0_61ck740 FIND v(dout0_61) AT=375.025n

.meas tran vdout0_62ck740 FIND v(dout0_62) AT=375.025n

.meas tran vdout0_63ck740 FIND v(dout0_63) AT=375.025n

.meas tran vdout0_64ck740 FIND v(dout0_64) AT=375.025n

.meas tran vdout0_65ck740 FIND v(dout0_65) AT=375.025n

.meas tran vdout0_66ck740 FIND v(dout0_66) AT=375.025n

.meas tran vdout0_67ck740 FIND v(dout0_67) AT=375.025n

.meas tran vdout0_68ck740 FIND v(dout0_68) AT=375.025n

.meas tran vdout0_69ck740 FIND v(dout0_69) AT=375.025n

.meas tran vdout0_70ck740 FIND v(dout0_70) AT=375.025n

.meas tran vdout0_71ck740 FIND v(dout0_71) AT=375.025n

.meas tran vdout0_72ck740 FIND v(dout0_72) AT=375.025n

.meas tran vdout0_73ck740 FIND v(dout0_73) AT=375.025n

.meas tran vdout0_74ck740 FIND v(dout0_74) AT=375.025n

.meas tran vdout0_75ck740 FIND v(dout0_75) AT=375.025n

.meas tran vdout0_76ck740 FIND v(dout0_76) AT=375.025n

.meas tran vdout0_77ck740 FIND v(dout0_77) AT=375.025n

.meas tran vdout0_78ck740 FIND v(dout0_78) AT=375.025n

.meas tran vdout0_79ck740 FIND v(dout0_79) AT=375.025n

.meas tran vdout0_80ck740 FIND v(dout0_80) AT=375.025n

.meas tran vdout0_81ck740 FIND v(dout0_81) AT=375.025n

.meas tran vdout0_82ck740 FIND v(dout0_82) AT=375.025n

.meas tran vdout0_83ck740 FIND v(dout0_83) AT=375.025n

.meas tran vdout0_84ck740 FIND v(dout0_84) AT=375.025n

.meas tran vdout0_85ck740 FIND v(dout0_85) AT=375.025n

.meas tran vdout0_86ck740 FIND v(dout0_86) AT=375.025n

.meas tran vdout0_87ck740 FIND v(dout0_87) AT=375.025n

.meas tran vdout0_88ck740 FIND v(dout0_88) AT=375.025n

.meas tran vdout0_89ck740 FIND v(dout0_89) AT=375.025n

.meas tran vdout0_90ck740 FIND v(dout0_90) AT=375.025n

.meas tran vdout0_91ck740 FIND v(dout0_91) AT=375.025n

.meas tran vdout0_92ck740 FIND v(dout0_92) AT=375.025n

.meas tran vdout0_93ck740 FIND v(dout0_93) AT=375.025n

.meas tran vdout0_94ck740 FIND v(dout0_94) AT=375.025n

.meas tran vdout0_95ck740 FIND v(dout0_95) AT=375.025n

.meas tran vdout0_96ck740 FIND v(dout0_96) AT=375.025n

.meas tran vdout0_97ck740 FIND v(dout0_97) AT=375.025n

.meas tran vdout0_98ck740 FIND v(dout0_98) AT=375.025n

.meas tran vdout0_99ck740 FIND v(dout0_99) AT=375.025n

.meas tran vdout0_100ck740 FIND v(dout0_100) AT=375.025n

.meas tran vdout0_101ck740 FIND v(dout0_101) AT=375.025n

.meas tran vdout0_102ck740 FIND v(dout0_102) AT=375.025n

.meas tran vdout0_103ck740 FIND v(dout0_103) AT=375.025n

.meas tran vdout0_104ck740 FIND v(dout0_104) AT=375.025n

.meas tran vdout0_105ck740 FIND v(dout0_105) AT=375.025n

.meas tran vdout0_106ck740 FIND v(dout0_106) AT=375.025n

.meas tran vdout0_107ck740 FIND v(dout0_107) AT=375.025n

.meas tran vdout0_108ck740 FIND v(dout0_108) AT=375.025n

.meas tran vdout0_109ck740 FIND v(dout0_109) AT=375.025n

.meas tran vdout0_110ck740 FIND v(dout0_110) AT=375.025n

.meas tran vdout0_111ck740 FIND v(dout0_111) AT=375.025n

.meas tran vdout0_112ck740 FIND v(dout0_112) AT=375.025n

.meas tran vdout0_113ck740 FIND v(dout0_113) AT=375.025n

.meas tran vdout0_114ck740 FIND v(dout0_114) AT=375.025n

.meas tran vdout0_115ck740 FIND v(dout0_115) AT=375.025n

.meas tran vdout0_116ck740 FIND v(dout0_116) AT=375.025n

.meas tran vdout0_117ck740 FIND v(dout0_117) AT=375.025n

.meas tran vdout0_118ck740 FIND v(dout0_118) AT=375.025n

.meas tran vdout0_119ck740 FIND v(dout0_119) AT=375.025n

.meas tran vdout0_120ck740 FIND v(dout0_120) AT=375.025n

.meas tran vdout0_121ck740 FIND v(dout0_121) AT=375.025n

.meas tran vdout0_122ck740 FIND v(dout0_122) AT=375.025n

.meas tran vdout0_123ck740 FIND v(dout0_123) AT=375.025n

.meas tran vdout0_124ck740 FIND v(dout0_124) AT=375.025n

.meas tran vdout0_125ck740 FIND v(dout0_125) AT=375.025n

.meas tran vdout0_126ck740 FIND v(dout0_126) AT=375.025n

.meas tran vdout0_127ck740 FIND v(dout0_127) AT=375.025n

.meas tran vdout0_128ck740 FIND v(dout0_128) AT=375.025n

.meas tran vdout0_129ck740 FIND v(dout0_129) AT=375.025n

.meas tran vdout0_130ck740 FIND v(dout0_130) AT=375.025n

.meas tran vdout0_131ck740 FIND v(dout0_131) AT=375.025n

.meas tran vdout0_132ck740 FIND v(dout0_132) AT=375.025n

.meas tran vdout0_133ck740 FIND v(dout0_133) AT=375.025n

.meas tran vdout0_134ck740 FIND v(dout0_134) AT=375.025n

.meas tran vdout0_135ck740 FIND v(dout0_135) AT=375.025n

.meas tran vdout0_136ck740 FIND v(dout0_136) AT=375.025n

.meas tran vdout0_137ck740 FIND v(dout0_137) AT=375.025n

.meas tran vdout0_138ck740 FIND v(dout0_138) AT=375.025n

.meas tran vdout0_139ck740 FIND v(dout0_139) AT=375.025n

.meas tran vdout0_140ck740 FIND v(dout0_140) AT=375.025n

.meas tran vdout0_141ck740 FIND v(dout0_141) AT=375.025n

.meas tran vdout0_142ck740 FIND v(dout0_142) AT=375.025n

.meas tran vdout0_143ck740 FIND v(dout0_143) AT=375.025n

.meas tran vdout0_144ck740 FIND v(dout0_144) AT=375.025n

.meas tran vdout0_145ck740 FIND v(dout0_145) AT=375.025n

.meas tran vdout0_146ck740 FIND v(dout0_146) AT=375.025n

.meas tran vdout0_147ck740 FIND v(dout0_147) AT=375.025n

.meas tran vdout0_148ck740 FIND v(dout0_148) AT=375.025n

.meas tran vdout0_149ck740 FIND v(dout0_149) AT=375.025n

.meas tran vdout0_0ck760 FIND v(dout0_0) AT=385.025n

.meas tran vdout0_1ck760 FIND v(dout0_1) AT=385.025n

.meas tran vdout0_2ck760 FIND v(dout0_2) AT=385.025n

.meas tran vdout0_3ck760 FIND v(dout0_3) AT=385.025n

.meas tran vdout0_4ck760 FIND v(dout0_4) AT=385.025n

.meas tran vdout0_5ck760 FIND v(dout0_5) AT=385.025n

.meas tran vdout0_6ck760 FIND v(dout0_6) AT=385.025n

.meas tran vdout0_7ck760 FIND v(dout0_7) AT=385.025n

.meas tran vdout0_8ck760 FIND v(dout0_8) AT=385.025n

.meas tran vdout0_9ck760 FIND v(dout0_9) AT=385.025n

.meas tran vdout0_10ck760 FIND v(dout0_10) AT=385.025n

.meas tran vdout0_11ck760 FIND v(dout0_11) AT=385.025n

.meas tran vdout0_12ck760 FIND v(dout0_12) AT=385.025n

.meas tran vdout0_13ck760 FIND v(dout0_13) AT=385.025n

.meas tran vdout0_14ck760 FIND v(dout0_14) AT=385.025n

.meas tran vdout0_15ck760 FIND v(dout0_15) AT=385.025n

.meas tran vdout0_16ck760 FIND v(dout0_16) AT=385.025n

.meas tran vdout0_17ck760 FIND v(dout0_17) AT=385.025n

.meas tran vdout0_18ck760 FIND v(dout0_18) AT=385.025n

.meas tran vdout0_19ck760 FIND v(dout0_19) AT=385.025n

.meas tran vdout0_20ck760 FIND v(dout0_20) AT=385.025n

.meas tran vdout0_21ck760 FIND v(dout0_21) AT=385.025n

.meas tran vdout0_22ck760 FIND v(dout0_22) AT=385.025n

.meas tran vdout0_23ck760 FIND v(dout0_23) AT=385.025n

.meas tran vdout0_24ck760 FIND v(dout0_24) AT=385.025n

.meas tran vdout0_25ck760 FIND v(dout0_25) AT=385.025n

.meas tran vdout0_26ck760 FIND v(dout0_26) AT=385.025n

.meas tran vdout0_27ck760 FIND v(dout0_27) AT=385.025n

.meas tran vdout0_28ck760 FIND v(dout0_28) AT=385.025n

.meas tran vdout0_29ck760 FIND v(dout0_29) AT=385.025n

.meas tran vdout0_30ck760 FIND v(dout0_30) AT=385.025n

.meas tran vdout0_31ck760 FIND v(dout0_31) AT=385.025n

.meas tran vdout0_32ck760 FIND v(dout0_32) AT=385.025n

.meas tran vdout0_33ck760 FIND v(dout0_33) AT=385.025n

.meas tran vdout0_34ck760 FIND v(dout0_34) AT=385.025n

.meas tran vdout0_35ck760 FIND v(dout0_35) AT=385.025n

.meas tran vdout0_36ck760 FIND v(dout0_36) AT=385.025n

.meas tran vdout0_37ck760 FIND v(dout0_37) AT=385.025n

.meas tran vdout0_38ck760 FIND v(dout0_38) AT=385.025n

.meas tran vdout0_39ck760 FIND v(dout0_39) AT=385.025n

.meas tran vdout0_40ck760 FIND v(dout0_40) AT=385.025n

.meas tran vdout0_41ck760 FIND v(dout0_41) AT=385.025n

.meas tran vdout0_42ck760 FIND v(dout0_42) AT=385.025n

.meas tran vdout0_43ck760 FIND v(dout0_43) AT=385.025n

.meas tran vdout0_44ck760 FIND v(dout0_44) AT=385.025n

.meas tran vdout0_45ck760 FIND v(dout0_45) AT=385.025n

.meas tran vdout0_46ck760 FIND v(dout0_46) AT=385.025n

.meas tran vdout0_47ck760 FIND v(dout0_47) AT=385.025n

.meas tran vdout0_48ck760 FIND v(dout0_48) AT=385.025n

.meas tran vdout0_49ck760 FIND v(dout0_49) AT=385.025n

.meas tran vdout0_50ck760 FIND v(dout0_50) AT=385.025n

.meas tran vdout0_51ck760 FIND v(dout0_51) AT=385.025n

.meas tran vdout0_52ck760 FIND v(dout0_52) AT=385.025n

.meas tran vdout0_53ck760 FIND v(dout0_53) AT=385.025n

.meas tran vdout0_54ck760 FIND v(dout0_54) AT=385.025n

.meas tran vdout0_55ck760 FIND v(dout0_55) AT=385.025n

.meas tran vdout0_56ck760 FIND v(dout0_56) AT=385.025n

.meas tran vdout0_57ck760 FIND v(dout0_57) AT=385.025n

.meas tran vdout0_58ck760 FIND v(dout0_58) AT=385.025n

.meas tran vdout0_59ck760 FIND v(dout0_59) AT=385.025n

.meas tran vdout0_60ck760 FIND v(dout0_60) AT=385.025n

.meas tran vdout0_61ck760 FIND v(dout0_61) AT=385.025n

.meas tran vdout0_62ck760 FIND v(dout0_62) AT=385.025n

.meas tran vdout0_63ck760 FIND v(dout0_63) AT=385.025n

.meas tran vdout0_64ck760 FIND v(dout0_64) AT=385.025n

.meas tran vdout0_65ck760 FIND v(dout0_65) AT=385.025n

.meas tran vdout0_66ck760 FIND v(dout0_66) AT=385.025n

.meas tran vdout0_67ck760 FIND v(dout0_67) AT=385.025n

.meas tran vdout0_68ck760 FIND v(dout0_68) AT=385.025n

.meas tran vdout0_69ck760 FIND v(dout0_69) AT=385.025n

.meas tran vdout0_70ck760 FIND v(dout0_70) AT=385.025n

.meas tran vdout0_71ck760 FIND v(dout0_71) AT=385.025n

.meas tran vdout0_72ck760 FIND v(dout0_72) AT=385.025n

.meas tran vdout0_73ck760 FIND v(dout0_73) AT=385.025n

.meas tran vdout0_74ck760 FIND v(dout0_74) AT=385.025n

.meas tran vdout0_75ck760 FIND v(dout0_75) AT=385.025n

.meas tran vdout0_76ck760 FIND v(dout0_76) AT=385.025n

.meas tran vdout0_77ck760 FIND v(dout0_77) AT=385.025n

.meas tran vdout0_78ck760 FIND v(dout0_78) AT=385.025n

.meas tran vdout0_79ck760 FIND v(dout0_79) AT=385.025n

.meas tran vdout0_80ck760 FIND v(dout0_80) AT=385.025n

.meas tran vdout0_81ck760 FIND v(dout0_81) AT=385.025n

.meas tran vdout0_82ck760 FIND v(dout0_82) AT=385.025n

.meas tran vdout0_83ck760 FIND v(dout0_83) AT=385.025n

.meas tran vdout0_84ck760 FIND v(dout0_84) AT=385.025n

.meas tran vdout0_85ck760 FIND v(dout0_85) AT=385.025n

.meas tran vdout0_86ck760 FIND v(dout0_86) AT=385.025n

.meas tran vdout0_87ck760 FIND v(dout0_87) AT=385.025n

.meas tran vdout0_88ck760 FIND v(dout0_88) AT=385.025n

.meas tran vdout0_89ck760 FIND v(dout0_89) AT=385.025n

.meas tran vdout0_90ck760 FIND v(dout0_90) AT=385.025n

.meas tran vdout0_91ck760 FIND v(dout0_91) AT=385.025n

.meas tran vdout0_92ck760 FIND v(dout0_92) AT=385.025n

.meas tran vdout0_93ck760 FIND v(dout0_93) AT=385.025n

.meas tran vdout0_94ck760 FIND v(dout0_94) AT=385.025n

.meas tran vdout0_95ck760 FIND v(dout0_95) AT=385.025n

.meas tran vdout0_96ck760 FIND v(dout0_96) AT=385.025n

.meas tran vdout0_97ck760 FIND v(dout0_97) AT=385.025n

.meas tran vdout0_98ck760 FIND v(dout0_98) AT=385.025n

.meas tran vdout0_99ck760 FIND v(dout0_99) AT=385.025n

.meas tran vdout0_100ck760 FIND v(dout0_100) AT=385.025n

.meas tran vdout0_101ck760 FIND v(dout0_101) AT=385.025n

.meas tran vdout0_102ck760 FIND v(dout0_102) AT=385.025n

.meas tran vdout0_103ck760 FIND v(dout0_103) AT=385.025n

.meas tran vdout0_104ck760 FIND v(dout0_104) AT=385.025n

.meas tran vdout0_105ck760 FIND v(dout0_105) AT=385.025n

.meas tran vdout0_106ck760 FIND v(dout0_106) AT=385.025n

.meas tran vdout0_107ck760 FIND v(dout0_107) AT=385.025n

.meas tran vdout0_108ck760 FIND v(dout0_108) AT=385.025n

.meas tran vdout0_109ck760 FIND v(dout0_109) AT=385.025n

.meas tran vdout0_110ck760 FIND v(dout0_110) AT=385.025n

.meas tran vdout0_111ck760 FIND v(dout0_111) AT=385.025n

.meas tran vdout0_112ck760 FIND v(dout0_112) AT=385.025n

.meas tran vdout0_113ck760 FIND v(dout0_113) AT=385.025n

.meas tran vdout0_114ck760 FIND v(dout0_114) AT=385.025n

.meas tran vdout0_115ck760 FIND v(dout0_115) AT=385.025n

.meas tran vdout0_116ck760 FIND v(dout0_116) AT=385.025n

.meas tran vdout0_117ck760 FIND v(dout0_117) AT=385.025n

.meas tran vdout0_118ck760 FIND v(dout0_118) AT=385.025n

.meas tran vdout0_119ck760 FIND v(dout0_119) AT=385.025n

.meas tran vdout0_120ck760 FIND v(dout0_120) AT=385.025n

.meas tran vdout0_121ck760 FIND v(dout0_121) AT=385.025n

.meas tran vdout0_122ck760 FIND v(dout0_122) AT=385.025n

.meas tran vdout0_123ck760 FIND v(dout0_123) AT=385.025n

.meas tran vdout0_124ck760 FIND v(dout0_124) AT=385.025n

.meas tran vdout0_125ck760 FIND v(dout0_125) AT=385.025n

.meas tran vdout0_126ck760 FIND v(dout0_126) AT=385.025n

.meas tran vdout0_127ck760 FIND v(dout0_127) AT=385.025n

.meas tran vdout0_128ck760 FIND v(dout0_128) AT=385.025n

.meas tran vdout0_129ck760 FIND v(dout0_129) AT=385.025n

.meas tran vdout0_130ck760 FIND v(dout0_130) AT=385.025n

.meas tran vdout0_131ck760 FIND v(dout0_131) AT=385.025n

.meas tran vdout0_132ck760 FIND v(dout0_132) AT=385.025n

.meas tran vdout0_133ck760 FIND v(dout0_133) AT=385.025n

.meas tran vdout0_134ck760 FIND v(dout0_134) AT=385.025n

.meas tran vdout0_135ck760 FIND v(dout0_135) AT=385.025n

.meas tran vdout0_136ck760 FIND v(dout0_136) AT=385.025n

.meas tran vdout0_137ck760 FIND v(dout0_137) AT=385.025n

.meas tran vdout0_138ck760 FIND v(dout0_138) AT=385.025n

.meas tran vdout0_139ck760 FIND v(dout0_139) AT=385.025n

.meas tran vdout0_140ck760 FIND v(dout0_140) AT=385.025n

.meas tran vdout0_141ck760 FIND v(dout0_141) AT=385.025n

.meas tran vdout0_142ck760 FIND v(dout0_142) AT=385.025n

.meas tran vdout0_143ck760 FIND v(dout0_143) AT=385.025n

.meas tran vdout0_144ck760 FIND v(dout0_144) AT=385.025n

.meas tran vdout0_145ck760 FIND v(dout0_145) AT=385.025n

.meas tran vdout0_146ck760 FIND v(dout0_146) AT=385.025n

.meas tran vdout0_147ck760 FIND v(dout0_147) AT=385.025n

.meas tran vdout0_148ck760 FIND v(dout0_148) AT=385.025n

.meas tran vdout0_149ck760 FIND v(dout0_149) AT=385.025n

.meas tran vdout0_0ck780 FIND v(dout0_0) AT=395.025n

.meas tran vdout0_1ck780 FIND v(dout0_1) AT=395.025n

.meas tran vdout0_2ck780 FIND v(dout0_2) AT=395.025n

.meas tran vdout0_3ck780 FIND v(dout0_3) AT=395.025n

.meas tran vdout0_4ck780 FIND v(dout0_4) AT=395.025n

.meas tran vdout0_5ck780 FIND v(dout0_5) AT=395.025n

.meas tran vdout0_6ck780 FIND v(dout0_6) AT=395.025n

.meas tran vdout0_7ck780 FIND v(dout0_7) AT=395.025n

.meas tran vdout0_8ck780 FIND v(dout0_8) AT=395.025n

.meas tran vdout0_9ck780 FIND v(dout0_9) AT=395.025n

.meas tran vdout0_10ck780 FIND v(dout0_10) AT=395.025n

.meas tran vdout0_11ck780 FIND v(dout0_11) AT=395.025n

.meas tran vdout0_12ck780 FIND v(dout0_12) AT=395.025n

.meas tran vdout0_13ck780 FIND v(dout0_13) AT=395.025n

.meas tran vdout0_14ck780 FIND v(dout0_14) AT=395.025n

.meas tran vdout0_15ck780 FIND v(dout0_15) AT=395.025n

.meas tran vdout0_16ck780 FIND v(dout0_16) AT=395.025n

.meas tran vdout0_17ck780 FIND v(dout0_17) AT=395.025n

.meas tran vdout0_18ck780 FIND v(dout0_18) AT=395.025n

.meas tran vdout0_19ck780 FIND v(dout0_19) AT=395.025n

.meas tran vdout0_20ck780 FIND v(dout0_20) AT=395.025n

.meas tran vdout0_21ck780 FIND v(dout0_21) AT=395.025n

.meas tran vdout0_22ck780 FIND v(dout0_22) AT=395.025n

.meas tran vdout0_23ck780 FIND v(dout0_23) AT=395.025n

.meas tran vdout0_24ck780 FIND v(dout0_24) AT=395.025n

.meas tran vdout0_25ck780 FIND v(dout0_25) AT=395.025n

.meas tran vdout0_26ck780 FIND v(dout0_26) AT=395.025n

.meas tran vdout0_27ck780 FIND v(dout0_27) AT=395.025n

.meas tran vdout0_28ck780 FIND v(dout0_28) AT=395.025n

.meas tran vdout0_29ck780 FIND v(dout0_29) AT=395.025n

.meas tran vdout0_30ck780 FIND v(dout0_30) AT=395.025n

.meas tran vdout0_31ck780 FIND v(dout0_31) AT=395.025n

.meas tran vdout0_32ck780 FIND v(dout0_32) AT=395.025n

.meas tran vdout0_33ck780 FIND v(dout0_33) AT=395.025n

.meas tran vdout0_34ck780 FIND v(dout0_34) AT=395.025n

.meas tran vdout0_35ck780 FIND v(dout0_35) AT=395.025n

.meas tran vdout0_36ck780 FIND v(dout0_36) AT=395.025n

.meas tran vdout0_37ck780 FIND v(dout0_37) AT=395.025n

.meas tran vdout0_38ck780 FIND v(dout0_38) AT=395.025n

.meas tran vdout0_39ck780 FIND v(dout0_39) AT=395.025n

.meas tran vdout0_40ck780 FIND v(dout0_40) AT=395.025n

.meas tran vdout0_41ck780 FIND v(dout0_41) AT=395.025n

.meas tran vdout0_42ck780 FIND v(dout0_42) AT=395.025n

.meas tran vdout0_43ck780 FIND v(dout0_43) AT=395.025n

.meas tran vdout0_44ck780 FIND v(dout0_44) AT=395.025n

.meas tran vdout0_45ck780 FIND v(dout0_45) AT=395.025n

.meas tran vdout0_46ck780 FIND v(dout0_46) AT=395.025n

.meas tran vdout0_47ck780 FIND v(dout0_47) AT=395.025n

.meas tran vdout0_48ck780 FIND v(dout0_48) AT=395.025n

.meas tran vdout0_49ck780 FIND v(dout0_49) AT=395.025n

.meas tran vdout0_50ck780 FIND v(dout0_50) AT=395.025n

.meas tran vdout0_51ck780 FIND v(dout0_51) AT=395.025n

.meas tran vdout0_52ck780 FIND v(dout0_52) AT=395.025n

.meas tran vdout0_53ck780 FIND v(dout0_53) AT=395.025n

.meas tran vdout0_54ck780 FIND v(dout0_54) AT=395.025n

.meas tran vdout0_55ck780 FIND v(dout0_55) AT=395.025n

.meas tran vdout0_56ck780 FIND v(dout0_56) AT=395.025n

.meas tran vdout0_57ck780 FIND v(dout0_57) AT=395.025n

.meas tran vdout0_58ck780 FIND v(dout0_58) AT=395.025n

.meas tran vdout0_59ck780 FIND v(dout0_59) AT=395.025n

.meas tran vdout0_60ck780 FIND v(dout0_60) AT=395.025n

.meas tran vdout0_61ck780 FIND v(dout0_61) AT=395.025n

.meas tran vdout0_62ck780 FIND v(dout0_62) AT=395.025n

.meas tran vdout0_63ck780 FIND v(dout0_63) AT=395.025n

.meas tran vdout0_64ck780 FIND v(dout0_64) AT=395.025n

.meas tran vdout0_65ck780 FIND v(dout0_65) AT=395.025n

.meas tran vdout0_66ck780 FIND v(dout0_66) AT=395.025n

.meas tran vdout0_67ck780 FIND v(dout0_67) AT=395.025n

.meas tran vdout0_68ck780 FIND v(dout0_68) AT=395.025n

.meas tran vdout0_69ck780 FIND v(dout0_69) AT=395.025n

.meas tran vdout0_70ck780 FIND v(dout0_70) AT=395.025n

.meas tran vdout0_71ck780 FIND v(dout0_71) AT=395.025n

.meas tran vdout0_72ck780 FIND v(dout0_72) AT=395.025n

.meas tran vdout0_73ck780 FIND v(dout0_73) AT=395.025n

.meas tran vdout0_74ck780 FIND v(dout0_74) AT=395.025n

.meas tran vdout0_75ck780 FIND v(dout0_75) AT=395.025n

.meas tran vdout0_76ck780 FIND v(dout0_76) AT=395.025n

.meas tran vdout0_77ck780 FIND v(dout0_77) AT=395.025n

.meas tran vdout0_78ck780 FIND v(dout0_78) AT=395.025n

.meas tran vdout0_79ck780 FIND v(dout0_79) AT=395.025n

.meas tran vdout0_80ck780 FIND v(dout0_80) AT=395.025n

.meas tran vdout0_81ck780 FIND v(dout0_81) AT=395.025n

.meas tran vdout0_82ck780 FIND v(dout0_82) AT=395.025n

.meas tran vdout0_83ck780 FIND v(dout0_83) AT=395.025n

.meas tran vdout0_84ck780 FIND v(dout0_84) AT=395.025n

.meas tran vdout0_85ck780 FIND v(dout0_85) AT=395.025n

.meas tran vdout0_86ck780 FIND v(dout0_86) AT=395.025n

.meas tran vdout0_87ck780 FIND v(dout0_87) AT=395.025n

.meas tran vdout0_88ck780 FIND v(dout0_88) AT=395.025n

.meas tran vdout0_89ck780 FIND v(dout0_89) AT=395.025n

.meas tran vdout0_90ck780 FIND v(dout0_90) AT=395.025n

.meas tran vdout0_91ck780 FIND v(dout0_91) AT=395.025n

.meas tran vdout0_92ck780 FIND v(dout0_92) AT=395.025n

.meas tran vdout0_93ck780 FIND v(dout0_93) AT=395.025n

.meas tran vdout0_94ck780 FIND v(dout0_94) AT=395.025n

.meas tran vdout0_95ck780 FIND v(dout0_95) AT=395.025n

.meas tran vdout0_96ck780 FIND v(dout0_96) AT=395.025n

.meas tran vdout0_97ck780 FIND v(dout0_97) AT=395.025n

.meas tran vdout0_98ck780 FIND v(dout0_98) AT=395.025n

.meas tran vdout0_99ck780 FIND v(dout0_99) AT=395.025n

.meas tran vdout0_100ck780 FIND v(dout0_100) AT=395.025n

.meas tran vdout0_101ck780 FIND v(dout0_101) AT=395.025n

.meas tran vdout0_102ck780 FIND v(dout0_102) AT=395.025n

.meas tran vdout0_103ck780 FIND v(dout0_103) AT=395.025n

.meas tran vdout0_104ck780 FIND v(dout0_104) AT=395.025n

.meas tran vdout0_105ck780 FIND v(dout0_105) AT=395.025n

.meas tran vdout0_106ck780 FIND v(dout0_106) AT=395.025n

.meas tran vdout0_107ck780 FIND v(dout0_107) AT=395.025n

.meas tran vdout0_108ck780 FIND v(dout0_108) AT=395.025n

.meas tran vdout0_109ck780 FIND v(dout0_109) AT=395.025n

.meas tran vdout0_110ck780 FIND v(dout0_110) AT=395.025n

.meas tran vdout0_111ck780 FIND v(dout0_111) AT=395.025n

.meas tran vdout0_112ck780 FIND v(dout0_112) AT=395.025n

.meas tran vdout0_113ck780 FIND v(dout0_113) AT=395.025n

.meas tran vdout0_114ck780 FIND v(dout0_114) AT=395.025n

.meas tran vdout0_115ck780 FIND v(dout0_115) AT=395.025n

.meas tran vdout0_116ck780 FIND v(dout0_116) AT=395.025n

.meas tran vdout0_117ck780 FIND v(dout0_117) AT=395.025n

.meas tran vdout0_118ck780 FIND v(dout0_118) AT=395.025n

.meas tran vdout0_119ck780 FIND v(dout0_119) AT=395.025n

.meas tran vdout0_120ck780 FIND v(dout0_120) AT=395.025n

.meas tran vdout0_121ck780 FIND v(dout0_121) AT=395.025n

.meas tran vdout0_122ck780 FIND v(dout0_122) AT=395.025n

.meas tran vdout0_123ck780 FIND v(dout0_123) AT=395.025n

.meas tran vdout0_124ck780 FIND v(dout0_124) AT=395.025n

.meas tran vdout0_125ck780 FIND v(dout0_125) AT=395.025n

.meas tran vdout0_126ck780 FIND v(dout0_126) AT=395.025n

.meas tran vdout0_127ck780 FIND v(dout0_127) AT=395.025n

.meas tran vdout0_128ck780 FIND v(dout0_128) AT=395.025n

.meas tran vdout0_129ck780 FIND v(dout0_129) AT=395.025n

.meas tran vdout0_130ck780 FIND v(dout0_130) AT=395.025n

.meas tran vdout0_131ck780 FIND v(dout0_131) AT=395.025n

.meas tran vdout0_132ck780 FIND v(dout0_132) AT=395.025n

.meas tran vdout0_133ck780 FIND v(dout0_133) AT=395.025n

.meas tran vdout0_134ck780 FIND v(dout0_134) AT=395.025n

.meas tran vdout0_135ck780 FIND v(dout0_135) AT=395.025n

.meas tran vdout0_136ck780 FIND v(dout0_136) AT=395.025n

.meas tran vdout0_137ck780 FIND v(dout0_137) AT=395.025n

.meas tran vdout0_138ck780 FIND v(dout0_138) AT=395.025n

.meas tran vdout0_139ck780 FIND v(dout0_139) AT=395.025n

.meas tran vdout0_140ck780 FIND v(dout0_140) AT=395.025n

.meas tran vdout0_141ck780 FIND v(dout0_141) AT=395.025n

.meas tran vdout0_142ck780 FIND v(dout0_142) AT=395.025n

.meas tran vdout0_143ck780 FIND v(dout0_143) AT=395.025n

.meas tran vdout0_144ck780 FIND v(dout0_144) AT=395.025n

.meas tran vdout0_145ck780 FIND v(dout0_145) AT=395.025n

.meas tran vdout0_146ck780 FIND v(dout0_146) AT=395.025n

.meas tran vdout0_147ck780 FIND v(dout0_147) AT=395.025n

.meas tran vdout0_148ck780 FIND v(dout0_148) AT=395.025n

.meas tran vdout0_149ck780 FIND v(dout0_149) AT=395.025n

.meas tran vdout0_0ck810 FIND v(dout0_0) AT=410.025n

.meas tran vdout0_1ck810 FIND v(dout0_1) AT=410.025n

.meas tran vdout0_2ck810 FIND v(dout0_2) AT=410.025n

.meas tran vdout0_3ck810 FIND v(dout0_3) AT=410.025n

.meas tran vdout0_4ck810 FIND v(dout0_4) AT=410.025n

.meas tran vdout0_5ck810 FIND v(dout0_5) AT=410.025n

.meas tran vdout0_6ck810 FIND v(dout0_6) AT=410.025n

.meas tran vdout0_7ck810 FIND v(dout0_7) AT=410.025n

.meas tran vdout0_8ck810 FIND v(dout0_8) AT=410.025n

.meas tran vdout0_9ck810 FIND v(dout0_9) AT=410.025n

.meas tran vdout0_10ck810 FIND v(dout0_10) AT=410.025n

.meas tran vdout0_11ck810 FIND v(dout0_11) AT=410.025n

.meas tran vdout0_12ck810 FIND v(dout0_12) AT=410.025n

.meas tran vdout0_13ck810 FIND v(dout0_13) AT=410.025n

.meas tran vdout0_14ck810 FIND v(dout0_14) AT=410.025n

.meas tran vdout0_15ck810 FIND v(dout0_15) AT=410.025n

.meas tran vdout0_16ck810 FIND v(dout0_16) AT=410.025n

.meas tran vdout0_17ck810 FIND v(dout0_17) AT=410.025n

.meas tran vdout0_18ck810 FIND v(dout0_18) AT=410.025n

.meas tran vdout0_19ck810 FIND v(dout0_19) AT=410.025n

.meas tran vdout0_20ck810 FIND v(dout0_20) AT=410.025n

.meas tran vdout0_21ck810 FIND v(dout0_21) AT=410.025n

.meas tran vdout0_22ck810 FIND v(dout0_22) AT=410.025n

.meas tran vdout0_23ck810 FIND v(dout0_23) AT=410.025n

.meas tran vdout0_24ck810 FIND v(dout0_24) AT=410.025n

.meas tran vdout0_25ck810 FIND v(dout0_25) AT=410.025n

.meas tran vdout0_26ck810 FIND v(dout0_26) AT=410.025n

.meas tran vdout0_27ck810 FIND v(dout0_27) AT=410.025n

.meas tran vdout0_28ck810 FIND v(dout0_28) AT=410.025n

.meas tran vdout0_29ck810 FIND v(dout0_29) AT=410.025n

.meas tran vdout0_30ck810 FIND v(dout0_30) AT=410.025n

.meas tran vdout0_31ck810 FIND v(dout0_31) AT=410.025n

.meas tran vdout0_32ck810 FIND v(dout0_32) AT=410.025n

.meas tran vdout0_33ck810 FIND v(dout0_33) AT=410.025n

.meas tran vdout0_34ck810 FIND v(dout0_34) AT=410.025n

.meas tran vdout0_35ck810 FIND v(dout0_35) AT=410.025n

.meas tran vdout0_36ck810 FIND v(dout0_36) AT=410.025n

.meas tran vdout0_37ck810 FIND v(dout0_37) AT=410.025n

.meas tran vdout0_38ck810 FIND v(dout0_38) AT=410.025n

.meas tran vdout0_39ck810 FIND v(dout0_39) AT=410.025n

.meas tran vdout0_40ck810 FIND v(dout0_40) AT=410.025n

.meas tran vdout0_41ck810 FIND v(dout0_41) AT=410.025n

.meas tran vdout0_42ck810 FIND v(dout0_42) AT=410.025n

.meas tran vdout0_43ck810 FIND v(dout0_43) AT=410.025n

.meas tran vdout0_44ck810 FIND v(dout0_44) AT=410.025n

.meas tran vdout0_45ck810 FIND v(dout0_45) AT=410.025n

.meas tran vdout0_46ck810 FIND v(dout0_46) AT=410.025n

.meas tran vdout0_47ck810 FIND v(dout0_47) AT=410.025n

.meas tran vdout0_48ck810 FIND v(dout0_48) AT=410.025n

.meas tran vdout0_49ck810 FIND v(dout0_49) AT=410.025n

.meas tran vdout0_50ck810 FIND v(dout0_50) AT=410.025n

.meas tran vdout0_51ck810 FIND v(dout0_51) AT=410.025n

.meas tran vdout0_52ck810 FIND v(dout0_52) AT=410.025n

.meas tran vdout0_53ck810 FIND v(dout0_53) AT=410.025n

.meas tran vdout0_54ck810 FIND v(dout0_54) AT=410.025n

.meas tran vdout0_55ck810 FIND v(dout0_55) AT=410.025n

.meas tran vdout0_56ck810 FIND v(dout0_56) AT=410.025n

.meas tran vdout0_57ck810 FIND v(dout0_57) AT=410.025n

.meas tran vdout0_58ck810 FIND v(dout0_58) AT=410.025n

.meas tran vdout0_59ck810 FIND v(dout0_59) AT=410.025n

.meas tran vdout0_60ck810 FIND v(dout0_60) AT=410.025n

.meas tran vdout0_61ck810 FIND v(dout0_61) AT=410.025n

.meas tran vdout0_62ck810 FIND v(dout0_62) AT=410.025n

.meas tran vdout0_63ck810 FIND v(dout0_63) AT=410.025n

.meas tran vdout0_64ck810 FIND v(dout0_64) AT=410.025n

.meas tran vdout0_65ck810 FIND v(dout0_65) AT=410.025n

.meas tran vdout0_66ck810 FIND v(dout0_66) AT=410.025n

.meas tran vdout0_67ck810 FIND v(dout0_67) AT=410.025n

.meas tran vdout0_68ck810 FIND v(dout0_68) AT=410.025n

.meas tran vdout0_69ck810 FIND v(dout0_69) AT=410.025n

.meas tran vdout0_70ck810 FIND v(dout0_70) AT=410.025n

.meas tran vdout0_71ck810 FIND v(dout0_71) AT=410.025n

.meas tran vdout0_72ck810 FIND v(dout0_72) AT=410.025n

.meas tran vdout0_73ck810 FIND v(dout0_73) AT=410.025n

.meas tran vdout0_74ck810 FIND v(dout0_74) AT=410.025n

.meas tran vdout0_75ck810 FIND v(dout0_75) AT=410.025n

.meas tran vdout0_76ck810 FIND v(dout0_76) AT=410.025n

.meas tran vdout0_77ck810 FIND v(dout0_77) AT=410.025n

.meas tran vdout0_78ck810 FIND v(dout0_78) AT=410.025n

.meas tran vdout0_79ck810 FIND v(dout0_79) AT=410.025n

.meas tran vdout0_80ck810 FIND v(dout0_80) AT=410.025n

.meas tran vdout0_81ck810 FIND v(dout0_81) AT=410.025n

.meas tran vdout0_82ck810 FIND v(dout0_82) AT=410.025n

.meas tran vdout0_83ck810 FIND v(dout0_83) AT=410.025n

.meas tran vdout0_84ck810 FIND v(dout0_84) AT=410.025n

.meas tran vdout0_85ck810 FIND v(dout0_85) AT=410.025n

.meas tran vdout0_86ck810 FIND v(dout0_86) AT=410.025n

.meas tran vdout0_87ck810 FIND v(dout0_87) AT=410.025n

.meas tran vdout0_88ck810 FIND v(dout0_88) AT=410.025n

.meas tran vdout0_89ck810 FIND v(dout0_89) AT=410.025n

.meas tran vdout0_90ck810 FIND v(dout0_90) AT=410.025n

.meas tran vdout0_91ck810 FIND v(dout0_91) AT=410.025n

.meas tran vdout0_92ck810 FIND v(dout0_92) AT=410.025n

.meas tran vdout0_93ck810 FIND v(dout0_93) AT=410.025n

.meas tran vdout0_94ck810 FIND v(dout0_94) AT=410.025n

.meas tran vdout0_95ck810 FIND v(dout0_95) AT=410.025n

.meas tran vdout0_96ck810 FIND v(dout0_96) AT=410.025n

.meas tran vdout0_97ck810 FIND v(dout0_97) AT=410.025n

.meas tran vdout0_98ck810 FIND v(dout0_98) AT=410.025n

.meas tran vdout0_99ck810 FIND v(dout0_99) AT=410.025n

.meas tran vdout0_100ck810 FIND v(dout0_100) AT=410.025n

.meas tran vdout0_101ck810 FIND v(dout0_101) AT=410.025n

.meas tran vdout0_102ck810 FIND v(dout0_102) AT=410.025n

.meas tran vdout0_103ck810 FIND v(dout0_103) AT=410.025n

.meas tran vdout0_104ck810 FIND v(dout0_104) AT=410.025n

.meas tran vdout0_105ck810 FIND v(dout0_105) AT=410.025n

.meas tran vdout0_106ck810 FIND v(dout0_106) AT=410.025n

.meas tran vdout0_107ck810 FIND v(dout0_107) AT=410.025n

.meas tran vdout0_108ck810 FIND v(dout0_108) AT=410.025n

.meas tran vdout0_109ck810 FIND v(dout0_109) AT=410.025n

.meas tran vdout0_110ck810 FIND v(dout0_110) AT=410.025n

.meas tran vdout0_111ck810 FIND v(dout0_111) AT=410.025n

.meas tran vdout0_112ck810 FIND v(dout0_112) AT=410.025n

.meas tran vdout0_113ck810 FIND v(dout0_113) AT=410.025n

.meas tran vdout0_114ck810 FIND v(dout0_114) AT=410.025n

.meas tran vdout0_115ck810 FIND v(dout0_115) AT=410.025n

.meas tran vdout0_116ck810 FIND v(dout0_116) AT=410.025n

.meas tran vdout0_117ck810 FIND v(dout0_117) AT=410.025n

.meas tran vdout0_118ck810 FIND v(dout0_118) AT=410.025n

.meas tran vdout0_119ck810 FIND v(dout0_119) AT=410.025n

.meas tran vdout0_120ck810 FIND v(dout0_120) AT=410.025n

.meas tran vdout0_121ck810 FIND v(dout0_121) AT=410.025n

.meas tran vdout0_122ck810 FIND v(dout0_122) AT=410.025n

.meas tran vdout0_123ck810 FIND v(dout0_123) AT=410.025n

.meas tran vdout0_124ck810 FIND v(dout0_124) AT=410.025n

.meas tran vdout0_125ck810 FIND v(dout0_125) AT=410.025n

.meas tran vdout0_126ck810 FIND v(dout0_126) AT=410.025n

.meas tran vdout0_127ck810 FIND v(dout0_127) AT=410.025n

.meas tran vdout0_128ck810 FIND v(dout0_128) AT=410.025n

.meas tran vdout0_129ck810 FIND v(dout0_129) AT=410.025n

.meas tran vdout0_130ck810 FIND v(dout0_130) AT=410.025n

.meas tran vdout0_131ck810 FIND v(dout0_131) AT=410.025n

.meas tran vdout0_132ck810 FIND v(dout0_132) AT=410.025n

.meas tran vdout0_133ck810 FIND v(dout0_133) AT=410.025n

.meas tran vdout0_134ck810 FIND v(dout0_134) AT=410.025n

.meas tran vdout0_135ck810 FIND v(dout0_135) AT=410.025n

.meas tran vdout0_136ck810 FIND v(dout0_136) AT=410.025n

.meas tran vdout0_137ck810 FIND v(dout0_137) AT=410.025n

.meas tran vdout0_138ck810 FIND v(dout0_138) AT=410.025n

.meas tran vdout0_139ck810 FIND v(dout0_139) AT=410.025n

.meas tran vdout0_140ck810 FIND v(dout0_140) AT=410.025n

.meas tran vdout0_141ck810 FIND v(dout0_141) AT=410.025n

.meas tran vdout0_142ck810 FIND v(dout0_142) AT=410.025n

.meas tran vdout0_143ck810 FIND v(dout0_143) AT=410.025n

.meas tran vdout0_144ck810 FIND v(dout0_144) AT=410.025n

.meas tran vdout0_145ck810 FIND v(dout0_145) AT=410.025n

.meas tran vdout0_146ck810 FIND v(dout0_146) AT=410.025n

.meas tran vdout0_147ck810 FIND v(dout0_147) AT=410.025n

.meas tran vdout0_148ck810 FIND v(dout0_148) AT=410.025n

.meas tran vdout0_149ck810 FIND v(dout0_149) AT=410.025n

.meas tran vdout0_0ck840 FIND v(dout0_0) AT=425.025n

.meas tran vdout0_1ck840 FIND v(dout0_1) AT=425.025n

.meas tran vdout0_2ck840 FIND v(dout0_2) AT=425.025n

.meas tran vdout0_3ck840 FIND v(dout0_3) AT=425.025n

.meas tran vdout0_4ck840 FIND v(dout0_4) AT=425.025n

.meas tran vdout0_5ck840 FIND v(dout0_5) AT=425.025n

.meas tran vdout0_6ck840 FIND v(dout0_6) AT=425.025n

.meas tran vdout0_7ck840 FIND v(dout0_7) AT=425.025n

.meas tran vdout0_8ck840 FIND v(dout0_8) AT=425.025n

.meas tran vdout0_9ck840 FIND v(dout0_9) AT=425.025n

.meas tran vdout0_10ck840 FIND v(dout0_10) AT=425.025n

.meas tran vdout0_11ck840 FIND v(dout0_11) AT=425.025n

.meas tran vdout0_12ck840 FIND v(dout0_12) AT=425.025n

.meas tran vdout0_13ck840 FIND v(dout0_13) AT=425.025n

.meas tran vdout0_14ck840 FIND v(dout0_14) AT=425.025n

.meas tran vdout0_15ck840 FIND v(dout0_15) AT=425.025n

.meas tran vdout0_16ck840 FIND v(dout0_16) AT=425.025n

.meas tran vdout0_17ck840 FIND v(dout0_17) AT=425.025n

.meas tran vdout0_18ck840 FIND v(dout0_18) AT=425.025n

.meas tran vdout0_19ck840 FIND v(dout0_19) AT=425.025n

.meas tran vdout0_20ck840 FIND v(dout0_20) AT=425.025n

.meas tran vdout0_21ck840 FIND v(dout0_21) AT=425.025n

.meas tran vdout0_22ck840 FIND v(dout0_22) AT=425.025n

.meas tran vdout0_23ck840 FIND v(dout0_23) AT=425.025n

.meas tran vdout0_24ck840 FIND v(dout0_24) AT=425.025n

.meas tran vdout0_25ck840 FIND v(dout0_25) AT=425.025n

.meas tran vdout0_26ck840 FIND v(dout0_26) AT=425.025n

.meas tran vdout0_27ck840 FIND v(dout0_27) AT=425.025n

.meas tran vdout0_28ck840 FIND v(dout0_28) AT=425.025n

.meas tran vdout0_29ck840 FIND v(dout0_29) AT=425.025n

.meas tran vdout0_30ck840 FIND v(dout0_30) AT=425.025n

.meas tran vdout0_31ck840 FIND v(dout0_31) AT=425.025n

.meas tran vdout0_32ck840 FIND v(dout0_32) AT=425.025n

.meas tran vdout0_33ck840 FIND v(dout0_33) AT=425.025n

.meas tran vdout0_34ck840 FIND v(dout0_34) AT=425.025n

.meas tran vdout0_35ck840 FIND v(dout0_35) AT=425.025n

.meas tran vdout0_36ck840 FIND v(dout0_36) AT=425.025n

.meas tran vdout0_37ck840 FIND v(dout0_37) AT=425.025n

.meas tran vdout0_38ck840 FIND v(dout0_38) AT=425.025n

.meas tran vdout0_39ck840 FIND v(dout0_39) AT=425.025n

.meas tran vdout0_40ck840 FIND v(dout0_40) AT=425.025n

.meas tran vdout0_41ck840 FIND v(dout0_41) AT=425.025n

.meas tran vdout0_42ck840 FIND v(dout0_42) AT=425.025n

.meas tran vdout0_43ck840 FIND v(dout0_43) AT=425.025n

.meas tran vdout0_44ck840 FIND v(dout0_44) AT=425.025n

.meas tran vdout0_45ck840 FIND v(dout0_45) AT=425.025n

.meas tran vdout0_46ck840 FIND v(dout0_46) AT=425.025n

.meas tran vdout0_47ck840 FIND v(dout0_47) AT=425.025n

.meas tran vdout0_48ck840 FIND v(dout0_48) AT=425.025n

.meas tran vdout0_49ck840 FIND v(dout0_49) AT=425.025n

.meas tran vdout0_50ck840 FIND v(dout0_50) AT=425.025n

.meas tran vdout0_51ck840 FIND v(dout0_51) AT=425.025n

.meas tran vdout0_52ck840 FIND v(dout0_52) AT=425.025n

.meas tran vdout0_53ck840 FIND v(dout0_53) AT=425.025n

.meas tran vdout0_54ck840 FIND v(dout0_54) AT=425.025n

.meas tran vdout0_55ck840 FIND v(dout0_55) AT=425.025n

.meas tran vdout0_56ck840 FIND v(dout0_56) AT=425.025n

.meas tran vdout0_57ck840 FIND v(dout0_57) AT=425.025n

.meas tran vdout0_58ck840 FIND v(dout0_58) AT=425.025n

.meas tran vdout0_59ck840 FIND v(dout0_59) AT=425.025n

.meas tran vdout0_60ck840 FIND v(dout0_60) AT=425.025n

.meas tran vdout0_61ck840 FIND v(dout0_61) AT=425.025n

.meas tran vdout0_62ck840 FIND v(dout0_62) AT=425.025n

.meas tran vdout0_63ck840 FIND v(dout0_63) AT=425.025n

.meas tran vdout0_64ck840 FIND v(dout0_64) AT=425.025n

.meas tran vdout0_65ck840 FIND v(dout0_65) AT=425.025n

.meas tran vdout0_66ck840 FIND v(dout0_66) AT=425.025n

.meas tran vdout0_67ck840 FIND v(dout0_67) AT=425.025n

.meas tran vdout0_68ck840 FIND v(dout0_68) AT=425.025n

.meas tran vdout0_69ck840 FIND v(dout0_69) AT=425.025n

.meas tran vdout0_70ck840 FIND v(dout0_70) AT=425.025n

.meas tran vdout0_71ck840 FIND v(dout0_71) AT=425.025n

.meas tran vdout0_72ck840 FIND v(dout0_72) AT=425.025n

.meas tran vdout0_73ck840 FIND v(dout0_73) AT=425.025n

.meas tran vdout0_74ck840 FIND v(dout0_74) AT=425.025n

.meas tran vdout0_75ck840 FIND v(dout0_75) AT=425.025n

.meas tran vdout0_76ck840 FIND v(dout0_76) AT=425.025n

.meas tran vdout0_77ck840 FIND v(dout0_77) AT=425.025n

.meas tran vdout0_78ck840 FIND v(dout0_78) AT=425.025n

.meas tran vdout0_79ck840 FIND v(dout0_79) AT=425.025n

.meas tran vdout0_80ck840 FIND v(dout0_80) AT=425.025n

.meas tran vdout0_81ck840 FIND v(dout0_81) AT=425.025n

.meas tran vdout0_82ck840 FIND v(dout0_82) AT=425.025n

.meas tran vdout0_83ck840 FIND v(dout0_83) AT=425.025n

.meas tran vdout0_84ck840 FIND v(dout0_84) AT=425.025n

.meas tran vdout0_85ck840 FIND v(dout0_85) AT=425.025n

.meas tran vdout0_86ck840 FIND v(dout0_86) AT=425.025n

.meas tran vdout0_87ck840 FIND v(dout0_87) AT=425.025n

.meas tran vdout0_88ck840 FIND v(dout0_88) AT=425.025n

.meas tran vdout0_89ck840 FIND v(dout0_89) AT=425.025n

.meas tran vdout0_90ck840 FIND v(dout0_90) AT=425.025n

.meas tran vdout0_91ck840 FIND v(dout0_91) AT=425.025n

.meas tran vdout0_92ck840 FIND v(dout0_92) AT=425.025n

.meas tran vdout0_93ck840 FIND v(dout0_93) AT=425.025n

.meas tran vdout0_94ck840 FIND v(dout0_94) AT=425.025n

.meas tran vdout0_95ck840 FIND v(dout0_95) AT=425.025n

.meas tran vdout0_96ck840 FIND v(dout0_96) AT=425.025n

.meas tran vdout0_97ck840 FIND v(dout0_97) AT=425.025n

.meas tran vdout0_98ck840 FIND v(dout0_98) AT=425.025n

.meas tran vdout0_99ck840 FIND v(dout0_99) AT=425.025n

.meas tran vdout0_100ck840 FIND v(dout0_100) AT=425.025n

.meas tran vdout0_101ck840 FIND v(dout0_101) AT=425.025n

.meas tran vdout0_102ck840 FIND v(dout0_102) AT=425.025n

.meas tran vdout0_103ck840 FIND v(dout0_103) AT=425.025n

.meas tran vdout0_104ck840 FIND v(dout0_104) AT=425.025n

.meas tran vdout0_105ck840 FIND v(dout0_105) AT=425.025n

.meas tran vdout0_106ck840 FIND v(dout0_106) AT=425.025n

.meas tran vdout0_107ck840 FIND v(dout0_107) AT=425.025n

.meas tran vdout0_108ck840 FIND v(dout0_108) AT=425.025n

.meas tran vdout0_109ck840 FIND v(dout0_109) AT=425.025n

.meas tran vdout0_110ck840 FIND v(dout0_110) AT=425.025n

.meas tran vdout0_111ck840 FIND v(dout0_111) AT=425.025n

.meas tran vdout0_112ck840 FIND v(dout0_112) AT=425.025n

.meas tran vdout0_113ck840 FIND v(dout0_113) AT=425.025n

.meas tran vdout0_114ck840 FIND v(dout0_114) AT=425.025n

.meas tran vdout0_115ck840 FIND v(dout0_115) AT=425.025n

.meas tran vdout0_116ck840 FIND v(dout0_116) AT=425.025n

.meas tran vdout0_117ck840 FIND v(dout0_117) AT=425.025n

.meas tran vdout0_118ck840 FIND v(dout0_118) AT=425.025n

.meas tran vdout0_119ck840 FIND v(dout0_119) AT=425.025n

.meas tran vdout0_120ck840 FIND v(dout0_120) AT=425.025n

.meas tran vdout0_121ck840 FIND v(dout0_121) AT=425.025n

.meas tran vdout0_122ck840 FIND v(dout0_122) AT=425.025n

.meas tran vdout0_123ck840 FIND v(dout0_123) AT=425.025n

.meas tran vdout0_124ck840 FIND v(dout0_124) AT=425.025n

.meas tran vdout0_125ck840 FIND v(dout0_125) AT=425.025n

.meas tran vdout0_126ck840 FIND v(dout0_126) AT=425.025n

.meas tran vdout0_127ck840 FIND v(dout0_127) AT=425.025n

.meas tran vdout0_128ck840 FIND v(dout0_128) AT=425.025n

.meas tran vdout0_129ck840 FIND v(dout0_129) AT=425.025n

.meas tran vdout0_130ck840 FIND v(dout0_130) AT=425.025n

.meas tran vdout0_131ck840 FIND v(dout0_131) AT=425.025n

.meas tran vdout0_132ck840 FIND v(dout0_132) AT=425.025n

.meas tran vdout0_133ck840 FIND v(dout0_133) AT=425.025n

.meas tran vdout0_134ck840 FIND v(dout0_134) AT=425.025n

.meas tran vdout0_135ck840 FIND v(dout0_135) AT=425.025n

.meas tran vdout0_136ck840 FIND v(dout0_136) AT=425.025n

.meas tran vdout0_137ck840 FIND v(dout0_137) AT=425.025n

.meas tran vdout0_138ck840 FIND v(dout0_138) AT=425.025n

.meas tran vdout0_139ck840 FIND v(dout0_139) AT=425.025n

.meas tran vdout0_140ck840 FIND v(dout0_140) AT=425.025n

.meas tran vdout0_141ck840 FIND v(dout0_141) AT=425.025n

.meas tran vdout0_142ck840 FIND v(dout0_142) AT=425.025n

.meas tran vdout0_143ck840 FIND v(dout0_143) AT=425.025n

.meas tran vdout0_144ck840 FIND v(dout0_144) AT=425.025n

.meas tran vdout0_145ck840 FIND v(dout0_145) AT=425.025n

.meas tran vdout0_146ck840 FIND v(dout0_146) AT=425.025n

.meas tran vdout0_147ck840 FIND v(dout0_147) AT=425.025n

.meas tran vdout0_148ck840 FIND v(dout0_148) AT=425.025n

.meas tran vdout0_149ck840 FIND v(dout0_149) AT=425.025n

.meas tran vdout0_0ck880 FIND v(dout0_0) AT=445.025n

.meas tran vdout0_1ck880 FIND v(dout0_1) AT=445.025n

.meas tran vdout0_2ck880 FIND v(dout0_2) AT=445.025n

.meas tran vdout0_3ck880 FIND v(dout0_3) AT=445.025n

.meas tran vdout0_4ck880 FIND v(dout0_4) AT=445.025n

.meas tran vdout0_5ck880 FIND v(dout0_5) AT=445.025n

.meas tran vdout0_6ck880 FIND v(dout0_6) AT=445.025n

.meas tran vdout0_7ck880 FIND v(dout0_7) AT=445.025n

.meas tran vdout0_8ck880 FIND v(dout0_8) AT=445.025n

.meas tran vdout0_9ck880 FIND v(dout0_9) AT=445.025n

.meas tran vdout0_10ck880 FIND v(dout0_10) AT=445.025n

.meas tran vdout0_11ck880 FIND v(dout0_11) AT=445.025n

.meas tran vdout0_12ck880 FIND v(dout0_12) AT=445.025n

.meas tran vdout0_13ck880 FIND v(dout0_13) AT=445.025n

.meas tran vdout0_14ck880 FIND v(dout0_14) AT=445.025n

.meas tran vdout0_15ck880 FIND v(dout0_15) AT=445.025n

.meas tran vdout0_16ck880 FIND v(dout0_16) AT=445.025n

.meas tran vdout0_17ck880 FIND v(dout0_17) AT=445.025n

.meas tran vdout0_18ck880 FIND v(dout0_18) AT=445.025n

.meas tran vdout0_19ck880 FIND v(dout0_19) AT=445.025n

.meas tran vdout0_20ck880 FIND v(dout0_20) AT=445.025n

.meas tran vdout0_21ck880 FIND v(dout0_21) AT=445.025n

.meas tran vdout0_22ck880 FIND v(dout0_22) AT=445.025n

.meas tran vdout0_23ck880 FIND v(dout0_23) AT=445.025n

.meas tran vdout0_24ck880 FIND v(dout0_24) AT=445.025n

.meas tran vdout0_25ck880 FIND v(dout0_25) AT=445.025n

.meas tran vdout0_26ck880 FIND v(dout0_26) AT=445.025n

.meas tran vdout0_27ck880 FIND v(dout0_27) AT=445.025n

.meas tran vdout0_28ck880 FIND v(dout0_28) AT=445.025n

.meas tran vdout0_29ck880 FIND v(dout0_29) AT=445.025n

.meas tran vdout0_30ck880 FIND v(dout0_30) AT=445.025n

.meas tran vdout0_31ck880 FIND v(dout0_31) AT=445.025n

.meas tran vdout0_32ck880 FIND v(dout0_32) AT=445.025n

.meas tran vdout0_33ck880 FIND v(dout0_33) AT=445.025n

.meas tran vdout0_34ck880 FIND v(dout0_34) AT=445.025n

.meas tran vdout0_35ck880 FIND v(dout0_35) AT=445.025n

.meas tran vdout0_36ck880 FIND v(dout0_36) AT=445.025n

.meas tran vdout0_37ck880 FIND v(dout0_37) AT=445.025n

.meas tran vdout0_38ck880 FIND v(dout0_38) AT=445.025n

.meas tran vdout0_39ck880 FIND v(dout0_39) AT=445.025n

.meas tran vdout0_40ck880 FIND v(dout0_40) AT=445.025n

.meas tran vdout0_41ck880 FIND v(dout0_41) AT=445.025n

.meas tran vdout0_42ck880 FIND v(dout0_42) AT=445.025n

.meas tran vdout0_43ck880 FIND v(dout0_43) AT=445.025n

.meas tran vdout0_44ck880 FIND v(dout0_44) AT=445.025n

.meas tran vdout0_45ck880 FIND v(dout0_45) AT=445.025n

.meas tran vdout0_46ck880 FIND v(dout0_46) AT=445.025n

.meas tran vdout0_47ck880 FIND v(dout0_47) AT=445.025n

.meas tran vdout0_48ck880 FIND v(dout0_48) AT=445.025n

.meas tran vdout0_49ck880 FIND v(dout0_49) AT=445.025n

.meas tran vdout0_50ck880 FIND v(dout0_50) AT=445.025n

.meas tran vdout0_51ck880 FIND v(dout0_51) AT=445.025n

.meas tran vdout0_52ck880 FIND v(dout0_52) AT=445.025n

.meas tran vdout0_53ck880 FIND v(dout0_53) AT=445.025n

.meas tran vdout0_54ck880 FIND v(dout0_54) AT=445.025n

.meas tran vdout0_55ck880 FIND v(dout0_55) AT=445.025n

.meas tran vdout0_56ck880 FIND v(dout0_56) AT=445.025n

.meas tran vdout0_57ck880 FIND v(dout0_57) AT=445.025n

.meas tran vdout0_58ck880 FIND v(dout0_58) AT=445.025n

.meas tran vdout0_59ck880 FIND v(dout0_59) AT=445.025n

.meas tran vdout0_60ck880 FIND v(dout0_60) AT=445.025n

.meas tran vdout0_61ck880 FIND v(dout0_61) AT=445.025n

.meas tran vdout0_62ck880 FIND v(dout0_62) AT=445.025n

.meas tran vdout0_63ck880 FIND v(dout0_63) AT=445.025n

.meas tran vdout0_64ck880 FIND v(dout0_64) AT=445.025n

.meas tran vdout0_65ck880 FIND v(dout0_65) AT=445.025n

.meas tran vdout0_66ck880 FIND v(dout0_66) AT=445.025n

.meas tran vdout0_67ck880 FIND v(dout0_67) AT=445.025n

.meas tran vdout0_68ck880 FIND v(dout0_68) AT=445.025n

.meas tran vdout0_69ck880 FIND v(dout0_69) AT=445.025n

.meas tran vdout0_70ck880 FIND v(dout0_70) AT=445.025n

.meas tran vdout0_71ck880 FIND v(dout0_71) AT=445.025n

.meas tran vdout0_72ck880 FIND v(dout0_72) AT=445.025n

.meas tran vdout0_73ck880 FIND v(dout0_73) AT=445.025n

.meas tran vdout0_74ck880 FIND v(dout0_74) AT=445.025n

.meas tran vdout0_75ck880 FIND v(dout0_75) AT=445.025n

.meas tran vdout0_76ck880 FIND v(dout0_76) AT=445.025n

.meas tran vdout0_77ck880 FIND v(dout0_77) AT=445.025n

.meas tran vdout0_78ck880 FIND v(dout0_78) AT=445.025n

.meas tran vdout0_79ck880 FIND v(dout0_79) AT=445.025n

.meas tran vdout0_80ck880 FIND v(dout0_80) AT=445.025n

.meas tran vdout0_81ck880 FIND v(dout0_81) AT=445.025n

.meas tran vdout0_82ck880 FIND v(dout0_82) AT=445.025n

.meas tran vdout0_83ck880 FIND v(dout0_83) AT=445.025n

.meas tran vdout0_84ck880 FIND v(dout0_84) AT=445.025n

.meas tran vdout0_85ck880 FIND v(dout0_85) AT=445.025n

.meas tran vdout0_86ck880 FIND v(dout0_86) AT=445.025n

.meas tran vdout0_87ck880 FIND v(dout0_87) AT=445.025n

.meas tran vdout0_88ck880 FIND v(dout0_88) AT=445.025n

.meas tran vdout0_89ck880 FIND v(dout0_89) AT=445.025n

.meas tran vdout0_90ck880 FIND v(dout0_90) AT=445.025n

.meas tran vdout0_91ck880 FIND v(dout0_91) AT=445.025n

.meas tran vdout0_92ck880 FIND v(dout0_92) AT=445.025n

.meas tran vdout0_93ck880 FIND v(dout0_93) AT=445.025n

.meas tran vdout0_94ck880 FIND v(dout0_94) AT=445.025n

.meas tran vdout0_95ck880 FIND v(dout0_95) AT=445.025n

.meas tran vdout0_96ck880 FIND v(dout0_96) AT=445.025n

.meas tran vdout0_97ck880 FIND v(dout0_97) AT=445.025n

.meas tran vdout0_98ck880 FIND v(dout0_98) AT=445.025n

.meas tran vdout0_99ck880 FIND v(dout0_99) AT=445.025n

.meas tran vdout0_100ck880 FIND v(dout0_100) AT=445.025n

.meas tran vdout0_101ck880 FIND v(dout0_101) AT=445.025n

.meas tran vdout0_102ck880 FIND v(dout0_102) AT=445.025n

.meas tran vdout0_103ck880 FIND v(dout0_103) AT=445.025n

.meas tran vdout0_104ck880 FIND v(dout0_104) AT=445.025n

.meas tran vdout0_105ck880 FIND v(dout0_105) AT=445.025n

.meas tran vdout0_106ck880 FIND v(dout0_106) AT=445.025n

.meas tran vdout0_107ck880 FIND v(dout0_107) AT=445.025n

.meas tran vdout0_108ck880 FIND v(dout0_108) AT=445.025n

.meas tran vdout0_109ck880 FIND v(dout0_109) AT=445.025n

.meas tran vdout0_110ck880 FIND v(dout0_110) AT=445.025n

.meas tran vdout0_111ck880 FIND v(dout0_111) AT=445.025n

.meas tran vdout0_112ck880 FIND v(dout0_112) AT=445.025n

.meas tran vdout0_113ck880 FIND v(dout0_113) AT=445.025n

.meas tran vdout0_114ck880 FIND v(dout0_114) AT=445.025n

.meas tran vdout0_115ck880 FIND v(dout0_115) AT=445.025n

.meas tran vdout0_116ck880 FIND v(dout0_116) AT=445.025n

.meas tran vdout0_117ck880 FIND v(dout0_117) AT=445.025n

.meas tran vdout0_118ck880 FIND v(dout0_118) AT=445.025n

.meas tran vdout0_119ck880 FIND v(dout0_119) AT=445.025n

.meas tran vdout0_120ck880 FIND v(dout0_120) AT=445.025n

.meas tran vdout0_121ck880 FIND v(dout0_121) AT=445.025n

.meas tran vdout0_122ck880 FIND v(dout0_122) AT=445.025n

.meas tran vdout0_123ck880 FIND v(dout0_123) AT=445.025n

.meas tran vdout0_124ck880 FIND v(dout0_124) AT=445.025n

.meas tran vdout0_125ck880 FIND v(dout0_125) AT=445.025n

.meas tran vdout0_126ck880 FIND v(dout0_126) AT=445.025n

.meas tran vdout0_127ck880 FIND v(dout0_127) AT=445.025n

.meas tran vdout0_128ck880 FIND v(dout0_128) AT=445.025n

.meas tran vdout0_129ck880 FIND v(dout0_129) AT=445.025n

.meas tran vdout0_130ck880 FIND v(dout0_130) AT=445.025n

.meas tran vdout0_131ck880 FIND v(dout0_131) AT=445.025n

.meas tran vdout0_132ck880 FIND v(dout0_132) AT=445.025n

.meas tran vdout0_133ck880 FIND v(dout0_133) AT=445.025n

.meas tran vdout0_134ck880 FIND v(dout0_134) AT=445.025n

.meas tran vdout0_135ck880 FIND v(dout0_135) AT=445.025n

.meas tran vdout0_136ck880 FIND v(dout0_136) AT=445.025n

.meas tran vdout0_137ck880 FIND v(dout0_137) AT=445.025n

.meas tran vdout0_138ck880 FIND v(dout0_138) AT=445.025n

.meas tran vdout0_139ck880 FIND v(dout0_139) AT=445.025n

.meas tran vdout0_140ck880 FIND v(dout0_140) AT=445.025n

.meas tran vdout0_141ck880 FIND v(dout0_141) AT=445.025n

.meas tran vdout0_142ck880 FIND v(dout0_142) AT=445.025n

.meas tran vdout0_143ck880 FIND v(dout0_143) AT=445.025n

.meas tran vdout0_144ck880 FIND v(dout0_144) AT=445.025n

.meas tran vdout0_145ck880 FIND v(dout0_145) AT=445.025n

.meas tran vdout0_146ck880 FIND v(dout0_146) AT=445.025n

.meas tran vdout0_147ck880 FIND v(dout0_147) AT=445.025n

.meas tran vdout0_148ck880 FIND v(dout0_148) AT=445.025n

.meas tran vdout0_149ck880 FIND v(dout0_149) AT=445.025n

.meas tran vdout0_0ck920 FIND v(dout0_0) AT=465.025n

.meas tran vdout0_1ck920 FIND v(dout0_1) AT=465.025n

.meas tran vdout0_2ck920 FIND v(dout0_2) AT=465.025n

.meas tran vdout0_3ck920 FIND v(dout0_3) AT=465.025n

.meas tran vdout0_4ck920 FIND v(dout0_4) AT=465.025n

.meas tran vdout0_5ck920 FIND v(dout0_5) AT=465.025n

.meas tran vdout0_6ck920 FIND v(dout0_6) AT=465.025n

.meas tran vdout0_7ck920 FIND v(dout0_7) AT=465.025n

.meas tran vdout0_8ck920 FIND v(dout0_8) AT=465.025n

.meas tran vdout0_9ck920 FIND v(dout0_9) AT=465.025n

.meas tran vdout0_10ck920 FIND v(dout0_10) AT=465.025n

.meas tran vdout0_11ck920 FIND v(dout0_11) AT=465.025n

.meas tran vdout0_12ck920 FIND v(dout0_12) AT=465.025n

.meas tran vdout0_13ck920 FIND v(dout0_13) AT=465.025n

.meas tran vdout0_14ck920 FIND v(dout0_14) AT=465.025n

.meas tran vdout0_15ck920 FIND v(dout0_15) AT=465.025n

.meas tran vdout0_16ck920 FIND v(dout0_16) AT=465.025n

.meas tran vdout0_17ck920 FIND v(dout0_17) AT=465.025n

.meas tran vdout0_18ck920 FIND v(dout0_18) AT=465.025n

.meas tran vdout0_19ck920 FIND v(dout0_19) AT=465.025n

.meas tran vdout0_20ck920 FIND v(dout0_20) AT=465.025n

.meas tran vdout0_21ck920 FIND v(dout0_21) AT=465.025n

.meas tran vdout0_22ck920 FIND v(dout0_22) AT=465.025n

.meas tran vdout0_23ck920 FIND v(dout0_23) AT=465.025n

.meas tran vdout0_24ck920 FIND v(dout0_24) AT=465.025n

.meas tran vdout0_25ck920 FIND v(dout0_25) AT=465.025n

.meas tran vdout0_26ck920 FIND v(dout0_26) AT=465.025n

.meas tran vdout0_27ck920 FIND v(dout0_27) AT=465.025n

.meas tran vdout0_28ck920 FIND v(dout0_28) AT=465.025n

.meas tran vdout0_29ck920 FIND v(dout0_29) AT=465.025n

.meas tran vdout0_30ck920 FIND v(dout0_30) AT=465.025n

.meas tran vdout0_31ck920 FIND v(dout0_31) AT=465.025n

.meas tran vdout0_32ck920 FIND v(dout0_32) AT=465.025n

.meas tran vdout0_33ck920 FIND v(dout0_33) AT=465.025n

.meas tran vdout0_34ck920 FIND v(dout0_34) AT=465.025n

.meas tran vdout0_35ck920 FIND v(dout0_35) AT=465.025n

.meas tran vdout0_36ck920 FIND v(dout0_36) AT=465.025n

.meas tran vdout0_37ck920 FIND v(dout0_37) AT=465.025n

.meas tran vdout0_38ck920 FIND v(dout0_38) AT=465.025n

.meas tran vdout0_39ck920 FIND v(dout0_39) AT=465.025n

.meas tran vdout0_40ck920 FIND v(dout0_40) AT=465.025n

.meas tran vdout0_41ck920 FIND v(dout0_41) AT=465.025n

.meas tran vdout0_42ck920 FIND v(dout0_42) AT=465.025n

.meas tran vdout0_43ck920 FIND v(dout0_43) AT=465.025n

.meas tran vdout0_44ck920 FIND v(dout0_44) AT=465.025n

.meas tran vdout0_45ck920 FIND v(dout0_45) AT=465.025n

.meas tran vdout0_46ck920 FIND v(dout0_46) AT=465.025n

.meas tran vdout0_47ck920 FIND v(dout0_47) AT=465.025n

.meas tran vdout0_48ck920 FIND v(dout0_48) AT=465.025n

.meas tran vdout0_49ck920 FIND v(dout0_49) AT=465.025n

.meas tran vdout0_50ck920 FIND v(dout0_50) AT=465.025n

.meas tran vdout0_51ck920 FIND v(dout0_51) AT=465.025n

.meas tran vdout0_52ck920 FIND v(dout0_52) AT=465.025n

.meas tran vdout0_53ck920 FIND v(dout0_53) AT=465.025n

.meas tran vdout0_54ck920 FIND v(dout0_54) AT=465.025n

.meas tran vdout0_55ck920 FIND v(dout0_55) AT=465.025n

.meas tran vdout0_56ck920 FIND v(dout0_56) AT=465.025n

.meas tran vdout0_57ck920 FIND v(dout0_57) AT=465.025n

.meas tran vdout0_58ck920 FIND v(dout0_58) AT=465.025n

.meas tran vdout0_59ck920 FIND v(dout0_59) AT=465.025n

.meas tran vdout0_60ck920 FIND v(dout0_60) AT=465.025n

.meas tran vdout0_61ck920 FIND v(dout0_61) AT=465.025n

.meas tran vdout0_62ck920 FIND v(dout0_62) AT=465.025n

.meas tran vdout0_63ck920 FIND v(dout0_63) AT=465.025n

.meas tran vdout0_64ck920 FIND v(dout0_64) AT=465.025n

.meas tran vdout0_65ck920 FIND v(dout0_65) AT=465.025n

.meas tran vdout0_66ck920 FIND v(dout0_66) AT=465.025n

.meas tran vdout0_67ck920 FIND v(dout0_67) AT=465.025n

.meas tran vdout0_68ck920 FIND v(dout0_68) AT=465.025n

.meas tran vdout0_69ck920 FIND v(dout0_69) AT=465.025n

.meas tran vdout0_70ck920 FIND v(dout0_70) AT=465.025n

.meas tran vdout0_71ck920 FIND v(dout0_71) AT=465.025n

.meas tran vdout0_72ck920 FIND v(dout0_72) AT=465.025n

.meas tran vdout0_73ck920 FIND v(dout0_73) AT=465.025n

.meas tran vdout0_74ck920 FIND v(dout0_74) AT=465.025n

.meas tran vdout0_75ck920 FIND v(dout0_75) AT=465.025n

.meas tran vdout0_76ck920 FIND v(dout0_76) AT=465.025n

.meas tran vdout0_77ck920 FIND v(dout0_77) AT=465.025n

.meas tran vdout0_78ck920 FIND v(dout0_78) AT=465.025n

.meas tran vdout0_79ck920 FIND v(dout0_79) AT=465.025n

.meas tran vdout0_80ck920 FIND v(dout0_80) AT=465.025n

.meas tran vdout0_81ck920 FIND v(dout0_81) AT=465.025n

.meas tran vdout0_82ck920 FIND v(dout0_82) AT=465.025n

.meas tran vdout0_83ck920 FIND v(dout0_83) AT=465.025n

.meas tran vdout0_84ck920 FIND v(dout0_84) AT=465.025n

.meas tran vdout0_85ck920 FIND v(dout0_85) AT=465.025n

.meas tran vdout0_86ck920 FIND v(dout0_86) AT=465.025n

.meas tran vdout0_87ck920 FIND v(dout0_87) AT=465.025n

.meas tran vdout0_88ck920 FIND v(dout0_88) AT=465.025n

.meas tran vdout0_89ck920 FIND v(dout0_89) AT=465.025n

.meas tran vdout0_90ck920 FIND v(dout0_90) AT=465.025n

.meas tran vdout0_91ck920 FIND v(dout0_91) AT=465.025n

.meas tran vdout0_92ck920 FIND v(dout0_92) AT=465.025n

.meas tran vdout0_93ck920 FIND v(dout0_93) AT=465.025n

.meas tran vdout0_94ck920 FIND v(dout0_94) AT=465.025n

.meas tran vdout0_95ck920 FIND v(dout0_95) AT=465.025n

.meas tran vdout0_96ck920 FIND v(dout0_96) AT=465.025n

.meas tran vdout0_97ck920 FIND v(dout0_97) AT=465.025n

.meas tran vdout0_98ck920 FIND v(dout0_98) AT=465.025n

.meas tran vdout0_99ck920 FIND v(dout0_99) AT=465.025n

.meas tran vdout0_100ck920 FIND v(dout0_100) AT=465.025n

.meas tran vdout0_101ck920 FIND v(dout0_101) AT=465.025n

.meas tran vdout0_102ck920 FIND v(dout0_102) AT=465.025n

.meas tran vdout0_103ck920 FIND v(dout0_103) AT=465.025n

.meas tran vdout0_104ck920 FIND v(dout0_104) AT=465.025n

.meas tran vdout0_105ck920 FIND v(dout0_105) AT=465.025n

.meas tran vdout0_106ck920 FIND v(dout0_106) AT=465.025n

.meas tran vdout0_107ck920 FIND v(dout0_107) AT=465.025n

.meas tran vdout0_108ck920 FIND v(dout0_108) AT=465.025n

.meas tran vdout0_109ck920 FIND v(dout0_109) AT=465.025n

.meas tran vdout0_110ck920 FIND v(dout0_110) AT=465.025n

.meas tran vdout0_111ck920 FIND v(dout0_111) AT=465.025n

.meas tran vdout0_112ck920 FIND v(dout0_112) AT=465.025n

.meas tran vdout0_113ck920 FIND v(dout0_113) AT=465.025n

.meas tran vdout0_114ck920 FIND v(dout0_114) AT=465.025n

.meas tran vdout0_115ck920 FIND v(dout0_115) AT=465.025n

.meas tran vdout0_116ck920 FIND v(dout0_116) AT=465.025n

.meas tran vdout0_117ck920 FIND v(dout0_117) AT=465.025n

.meas tran vdout0_118ck920 FIND v(dout0_118) AT=465.025n

.meas tran vdout0_119ck920 FIND v(dout0_119) AT=465.025n

.meas tran vdout0_120ck920 FIND v(dout0_120) AT=465.025n

.meas tran vdout0_121ck920 FIND v(dout0_121) AT=465.025n

.meas tran vdout0_122ck920 FIND v(dout0_122) AT=465.025n

.meas tran vdout0_123ck920 FIND v(dout0_123) AT=465.025n

.meas tran vdout0_124ck920 FIND v(dout0_124) AT=465.025n

.meas tran vdout0_125ck920 FIND v(dout0_125) AT=465.025n

.meas tran vdout0_126ck920 FIND v(dout0_126) AT=465.025n

.meas tran vdout0_127ck920 FIND v(dout0_127) AT=465.025n

.meas tran vdout0_128ck920 FIND v(dout0_128) AT=465.025n

.meas tran vdout0_129ck920 FIND v(dout0_129) AT=465.025n

.meas tran vdout0_130ck920 FIND v(dout0_130) AT=465.025n

.meas tran vdout0_131ck920 FIND v(dout0_131) AT=465.025n

.meas tran vdout0_132ck920 FIND v(dout0_132) AT=465.025n

.meas tran vdout0_133ck920 FIND v(dout0_133) AT=465.025n

.meas tran vdout0_134ck920 FIND v(dout0_134) AT=465.025n

.meas tran vdout0_135ck920 FIND v(dout0_135) AT=465.025n

.meas tran vdout0_136ck920 FIND v(dout0_136) AT=465.025n

.meas tran vdout0_137ck920 FIND v(dout0_137) AT=465.025n

.meas tran vdout0_138ck920 FIND v(dout0_138) AT=465.025n

.meas tran vdout0_139ck920 FIND v(dout0_139) AT=465.025n

.meas tran vdout0_140ck920 FIND v(dout0_140) AT=465.025n

.meas tran vdout0_141ck920 FIND v(dout0_141) AT=465.025n

.meas tran vdout0_142ck920 FIND v(dout0_142) AT=465.025n

.meas tran vdout0_143ck920 FIND v(dout0_143) AT=465.025n

.meas tran vdout0_144ck920 FIND v(dout0_144) AT=465.025n

.meas tran vdout0_145ck920 FIND v(dout0_145) AT=465.025n

.meas tran vdout0_146ck920 FIND v(dout0_146) AT=465.025n

.meas tran vdout0_147ck920 FIND v(dout0_147) AT=465.025n

.meas tran vdout0_148ck920 FIND v(dout0_148) AT=465.025n

.meas tran vdout0_149ck920 FIND v(dout0_149) AT=465.025n

.meas tran vdout0_0ck940 FIND v(dout0_0) AT=475.025n

.meas tran vdout0_1ck940 FIND v(dout0_1) AT=475.025n

.meas tran vdout0_2ck940 FIND v(dout0_2) AT=475.025n

.meas tran vdout0_3ck940 FIND v(dout0_3) AT=475.025n

.meas tran vdout0_4ck940 FIND v(dout0_4) AT=475.025n

.meas tran vdout0_5ck940 FIND v(dout0_5) AT=475.025n

.meas tran vdout0_6ck940 FIND v(dout0_6) AT=475.025n

.meas tran vdout0_7ck940 FIND v(dout0_7) AT=475.025n

.meas tran vdout0_8ck940 FIND v(dout0_8) AT=475.025n

.meas tran vdout0_9ck940 FIND v(dout0_9) AT=475.025n

.meas tran vdout0_10ck940 FIND v(dout0_10) AT=475.025n

.meas tran vdout0_11ck940 FIND v(dout0_11) AT=475.025n

.meas tran vdout0_12ck940 FIND v(dout0_12) AT=475.025n

.meas tran vdout0_13ck940 FIND v(dout0_13) AT=475.025n

.meas tran vdout0_14ck940 FIND v(dout0_14) AT=475.025n

.meas tran vdout0_15ck940 FIND v(dout0_15) AT=475.025n

.meas tran vdout0_16ck940 FIND v(dout0_16) AT=475.025n

.meas tran vdout0_17ck940 FIND v(dout0_17) AT=475.025n

.meas tran vdout0_18ck940 FIND v(dout0_18) AT=475.025n

.meas tran vdout0_19ck940 FIND v(dout0_19) AT=475.025n

.meas tran vdout0_20ck940 FIND v(dout0_20) AT=475.025n

.meas tran vdout0_21ck940 FIND v(dout0_21) AT=475.025n

.meas tran vdout0_22ck940 FIND v(dout0_22) AT=475.025n

.meas tran vdout0_23ck940 FIND v(dout0_23) AT=475.025n

.meas tran vdout0_24ck940 FIND v(dout0_24) AT=475.025n

.meas tran vdout0_25ck940 FIND v(dout0_25) AT=475.025n

.meas tran vdout0_26ck940 FIND v(dout0_26) AT=475.025n

.meas tran vdout0_27ck940 FIND v(dout0_27) AT=475.025n

.meas tran vdout0_28ck940 FIND v(dout0_28) AT=475.025n

.meas tran vdout0_29ck940 FIND v(dout0_29) AT=475.025n

.meas tran vdout0_30ck940 FIND v(dout0_30) AT=475.025n

.meas tran vdout0_31ck940 FIND v(dout0_31) AT=475.025n

.meas tran vdout0_32ck940 FIND v(dout0_32) AT=475.025n

.meas tran vdout0_33ck940 FIND v(dout0_33) AT=475.025n

.meas tran vdout0_34ck940 FIND v(dout0_34) AT=475.025n

.meas tran vdout0_35ck940 FIND v(dout0_35) AT=475.025n

.meas tran vdout0_36ck940 FIND v(dout0_36) AT=475.025n

.meas tran vdout0_37ck940 FIND v(dout0_37) AT=475.025n

.meas tran vdout0_38ck940 FIND v(dout0_38) AT=475.025n

.meas tran vdout0_39ck940 FIND v(dout0_39) AT=475.025n

.meas tran vdout0_40ck940 FIND v(dout0_40) AT=475.025n

.meas tran vdout0_41ck940 FIND v(dout0_41) AT=475.025n

.meas tran vdout0_42ck940 FIND v(dout0_42) AT=475.025n

.meas tran vdout0_43ck940 FIND v(dout0_43) AT=475.025n

.meas tran vdout0_44ck940 FIND v(dout0_44) AT=475.025n

.meas tran vdout0_45ck940 FIND v(dout0_45) AT=475.025n

.meas tran vdout0_46ck940 FIND v(dout0_46) AT=475.025n

.meas tran vdout0_47ck940 FIND v(dout0_47) AT=475.025n

.meas tran vdout0_48ck940 FIND v(dout0_48) AT=475.025n

.meas tran vdout0_49ck940 FIND v(dout0_49) AT=475.025n

.meas tran vdout0_50ck940 FIND v(dout0_50) AT=475.025n

.meas tran vdout0_51ck940 FIND v(dout0_51) AT=475.025n

.meas tran vdout0_52ck940 FIND v(dout0_52) AT=475.025n

.meas tran vdout0_53ck940 FIND v(dout0_53) AT=475.025n

.meas tran vdout0_54ck940 FIND v(dout0_54) AT=475.025n

.meas tran vdout0_55ck940 FIND v(dout0_55) AT=475.025n

.meas tran vdout0_56ck940 FIND v(dout0_56) AT=475.025n

.meas tran vdout0_57ck940 FIND v(dout0_57) AT=475.025n

.meas tran vdout0_58ck940 FIND v(dout0_58) AT=475.025n

.meas tran vdout0_59ck940 FIND v(dout0_59) AT=475.025n

.meas tran vdout0_60ck940 FIND v(dout0_60) AT=475.025n

.meas tran vdout0_61ck940 FIND v(dout0_61) AT=475.025n

.meas tran vdout0_62ck940 FIND v(dout0_62) AT=475.025n

.meas tran vdout0_63ck940 FIND v(dout0_63) AT=475.025n

.meas tran vdout0_64ck940 FIND v(dout0_64) AT=475.025n

.meas tran vdout0_65ck940 FIND v(dout0_65) AT=475.025n

.meas tran vdout0_66ck940 FIND v(dout0_66) AT=475.025n

.meas tran vdout0_67ck940 FIND v(dout0_67) AT=475.025n

.meas tran vdout0_68ck940 FIND v(dout0_68) AT=475.025n

.meas tran vdout0_69ck940 FIND v(dout0_69) AT=475.025n

.meas tran vdout0_70ck940 FIND v(dout0_70) AT=475.025n

.meas tran vdout0_71ck940 FIND v(dout0_71) AT=475.025n

.meas tran vdout0_72ck940 FIND v(dout0_72) AT=475.025n

.meas tran vdout0_73ck940 FIND v(dout0_73) AT=475.025n

.meas tran vdout0_74ck940 FIND v(dout0_74) AT=475.025n

.meas tran vdout0_75ck940 FIND v(dout0_75) AT=475.025n

.meas tran vdout0_76ck940 FIND v(dout0_76) AT=475.025n

.meas tran vdout0_77ck940 FIND v(dout0_77) AT=475.025n

.meas tran vdout0_78ck940 FIND v(dout0_78) AT=475.025n

.meas tran vdout0_79ck940 FIND v(dout0_79) AT=475.025n

.meas tran vdout0_80ck940 FIND v(dout0_80) AT=475.025n

.meas tran vdout0_81ck940 FIND v(dout0_81) AT=475.025n

.meas tran vdout0_82ck940 FIND v(dout0_82) AT=475.025n

.meas tran vdout0_83ck940 FIND v(dout0_83) AT=475.025n

.meas tran vdout0_84ck940 FIND v(dout0_84) AT=475.025n

.meas tran vdout0_85ck940 FIND v(dout0_85) AT=475.025n

.meas tran vdout0_86ck940 FIND v(dout0_86) AT=475.025n

.meas tran vdout0_87ck940 FIND v(dout0_87) AT=475.025n

.meas tran vdout0_88ck940 FIND v(dout0_88) AT=475.025n

.meas tran vdout0_89ck940 FIND v(dout0_89) AT=475.025n

.meas tran vdout0_90ck940 FIND v(dout0_90) AT=475.025n

.meas tran vdout0_91ck940 FIND v(dout0_91) AT=475.025n

.meas tran vdout0_92ck940 FIND v(dout0_92) AT=475.025n

.meas tran vdout0_93ck940 FIND v(dout0_93) AT=475.025n

.meas tran vdout0_94ck940 FIND v(dout0_94) AT=475.025n

.meas tran vdout0_95ck940 FIND v(dout0_95) AT=475.025n

.meas tran vdout0_96ck940 FIND v(dout0_96) AT=475.025n

.meas tran vdout0_97ck940 FIND v(dout0_97) AT=475.025n

.meas tran vdout0_98ck940 FIND v(dout0_98) AT=475.025n

.meas tran vdout0_99ck940 FIND v(dout0_99) AT=475.025n

.meas tran vdout0_100ck940 FIND v(dout0_100) AT=475.025n

.meas tran vdout0_101ck940 FIND v(dout0_101) AT=475.025n

.meas tran vdout0_102ck940 FIND v(dout0_102) AT=475.025n

.meas tran vdout0_103ck940 FIND v(dout0_103) AT=475.025n

.meas tran vdout0_104ck940 FIND v(dout0_104) AT=475.025n

.meas tran vdout0_105ck940 FIND v(dout0_105) AT=475.025n

.meas tran vdout0_106ck940 FIND v(dout0_106) AT=475.025n

.meas tran vdout0_107ck940 FIND v(dout0_107) AT=475.025n

.meas tran vdout0_108ck940 FIND v(dout0_108) AT=475.025n

.meas tran vdout0_109ck940 FIND v(dout0_109) AT=475.025n

.meas tran vdout0_110ck940 FIND v(dout0_110) AT=475.025n

.meas tran vdout0_111ck940 FIND v(dout0_111) AT=475.025n

.meas tran vdout0_112ck940 FIND v(dout0_112) AT=475.025n

.meas tran vdout0_113ck940 FIND v(dout0_113) AT=475.025n

.meas tran vdout0_114ck940 FIND v(dout0_114) AT=475.025n

.meas tran vdout0_115ck940 FIND v(dout0_115) AT=475.025n

.meas tran vdout0_116ck940 FIND v(dout0_116) AT=475.025n

.meas tran vdout0_117ck940 FIND v(dout0_117) AT=475.025n

.meas tran vdout0_118ck940 FIND v(dout0_118) AT=475.025n

.meas tran vdout0_119ck940 FIND v(dout0_119) AT=475.025n

.meas tran vdout0_120ck940 FIND v(dout0_120) AT=475.025n

.meas tran vdout0_121ck940 FIND v(dout0_121) AT=475.025n

.meas tran vdout0_122ck940 FIND v(dout0_122) AT=475.025n

.meas tran vdout0_123ck940 FIND v(dout0_123) AT=475.025n

.meas tran vdout0_124ck940 FIND v(dout0_124) AT=475.025n

.meas tran vdout0_125ck940 FIND v(dout0_125) AT=475.025n

.meas tran vdout0_126ck940 FIND v(dout0_126) AT=475.025n

.meas tran vdout0_127ck940 FIND v(dout0_127) AT=475.025n

.meas tran vdout0_128ck940 FIND v(dout0_128) AT=475.025n

.meas tran vdout0_129ck940 FIND v(dout0_129) AT=475.025n

.meas tran vdout0_130ck940 FIND v(dout0_130) AT=475.025n

.meas tran vdout0_131ck940 FIND v(dout0_131) AT=475.025n

.meas tran vdout0_132ck940 FIND v(dout0_132) AT=475.025n

.meas tran vdout0_133ck940 FIND v(dout0_133) AT=475.025n

.meas tran vdout0_134ck940 FIND v(dout0_134) AT=475.025n

.meas tran vdout0_135ck940 FIND v(dout0_135) AT=475.025n

.meas tran vdout0_136ck940 FIND v(dout0_136) AT=475.025n

.meas tran vdout0_137ck940 FIND v(dout0_137) AT=475.025n

.meas tran vdout0_138ck940 FIND v(dout0_138) AT=475.025n

.meas tran vdout0_139ck940 FIND v(dout0_139) AT=475.025n

.meas tran vdout0_140ck940 FIND v(dout0_140) AT=475.025n

.meas tran vdout0_141ck940 FIND v(dout0_141) AT=475.025n

.meas tran vdout0_142ck940 FIND v(dout0_142) AT=475.025n

.meas tran vdout0_143ck940 FIND v(dout0_143) AT=475.025n

.meas tran vdout0_144ck940 FIND v(dout0_144) AT=475.025n

.meas tran vdout0_145ck940 FIND v(dout0_145) AT=475.025n

.meas tran vdout0_146ck940 FIND v(dout0_146) AT=475.025n

.meas tran vdout0_147ck940 FIND v(dout0_147) AT=475.025n

.meas tran vdout0_148ck940 FIND v(dout0_148) AT=475.025n

.meas tran vdout0_149ck940 FIND v(dout0_149) AT=475.025n

.meas tran vdout0_0ck950 FIND v(dout0_0) AT=480.025n

.meas tran vdout0_1ck950 FIND v(dout0_1) AT=480.025n

.meas tran vdout0_2ck950 FIND v(dout0_2) AT=480.025n

.meas tran vdout0_3ck950 FIND v(dout0_3) AT=480.025n

.meas tran vdout0_4ck950 FIND v(dout0_4) AT=480.025n

.meas tran vdout0_5ck950 FIND v(dout0_5) AT=480.025n

.meas tran vdout0_6ck950 FIND v(dout0_6) AT=480.025n

.meas tran vdout0_7ck950 FIND v(dout0_7) AT=480.025n

.meas tran vdout0_8ck950 FIND v(dout0_8) AT=480.025n

.meas tran vdout0_9ck950 FIND v(dout0_9) AT=480.025n

.meas tran vdout0_10ck950 FIND v(dout0_10) AT=480.025n

.meas tran vdout0_11ck950 FIND v(dout0_11) AT=480.025n

.meas tran vdout0_12ck950 FIND v(dout0_12) AT=480.025n

.meas tran vdout0_13ck950 FIND v(dout0_13) AT=480.025n

.meas tran vdout0_14ck950 FIND v(dout0_14) AT=480.025n

.meas tran vdout0_15ck950 FIND v(dout0_15) AT=480.025n

.meas tran vdout0_16ck950 FIND v(dout0_16) AT=480.025n

.meas tran vdout0_17ck950 FIND v(dout0_17) AT=480.025n

.meas tran vdout0_18ck950 FIND v(dout0_18) AT=480.025n

.meas tran vdout0_19ck950 FIND v(dout0_19) AT=480.025n

.meas tran vdout0_20ck950 FIND v(dout0_20) AT=480.025n

.meas tran vdout0_21ck950 FIND v(dout0_21) AT=480.025n

.meas tran vdout0_22ck950 FIND v(dout0_22) AT=480.025n

.meas tran vdout0_23ck950 FIND v(dout0_23) AT=480.025n

.meas tran vdout0_24ck950 FIND v(dout0_24) AT=480.025n

.meas tran vdout0_25ck950 FIND v(dout0_25) AT=480.025n

.meas tran vdout0_26ck950 FIND v(dout0_26) AT=480.025n

.meas tran vdout0_27ck950 FIND v(dout0_27) AT=480.025n

.meas tran vdout0_28ck950 FIND v(dout0_28) AT=480.025n

.meas tran vdout0_29ck950 FIND v(dout0_29) AT=480.025n

.meas tran vdout0_30ck950 FIND v(dout0_30) AT=480.025n

.meas tran vdout0_31ck950 FIND v(dout0_31) AT=480.025n

.meas tran vdout0_32ck950 FIND v(dout0_32) AT=480.025n

.meas tran vdout0_33ck950 FIND v(dout0_33) AT=480.025n

.meas tran vdout0_34ck950 FIND v(dout0_34) AT=480.025n

.meas tran vdout0_35ck950 FIND v(dout0_35) AT=480.025n

.meas tran vdout0_36ck950 FIND v(dout0_36) AT=480.025n

.meas tran vdout0_37ck950 FIND v(dout0_37) AT=480.025n

.meas tran vdout0_38ck950 FIND v(dout0_38) AT=480.025n

.meas tran vdout0_39ck950 FIND v(dout0_39) AT=480.025n

.meas tran vdout0_40ck950 FIND v(dout0_40) AT=480.025n

.meas tran vdout0_41ck950 FIND v(dout0_41) AT=480.025n

.meas tran vdout0_42ck950 FIND v(dout0_42) AT=480.025n

.meas tran vdout0_43ck950 FIND v(dout0_43) AT=480.025n

.meas tran vdout0_44ck950 FIND v(dout0_44) AT=480.025n

.meas tran vdout0_45ck950 FIND v(dout0_45) AT=480.025n

.meas tran vdout0_46ck950 FIND v(dout0_46) AT=480.025n

.meas tran vdout0_47ck950 FIND v(dout0_47) AT=480.025n

.meas tran vdout0_48ck950 FIND v(dout0_48) AT=480.025n

.meas tran vdout0_49ck950 FIND v(dout0_49) AT=480.025n

.meas tran vdout0_50ck950 FIND v(dout0_50) AT=480.025n

.meas tran vdout0_51ck950 FIND v(dout0_51) AT=480.025n

.meas tran vdout0_52ck950 FIND v(dout0_52) AT=480.025n

.meas tran vdout0_53ck950 FIND v(dout0_53) AT=480.025n

.meas tran vdout0_54ck950 FIND v(dout0_54) AT=480.025n

.meas tran vdout0_55ck950 FIND v(dout0_55) AT=480.025n

.meas tran vdout0_56ck950 FIND v(dout0_56) AT=480.025n

.meas tran vdout0_57ck950 FIND v(dout0_57) AT=480.025n

.meas tran vdout0_58ck950 FIND v(dout0_58) AT=480.025n

.meas tran vdout0_59ck950 FIND v(dout0_59) AT=480.025n

.meas tran vdout0_60ck950 FIND v(dout0_60) AT=480.025n

.meas tran vdout0_61ck950 FIND v(dout0_61) AT=480.025n

.meas tran vdout0_62ck950 FIND v(dout0_62) AT=480.025n

.meas tran vdout0_63ck950 FIND v(dout0_63) AT=480.025n

.meas tran vdout0_64ck950 FIND v(dout0_64) AT=480.025n

.meas tran vdout0_65ck950 FIND v(dout0_65) AT=480.025n

.meas tran vdout0_66ck950 FIND v(dout0_66) AT=480.025n

.meas tran vdout0_67ck950 FIND v(dout0_67) AT=480.025n

.meas tran vdout0_68ck950 FIND v(dout0_68) AT=480.025n

.meas tran vdout0_69ck950 FIND v(dout0_69) AT=480.025n

.meas tran vdout0_70ck950 FIND v(dout0_70) AT=480.025n

.meas tran vdout0_71ck950 FIND v(dout0_71) AT=480.025n

.meas tran vdout0_72ck950 FIND v(dout0_72) AT=480.025n

.meas tran vdout0_73ck950 FIND v(dout0_73) AT=480.025n

.meas tran vdout0_74ck950 FIND v(dout0_74) AT=480.025n

.meas tran vdout0_75ck950 FIND v(dout0_75) AT=480.025n

.meas tran vdout0_76ck950 FIND v(dout0_76) AT=480.025n

.meas tran vdout0_77ck950 FIND v(dout0_77) AT=480.025n

.meas tran vdout0_78ck950 FIND v(dout0_78) AT=480.025n

.meas tran vdout0_79ck950 FIND v(dout0_79) AT=480.025n

.meas tran vdout0_80ck950 FIND v(dout0_80) AT=480.025n

.meas tran vdout0_81ck950 FIND v(dout0_81) AT=480.025n

.meas tran vdout0_82ck950 FIND v(dout0_82) AT=480.025n

.meas tran vdout0_83ck950 FIND v(dout0_83) AT=480.025n

.meas tran vdout0_84ck950 FIND v(dout0_84) AT=480.025n

.meas tran vdout0_85ck950 FIND v(dout0_85) AT=480.025n

.meas tran vdout0_86ck950 FIND v(dout0_86) AT=480.025n

.meas tran vdout0_87ck950 FIND v(dout0_87) AT=480.025n

.meas tran vdout0_88ck950 FIND v(dout0_88) AT=480.025n

.meas tran vdout0_89ck950 FIND v(dout0_89) AT=480.025n

.meas tran vdout0_90ck950 FIND v(dout0_90) AT=480.025n

.meas tran vdout0_91ck950 FIND v(dout0_91) AT=480.025n

.meas tran vdout0_92ck950 FIND v(dout0_92) AT=480.025n

.meas tran vdout0_93ck950 FIND v(dout0_93) AT=480.025n

.meas tran vdout0_94ck950 FIND v(dout0_94) AT=480.025n

.meas tran vdout0_95ck950 FIND v(dout0_95) AT=480.025n

.meas tran vdout0_96ck950 FIND v(dout0_96) AT=480.025n

.meas tran vdout0_97ck950 FIND v(dout0_97) AT=480.025n

.meas tran vdout0_98ck950 FIND v(dout0_98) AT=480.025n

.meas tran vdout0_99ck950 FIND v(dout0_99) AT=480.025n

.meas tran vdout0_100ck950 FIND v(dout0_100) AT=480.025n

.meas tran vdout0_101ck950 FIND v(dout0_101) AT=480.025n

.meas tran vdout0_102ck950 FIND v(dout0_102) AT=480.025n

.meas tran vdout0_103ck950 FIND v(dout0_103) AT=480.025n

.meas tran vdout0_104ck950 FIND v(dout0_104) AT=480.025n

.meas tran vdout0_105ck950 FIND v(dout0_105) AT=480.025n

.meas tran vdout0_106ck950 FIND v(dout0_106) AT=480.025n

.meas tran vdout0_107ck950 FIND v(dout0_107) AT=480.025n

.meas tran vdout0_108ck950 FIND v(dout0_108) AT=480.025n

.meas tran vdout0_109ck950 FIND v(dout0_109) AT=480.025n

.meas tran vdout0_110ck950 FIND v(dout0_110) AT=480.025n

.meas tran vdout0_111ck950 FIND v(dout0_111) AT=480.025n

.meas tran vdout0_112ck950 FIND v(dout0_112) AT=480.025n

.meas tran vdout0_113ck950 FIND v(dout0_113) AT=480.025n

.meas tran vdout0_114ck950 FIND v(dout0_114) AT=480.025n

.meas tran vdout0_115ck950 FIND v(dout0_115) AT=480.025n

.meas tran vdout0_116ck950 FIND v(dout0_116) AT=480.025n

.meas tran vdout0_117ck950 FIND v(dout0_117) AT=480.025n

.meas tran vdout0_118ck950 FIND v(dout0_118) AT=480.025n

.meas tran vdout0_119ck950 FIND v(dout0_119) AT=480.025n

.meas tran vdout0_120ck950 FIND v(dout0_120) AT=480.025n

.meas tran vdout0_121ck950 FIND v(dout0_121) AT=480.025n

.meas tran vdout0_122ck950 FIND v(dout0_122) AT=480.025n

.meas tran vdout0_123ck950 FIND v(dout0_123) AT=480.025n

.meas tran vdout0_124ck950 FIND v(dout0_124) AT=480.025n

.meas tran vdout0_125ck950 FIND v(dout0_125) AT=480.025n

.meas tran vdout0_126ck950 FIND v(dout0_126) AT=480.025n

.meas tran vdout0_127ck950 FIND v(dout0_127) AT=480.025n

.meas tran vdout0_128ck950 FIND v(dout0_128) AT=480.025n

.meas tran vdout0_129ck950 FIND v(dout0_129) AT=480.025n

.meas tran vdout0_130ck950 FIND v(dout0_130) AT=480.025n

.meas tran vdout0_131ck950 FIND v(dout0_131) AT=480.025n

.meas tran vdout0_132ck950 FIND v(dout0_132) AT=480.025n

.meas tran vdout0_133ck950 FIND v(dout0_133) AT=480.025n

.meas tran vdout0_134ck950 FIND v(dout0_134) AT=480.025n

.meas tran vdout0_135ck950 FIND v(dout0_135) AT=480.025n

.meas tran vdout0_136ck950 FIND v(dout0_136) AT=480.025n

.meas tran vdout0_137ck950 FIND v(dout0_137) AT=480.025n

.meas tran vdout0_138ck950 FIND v(dout0_138) AT=480.025n

.meas tran vdout0_139ck950 FIND v(dout0_139) AT=480.025n

.meas tran vdout0_140ck950 FIND v(dout0_140) AT=480.025n

.meas tran vdout0_141ck950 FIND v(dout0_141) AT=480.025n

.meas tran vdout0_142ck950 FIND v(dout0_142) AT=480.025n

.meas tran vdout0_143ck950 FIND v(dout0_143) AT=480.025n

.meas tran vdout0_144ck950 FIND v(dout0_144) AT=480.025n

.meas tran vdout0_145ck950 FIND v(dout0_145) AT=480.025n

.meas tran vdout0_146ck950 FIND v(dout0_146) AT=480.025n

.meas tran vdout0_147ck950 FIND v(dout0_147) AT=480.025n

.meas tran vdout0_148ck950 FIND v(dout0_148) AT=480.025n

.meas tran vdout0_149ck950 FIND v(dout0_149) AT=480.025n

.meas tran vdout0_0ck970 FIND v(dout0_0) AT=490.025n

.meas tran vdout0_1ck970 FIND v(dout0_1) AT=490.025n

.meas tran vdout0_2ck970 FIND v(dout0_2) AT=490.025n

.meas tran vdout0_3ck970 FIND v(dout0_3) AT=490.025n

.meas tran vdout0_4ck970 FIND v(dout0_4) AT=490.025n

.meas tran vdout0_5ck970 FIND v(dout0_5) AT=490.025n

.meas tran vdout0_6ck970 FIND v(dout0_6) AT=490.025n

.meas tran vdout0_7ck970 FIND v(dout0_7) AT=490.025n

.meas tran vdout0_8ck970 FIND v(dout0_8) AT=490.025n

.meas tran vdout0_9ck970 FIND v(dout0_9) AT=490.025n

.meas tran vdout0_10ck970 FIND v(dout0_10) AT=490.025n

.meas tran vdout0_11ck970 FIND v(dout0_11) AT=490.025n

.meas tran vdout0_12ck970 FIND v(dout0_12) AT=490.025n

.meas tran vdout0_13ck970 FIND v(dout0_13) AT=490.025n

.meas tran vdout0_14ck970 FIND v(dout0_14) AT=490.025n

.meas tran vdout0_15ck970 FIND v(dout0_15) AT=490.025n

.meas tran vdout0_16ck970 FIND v(dout0_16) AT=490.025n

.meas tran vdout0_17ck970 FIND v(dout0_17) AT=490.025n

.meas tran vdout0_18ck970 FIND v(dout0_18) AT=490.025n

.meas tran vdout0_19ck970 FIND v(dout0_19) AT=490.025n

.meas tran vdout0_20ck970 FIND v(dout0_20) AT=490.025n

.meas tran vdout0_21ck970 FIND v(dout0_21) AT=490.025n

.meas tran vdout0_22ck970 FIND v(dout0_22) AT=490.025n

.meas tran vdout0_23ck970 FIND v(dout0_23) AT=490.025n

.meas tran vdout0_24ck970 FIND v(dout0_24) AT=490.025n

.meas tran vdout0_25ck970 FIND v(dout0_25) AT=490.025n

.meas tran vdout0_26ck970 FIND v(dout0_26) AT=490.025n

.meas tran vdout0_27ck970 FIND v(dout0_27) AT=490.025n

.meas tran vdout0_28ck970 FIND v(dout0_28) AT=490.025n

.meas tran vdout0_29ck970 FIND v(dout0_29) AT=490.025n

.meas tran vdout0_30ck970 FIND v(dout0_30) AT=490.025n

.meas tran vdout0_31ck970 FIND v(dout0_31) AT=490.025n

.meas tran vdout0_32ck970 FIND v(dout0_32) AT=490.025n

.meas tran vdout0_33ck970 FIND v(dout0_33) AT=490.025n

.meas tran vdout0_34ck970 FIND v(dout0_34) AT=490.025n

.meas tran vdout0_35ck970 FIND v(dout0_35) AT=490.025n

.meas tran vdout0_36ck970 FIND v(dout0_36) AT=490.025n

.meas tran vdout0_37ck970 FIND v(dout0_37) AT=490.025n

.meas tran vdout0_38ck970 FIND v(dout0_38) AT=490.025n

.meas tran vdout0_39ck970 FIND v(dout0_39) AT=490.025n

.meas tran vdout0_40ck970 FIND v(dout0_40) AT=490.025n

.meas tran vdout0_41ck970 FIND v(dout0_41) AT=490.025n

.meas tran vdout0_42ck970 FIND v(dout0_42) AT=490.025n

.meas tran vdout0_43ck970 FIND v(dout0_43) AT=490.025n

.meas tran vdout0_44ck970 FIND v(dout0_44) AT=490.025n

.meas tran vdout0_45ck970 FIND v(dout0_45) AT=490.025n

.meas tran vdout0_46ck970 FIND v(dout0_46) AT=490.025n

.meas tran vdout0_47ck970 FIND v(dout0_47) AT=490.025n

.meas tran vdout0_48ck970 FIND v(dout0_48) AT=490.025n

.meas tran vdout0_49ck970 FIND v(dout0_49) AT=490.025n

.meas tran vdout0_50ck970 FIND v(dout0_50) AT=490.025n

.meas tran vdout0_51ck970 FIND v(dout0_51) AT=490.025n

.meas tran vdout0_52ck970 FIND v(dout0_52) AT=490.025n

.meas tran vdout0_53ck970 FIND v(dout0_53) AT=490.025n

.meas tran vdout0_54ck970 FIND v(dout0_54) AT=490.025n

.meas tran vdout0_55ck970 FIND v(dout0_55) AT=490.025n

.meas tran vdout0_56ck970 FIND v(dout0_56) AT=490.025n

.meas tran vdout0_57ck970 FIND v(dout0_57) AT=490.025n

.meas tran vdout0_58ck970 FIND v(dout0_58) AT=490.025n

.meas tran vdout0_59ck970 FIND v(dout0_59) AT=490.025n

.meas tran vdout0_60ck970 FIND v(dout0_60) AT=490.025n

.meas tran vdout0_61ck970 FIND v(dout0_61) AT=490.025n

.meas tran vdout0_62ck970 FIND v(dout0_62) AT=490.025n

.meas tran vdout0_63ck970 FIND v(dout0_63) AT=490.025n

.meas tran vdout0_64ck970 FIND v(dout0_64) AT=490.025n

.meas tran vdout0_65ck970 FIND v(dout0_65) AT=490.025n

.meas tran vdout0_66ck970 FIND v(dout0_66) AT=490.025n

.meas tran vdout0_67ck970 FIND v(dout0_67) AT=490.025n

.meas tran vdout0_68ck970 FIND v(dout0_68) AT=490.025n

.meas tran vdout0_69ck970 FIND v(dout0_69) AT=490.025n

.meas tran vdout0_70ck970 FIND v(dout0_70) AT=490.025n

.meas tran vdout0_71ck970 FIND v(dout0_71) AT=490.025n

.meas tran vdout0_72ck970 FIND v(dout0_72) AT=490.025n

.meas tran vdout0_73ck970 FIND v(dout0_73) AT=490.025n

.meas tran vdout0_74ck970 FIND v(dout0_74) AT=490.025n

.meas tran vdout0_75ck970 FIND v(dout0_75) AT=490.025n

.meas tran vdout0_76ck970 FIND v(dout0_76) AT=490.025n

.meas tran vdout0_77ck970 FIND v(dout0_77) AT=490.025n

.meas tran vdout0_78ck970 FIND v(dout0_78) AT=490.025n

.meas tran vdout0_79ck970 FIND v(dout0_79) AT=490.025n

.meas tran vdout0_80ck970 FIND v(dout0_80) AT=490.025n

.meas tran vdout0_81ck970 FIND v(dout0_81) AT=490.025n

.meas tran vdout0_82ck970 FIND v(dout0_82) AT=490.025n

.meas tran vdout0_83ck970 FIND v(dout0_83) AT=490.025n

.meas tran vdout0_84ck970 FIND v(dout0_84) AT=490.025n

.meas tran vdout0_85ck970 FIND v(dout0_85) AT=490.025n

.meas tran vdout0_86ck970 FIND v(dout0_86) AT=490.025n

.meas tran vdout0_87ck970 FIND v(dout0_87) AT=490.025n

.meas tran vdout0_88ck970 FIND v(dout0_88) AT=490.025n

.meas tran vdout0_89ck970 FIND v(dout0_89) AT=490.025n

.meas tran vdout0_90ck970 FIND v(dout0_90) AT=490.025n

.meas tran vdout0_91ck970 FIND v(dout0_91) AT=490.025n

.meas tran vdout0_92ck970 FIND v(dout0_92) AT=490.025n

.meas tran vdout0_93ck970 FIND v(dout0_93) AT=490.025n

.meas tran vdout0_94ck970 FIND v(dout0_94) AT=490.025n

.meas tran vdout0_95ck970 FIND v(dout0_95) AT=490.025n

.meas tran vdout0_96ck970 FIND v(dout0_96) AT=490.025n

.meas tran vdout0_97ck970 FIND v(dout0_97) AT=490.025n

.meas tran vdout0_98ck970 FIND v(dout0_98) AT=490.025n

.meas tran vdout0_99ck970 FIND v(dout0_99) AT=490.025n

.meas tran vdout0_100ck970 FIND v(dout0_100) AT=490.025n

.meas tran vdout0_101ck970 FIND v(dout0_101) AT=490.025n

.meas tran vdout0_102ck970 FIND v(dout0_102) AT=490.025n

.meas tran vdout0_103ck970 FIND v(dout0_103) AT=490.025n

.meas tran vdout0_104ck970 FIND v(dout0_104) AT=490.025n

.meas tran vdout0_105ck970 FIND v(dout0_105) AT=490.025n

.meas tran vdout0_106ck970 FIND v(dout0_106) AT=490.025n

.meas tran vdout0_107ck970 FIND v(dout0_107) AT=490.025n

.meas tran vdout0_108ck970 FIND v(dout0_108) AT=490.025n

.meas tran vdout0_109ck970 FIND v(dout0_109) AT=490.025n

.meas tran vdout0_110ck970 FIND v(dout0_110) AT=490.025n

.meas tran vdout0_111ck970 FIND v(dout0_111) AT=490.025n

.meas tran vdout0_112ck970 FIND v(dout0_112) AT=490.025n

.meas tran vdout0_113ck970 FIND v(dout0_113) AT=490.025n

.meas tran vdout0_114ck970 FIND v(dout0_114) AT=490.025n

.meas tran vdout0_115ck970 FIND v(dout0_115) AT=490.025n

.meas tran vdout0_116ck970 FIND v(dout0_116) AT=490.025n

.meas tran vdout0_117ck970 FIND v(dout0_117) AT=490.025n

.meas tran vdout0_118ck970 FIND v(dout0_118) AT=490.025n

.meas tran vdout0_119ck970 FIND v(dout0_119) AT=490.025n

.meas tran vdout0_120ck970 FIND v(dout0_120) AT=490.025n

.meas tran vdout0_121ck970 FIND v(dout0_121) AT=490.025n

.meas tran vdout0_122ck970 FIND v(dout0_122) AT=490.025n

.meas tran vdout0_123ck970 FIND v(dout0_123) AT=490.025n

.meas tran vdout0_124ck970 FIND v(dout0_124) AT=490.025n

.meas tran vdout0_125ck970 FIND v(dout0_125) AT=490.025n

.meas tran vdout0_126ck970 FIND v(dout0_126) AT=490.025n

.meas tran vdout0_127ck970 FIND v(dout0_127) AT=490.025n

.meas tran vdout0_128ck970 FIND v(dout0_128) AT=490.025n

.meas tran vdout0_129ck970 FIND v(dout0_129) AT=490.025n

.meas tran vdout0_130ck970 FIND v(dout0_130) AT=490.025n

.meas tran vdout0_131ck970 FIND v(dout0_131) AT=490.025n

.meas tran vdout0_132ck970 FIND v(dout0_132) AT=490.025n

.meas tran vdout0_133ck970 FIND v(dout0_133) AT=490.025n

.meas tran vdout0_134ck970 FIND v(dout0_134) AT=490.025n

.meas tran vdout0_135ck970 FIND v(dout0_135) AT=490.025n

.meas tran vdout0_136ck970 FIND v(dout0_136) AT=490.025n

.meas tran vdout0_137ck970 FIND v(dout0_137) AT=490.025n

.meas tran vdout0_138ck970 FIND v(dout0_138) AT=490.025n

.meas tran vdout0_139ck970 FIND v(dout0_139) AT=490.025n

.meas tran vdout0_140ck970 FIND v(dout0_140) AT=490.025n

.meas tran vdout0_141ck970 FIND v(dout0_141) AT=490.025n

.meas tran vdout0_142ck970 FIND v(dout0_142) AT=490.025n

.meas tran vdout0_143ck970 FIND v(dout0_143) AT=490.025n

.meas tran vdout0_144ck970 FIND v(dout0_144) AT=490.025n

.meas tran vdout0_145ck970 FIND v(dout0_145) AT=490.025n

.meas tran vdout0_146ck970 FIND v(dout0_146) AT=490.025n

.meas tran vdout0_147ck970 FIND v(dout0_147) AT=490.025n

.meas tran vdout0_148ck970 FIND v(dout0_148) AT=490.025n

.meas tran vdout0_149ck970 FIND v(dout0_149) AT=490.025n

.meas tran vdout0_0ck980 FIND v(dout0_0) AT=495.025n

.meas tran vdout0_1ck980 FIND v(dout0_1) AT=495.025n

.meas tran vdout0_2ck980 FIND v(dout0_2) AT=495.025n

.meas tran vdout0_3ck980 FIND v(dout0_3) AT=495.025n

.meas tran vdout0_4ck980 FIND v(dout0_4) AT=495.025n

.meas tran vdout0_5ck980 FIND v(dout0_5) AT=495.025n

.meas tran vdout0_6ck980 FIND v(dout0_6) AT=495.025n

.meas tran vdout0_7ck980 FIND v(dout0_7) AT=495.025n

.meas tran vdout0_8ck980 FIND v(dout0_8) AT=495.025n

.meas tran vdout0_9ck980 FIND v(dout0_9) AT=495.025n

.meas tran vdout0_10ck980 FIND v(dout0_10) AT=495.025n

.meas tran vdout0_11ck980 FIND v(dout0_11) AT=495.025n

.meas tran vdout0_12ck980 FIND v(dout0_12) AT=495.025n

.meas tran vdout0_13ck980 FIND v(dout0_13) AT=495.025n

.meas tran vdout0_14ck980 FIND v(dout0_14) AT=495.025n

.meas tran vdout0_15ck980 FIND v(dout0_15) AT=495.025n

.meas tran vdout0_16ck980 FIND v(dout0_16) AT=495.025n

.meas tran vdout0_17ck980 FIND v(dout0_17) AT=495.025n

.meas tran vdout0_18ck980 FIND v(dout0_18) AT=495.025n

.meas tran vdout0_19ck980 FIND v(dout0_19) AT=495.025n

.meas tran vdout0_20ck980 FIND v(dout0_20) AT=495.025n

.meas tran vdout0_21ck980 FIND v(dout0_21) AT=495.025n

.meas tran vdout0_22ck980 FIND v(dout0_22) AT=495.025n

.meas tran vdout0_23ck980 FIND v(dout0_23) AT=495.025n

.meas tran vdout0_24ck980 FIND v(dout0_24) AT=495.025n

.meas tran vdout0_25ck980 FIND v(dout0_25) AT=495.025n

.meas tran vdout0_26ck980 FIND v(dout0_26) AT=495.025n

.meas tran vdout0_27ck980 FIND v(dout0_27) AT=495.025n

.meas tran vdout0_28ck980 FIND v(dout0_28) AT=495.025n

.meas tran vdout0_29ck980 FIND v(dout0_29) AT=495.025n

.meas tran vdout0_30ck980 FIND v(dout0_30) AT=495.025n

.meas tran vdout0_31ck980 FIND v(dout0_31) AT=495.025n

.meas tran vdout0_32ck980 FIND v(dout0_32) AT=495.025n

.meas tran vdout0_33ck980 FIND v(dout0_33) AT=495.025n

.meas tran vdout0_34ck980 FIND v(dout0_34) AT=495.025n

.meas tran vdout0_35ck980 FIND v(dout0_35) AT=495.025n

.meas tran vdout0_36ck980 FIND v(dout0_36) AT=495.025n

.meas tran vdout0_37ck980 FIND v(dout0_37) AT=495.025n

.meas tran vdout0_38ck980 FIND v(dout0_38) AT=495.025n

.meas tran vdout0_39ck980 FIND v(dout0_39) AT=495.025n

.meas tran vdout0_40ck980 FIND v(dout0_40) AT=495.025n

.meas tran vdout0_41ck980 FIND v(dout0_41) AT=495.025n

.meas tran vdout0_42ck980 FIND v(dout0_42) AT=495.025n

.meas tran vdout0_43ck980 FIND v(dout0_43) AT=495.025n

.meas tran vdout0_44ck980 FIND v(dout0_44) AT=495.025n

.meas tran vdout0_45ck980 FIND v(dout0_45) AT=495.025n

.meas tran vdout0_46ck980 FIND v(dout0_46) AT=495.025n

.meas tran vdout0_47ck980 FIND v(dout0_47) AT=495.025n

.meas tran vdout0_48ck980 FIND v(dout0_48) AT=495.025n

.meas tran vdout0_49ck980 FIND v(dout0_49) AT=495.025n

.meas tran vdout0_50ck980 FIND v(dout0_50) AT=495.025n

.meas tran vdout0_51ck980 FIND v(dout0_51) AT=495.025n

.meas tran vdout0_52ck980 FIND v(dout0_52) AT=495.025n

.meas tran vdout0_53ck980 FIND v(dout0_53) AT=495.025n

.meas tran vdout0_54ck980 FIND v(dout0_54) AT=495.025n

.meas tran vdout0_55ck980 FIND v(dout0_55) AT=495.025n

.meas tran vdout0_56ck980 FIND v(dout0_56) AT=495.025n

.meas tran vdout0_57ck980 FIND v(dout0_57) AT=495.025n

.meas tran vdout0_58ck980 FIND v(dout0_58) AT=495.025n

.meas tran vdout0_59ck980 FIND v(dout0_59) AT=495.025n

.meas tran vdout0_60ck980 FIND v(dout0_60) AT=495.025n

.meas tran vdout0_61ck980 FIND v(dout0_61) AT=495.025n

.meas tran vdout0_62ck980 FIND v(dout0_62) AT=495.025n

.meas tran vdout0_63ck980 FIND v(dout0_63) AT=495.025n

.meas tran vdout0_64ck980 FIND v(dout0_64) AT=495.025n

.meas tran vdout0_65ck980 FIND v(dout0_65) AT=495.025n

.meas tran vdout0_66ck980 FIND v(dout0_66) AT=495.025n

.meas tran vdout0_67ck980 FIND v(dout0_67) AT=495.025n

.meas tran vdout0_68ck980 FIND v(dout0_68) AT=495.025n

.meas tran vdout0_69ck980 FIND v(dout0_69) AT=495.025n

.meas tran vdout0_70ck980 FIND v(dout0_70) AT=495.025n

.meas tran vdout0_71ck980 FIND v(dout0_71) AT=495.025n

.meas tran vdout0_72ck980 FIND v(dout0_72) AT=495.025n

.meas tran vdout0_73ck980 FIND v(dout0_73) AT=495.025n

.meas tran vdout0_74ck980 FIND v(dout0_74) AT=495.025n

.meas tran vdout0_75ck980 FIND v(dout0_75) AT=495.025n

.meas tran vdout0_76ck980 FIND v(dout0_76) AT=495.025n

.meas tran vdout0_77ck980 FIND v(dout0_77) AT=495.025n

.meas tran vdout0_78ck980 FIND v(dout0_78) AT=495.025n

.meas tran vdout0_79ck980 FIND v(dout0_79) AT=495.025n

.meas tran vdout0_80ck980 FIND v(dout0_80) AT=495.025n

.meas tran vdout0_81ck980 FIND v(dout0_81) AT=495.025n

.meas tran vdout0_82ck980 FIND v(dout0_82) AT=495.025n

.meas tran vdout0_83ck980 FIND v(dout0_83) AT=495.025n

.meas tran vdout0_84ck980 FIND v(dout0_84) AT=495.025n

.meas tran vdout0_85ck980 FIND v(dout0_85) AT=495.025n

.meas tran vdout0_86ck980 FIND v(dout0_86) AT=495.025n

.meas tran vdout0_87ck980 FIND v(dout0_87) AT=495.025n

.meas tran vdout0_88ck980 FIND v(dout0_88) AT=495.025n

.meas tran vdout0_89ck980 FIND v(dout0_89) AT=495.025n

.meas tran vdout0_90ck980 FIND v(dout0_90) AT=495.025n

.meas tran vdout0_91ck980 FIND v(dout0_91) AT=495.025n

.meas tran vdout0_92ck980 FIND v(dout0_92) AT=495.025n

.meas tran vdout0_93ck980 FIND v(dout0_93) AT=495.025n

.meas tran vdout0_94ck980 FIND v(dout0_94) AT=495.025n

.meas tran vdout0_95ck980 FIND v(dout0_95) AT=495.025n

.meas tran vdout0_96ck980 FIND v(dout0_96) AT=495.025n

.meas tran vdout0_97ck980 FIND v(dout0_97) AT=495.025n

.meas tran vdout0_98ck980 FIND v(dout0_98) AT=495.025n

.meas tran vdout0_99ck980 FIND v(dout0_99) AT=495.025n

.meas tran vdout0_100ck980 FIND v(dout0_100) AT=495.025n

.meas tran vdout0_101ck980 FIND v(dout0_101) AT=495.025n

.meas tran vdout0_102ck980 FIND v(dout0_102) AT=495.025n

.meas tran vdout0_103ck980 FIND v(dout0_103) AT=495.025n

.meas tran vdout0_104ck980 FIND v(dout0_104) AT=495.025n

.meas tran vdout0_105ck980 FIND v(dout0_105) AT=495.025n

.meas tran vdout0_106ck980 FIND v(dout0_106) AT=495.025n

.meas tran vdout0_107ck980 FIND v(dout0_107) AT=495.025n

.meas tran vdout0_108ck980 FIND v(dout0_108) AT=495.025n

.meas tran vdout0_109ck980 FIND v(dout0_109) AT=495.025n

.meas tran vdout0_110ck980 FIND v(dout0_110) AT=495.025n

.meas tran vdout0_111ck980 FIND v(dout0_111) AT=495.025n

.meas tran vdout0_112ck980 FIND v(dout0_112) AT=495.025n

.meas tran vdout0_113ck980 FIND v(dout0_113) AT=495.025n

.meas tran vdout0_114ck980 FIND v(dout0_114) AT=495.025n

.meas tran vdout0_115ck980 FIND v(dout0_115) AT=495.025n

.meas tran vdout0_116ck980 FIND v(dout0_116) AT=495.025n

.meas tran vdout0_117ck980 FIND v(dout0_117) AT=495.025n

.meas tran vdout0_118ck980 FIND v(dout0_118) AT=495.025n

.meas tran vdout0_119ck980 FIND v(dout0_119) AT=495.025n

.meas tran vdout0_120ck980 FIND v(dout0_120) AT=495.025n

.meas tran vdout0_121ck980 FIND v(dout0_121) AT=495.025n

.meas tran vdout0_122ck980 FIND v(dout0_122) AT=495.025n

.meas tran vdout0_123ck980 FIND v(dout0_123) AT=495.025n

.meas tran vdout0_124ck980 FIND v(dout0_124) AT=495.025n

.meas tran vdout0_125ck980 FIND v(dout0_125) AT=495.025n

.meas tran vdout0_126ck980 FIND v(dout0_126) AT=495.025n

.meas tran vdout0_127ck980 FIND v(dout0_127) AT=495.025n

.meas tran vdout0_128ck980 FIND v(dout0_128) AT=495.025n

.meas tran vdout0_129ck980 FIND v(dout0_129) AT=495.025n

.meas tran vdout0_130ck980 FIND v(dout0_130) AT=495.025n

.meas tran vdout0_131ck980 FIND v(dout0_131) AT=495.025n

.meas tran vdout0_132ck980 FIND v(dout0_132) AT=495.025n

.meas tran vdout0_133ck980 FIND v(dout0_133) AT=495.025n

.meas tran vdout0_134ck980 FIND v(dout0_134) AT=495.025n

.meas tran vdout0_135ck980 FIND v(dout0_135) AT=495.025n

.meas tran vdout0_136ck980 FIND v(dout0_136) AT=495.025n

.meas tran vdout0_137ck980 FIND v(dout0_137) AT=495.025n

.meas tran vdout0_138ck980 FIND v(dout0_138) AT=495.025n

.meas tran vdout0_139ck980 FIND v(dout0_139) AT=495.025n

.meas tran vdout0_140ck980 FIND v(dout0_140) AT=495.025n

.meas tran vdout0_141ck980 FIND v(dout0_141) AT=495.025n

.meas tran vdout0_142ck980 FIND v(dout0_142) AT=495.025n

.meas tran vdout0_143ck980 FIND v(dout0_143) AT=495.025n

.meas tran vdout0_144ck980 FIND v(dout0_144) AT=495.025n

.meas tran vdout0_145ck980 FIND v(dout0_145) AT=495.025n

.meas tran vdout0_146ck980 FIND v(dout0_146) AT=495.025n

.meas tran vdout0_147ck980 FIND v(dout0_147) AT=495.025n

.meas tran vdout0_148ck980 FIND v(dout0_148) AT=495.025n

.meas tran vdout0_149ck980 FIND v(dout0_149) AT=495.025n

.meas tran vdout0_0ck1010 FIND v(dout0_0) AT=510.025n

.meas tran vdout0_1ck1010 FIND v(dout0_1) AT=510.025n

.meas tran vdout0_2ck1010 FIND v(dout0_2) AT=510.025n

.meas tran vdout0_3ck1010 FIND v(dout0_3) AT=510.025n

.meas tran vdout0_4ck1010 FIND v(dout0_4) AT=510.025n

.meas tran vdout0_5ck1010 FIND v(dout0_5) AT=510.025n

.meas tran vdout0_6ck1010 FIND v(dout0_6) AT=510.025n

.meas tran vdout0_7ck1010 FIND v(dout0_7) AT=510.025n

.meas tran vdout0_8ck1010 FIND v(dout0_8) AT=510.025n

.meas tran vdout0_9ck1010 FIND v(dout0_9) AT=510.025n

.meas tran vdout0_10ck1010 FIND v(dout0_10) AT=510.025n

.meas tran vdout0_11ck1010 FIND v(dout0_11) AT=510.025n

.meas tran vdout0_12ck1010 FIND v(dout0_12) AT=510.025n

.meas tran vdout0_13ck1010 FIND v(dout0_13) AT=510.025n

.meas tran vdout0_14ck1010 FIND v(dout0_14) AT=510.025n

.meas tran vdout0_15ck1010 FIND v(dout0_15) AT=510.025n

.meas tran vdout0_16ck1010 FIND v(dout0_16) AT=510.025n

.meas tran vdout0_17ck1010 FIND v(dout0_17) AT=510.025n

.meas tran vdout0_18ck1010 FIND v(dout0_18) AT=510.025n

.meas tran vdout0_19ck1010 FIND v(dout0_19) AT=510.025n

.meas tran vdout0_20ck1010 FIND v(dout0_20) AT=510.025n

.meas tran vdout0_21ck1010 FIND v(dout0_21) AT=510.025n

.meas tran vdout0_22ck1010 FIND v(dout0_22) AT=510.025n

.meas tran vdout0_23ck1010 FIND v(dout0_23) AT=510.025n

.meas tran vdout0_24ck1010 FIND v(dout0_24) AT=510.025n

.meas tran vdout0_25ck1010 FIND v(dout0_25) AT=510.025n

.meas tran vdout0_26ck1010 FIND v(dout0_26) AT=510.025n

.meas tran vdout0_27ck1010 FIND v(dout0_27) AT=510.025n

.meas tran vdout0_28ck1010 FIND v(dout0_28) AT=510.025n

.meas tran vdout0_29ck1010 FIND v(dout0_29) AT=510.025n

.meas tran vdout0_30ck1010 FIND v(dout0_30) AT=510.025n

.meas tran vdout0_31ck1010 FIND v(dout0_31) AT=510.025n

.meas tran vdout0_32ck1010 FIND v(dout0_32) AT=510.025n

.meas tran vdout0_33ck1010 FIND v(dout0_33) AT=510.025n

.meas tran vdout0_34ck1010 FIND v(dout0_34) AT=510.025n

.meas tran vdout0_35ck1010 FIND v(dout0_35) AT=510.025n

.meas tran vdout0_36ck1010 FIND v(dout0_36) AT=510.025n

.meas tran vdout0_37ck1010 FIND v(dout0_37) AT=510.025n

.meas tran vdout0_38ck1010 FIND v(dout0_38) AT=510.025n

.meas tran vdout0_39ck1010 FIND v(dout0_39) AT=510.025n

.meas tran vdout0_40ck1010 FIND v(dout0_40) AT=510.025n

.meas tran vdout0_41ck1010 FIND v(dout0_41) AT=510.025n

.meas tran vdout0_42ck1010 FIND v(dout0_42) AT=510.025n

.meas tran vdout0_43ck1010 FIND v(dout0_43) AT=510.025n

.meas tran vdout0_44ck1010 FIND v(dout0_44) AT=510.025n

.meas tran vdout0_45ck1010 FIND v(dout0_45) AT=510.025n

.meas tran vdout0_46ck1010 FIND v(dout0_46) AT=510.025n

.meas tran vdout0_47ck1010 FIND v(dout0_47) AT=510.025n

.meas tran vdout0_48ck1010 FIND v(dout0_48) AT=510.025n

.meas tran vdout0_49ck1010 FIND v(dout0_49) AT=510.025n

.meas tran vdout0_50ck1010 FIND v(dout0_50) AT=510.025n

.meas tran vdout0_51ck1010 FIND v(dout0_51) AT=510.025n

.meas tran vdout0_52ck1010 FIND v(dout0_52) AT=510.025n

.meas tran vdout0_53ck1010 FIND v(dout0_53) AT=510.025n

.meas tran vdout0_54ck1010 FIND v(dout0_54) AT=510.025n

.meas tran vdout0_55ck1010 FIND v(dout0_55) AT=510.025n

.meas tran vdout0_56ck1010 FIND v(dout0_56) AT=510.025n

.meas tran vdout0_57ck1010 FIND v(dout0_57) AT=510.025n

.meas tran vdout0_58ck1010 FIND v(dout0_58) AT=510.025n

.meas tran vdout0_59ck1010 FIND v(dout0_59) AT=510.025n

.meas tran vdout0_60ck1010 FIND v(dout0_60) AT=510.025n

.meas tran vdout0_61ck1010 FIND v(dout0_61) AT=510.025n

.meas tran vdout0_62ck1010 FIND v(dout0_62) AT=510.025n

.meas tran vdout0_63ck1010 FIND v(dout0_63) AT=510.025n

.meas tran vdout0_64ck1010 FIND v(dout0_64) AT=510.025n

.meas tran vdout0_65ck1010 FIND v(dout0_65) AT=510.025n

.meas tran vdout0_66ck1010 FIND v(dout0_66) AT=510.025n

.meas tran vdout0_67ck1010 FIND v(dout0_67) AT=510.025n

.meas tran vdout0_68ck1010 FIND v(dout0_68) AT=510.025n

.meas tran vdout0_69ck1010 FIND v(dout0_69) AT=510.025n

.meas tran vdout0_70ck1010 FIND v(dout0_70) AT=510.025n

.meas tran vdout0_71ck1010 FIND v(dout0_71) AT=510.025n

.meas tran vdout0_72ck1010 FIND v(dout0_72) AT=510.025n

.meas tran vdout0_73ck1010 FIND v(dout0_73) AT=510.025n

.meas tran vdout0_74ck1010 FIND v(dout0_74) AT=510.025n

.meas tran vdout0_75ck1010 FIND v(dout0_75) AT=510.025n

.meas tran vdout0_76ck1010 FIND v(dout0_76) AT=510.025n

.meas tran vdout0_77ck1010 FIND v(dout0_77) AT=510.025n

.meas tran vdout0_78ck1010 FIND v(dout0_78) AT=510.025n

.meas tran vdout0_79ck1010 FIND v(dout0_79) AT=510.025n

.meas tran vdout0_80ck1010 FIND v(dout0_80) AT=510.025n

.meas tran vdout0_81ck1010 FIND v(dout0_81) AT=510.025n

.meas tran vdout0_82ck1010 FIND v(dout0_82) AT=510.025n

.meas tran vdout0_83ck1010 FIND v(dout0_83) AT=510.025n

.meas tran vdout0_84ck1010 FIND v(dout0_84) AT=510.025n

.meas tran vdout0_85ck1010 FIND v(dout0_85) AT=510.025n

.meas tran vdout0_86ck1010 FIND v(dout0_86) AT=510.025n

.meas tran vdout0_87ck1010 FIND v(dout0_87) AT=510.025n

.meas tran vdout0_88ck1010 FIND v(dout0_88) AT=510.025n

.meas tran vdout0_89ck1010 FIND v(dout0_89) AT=510.025n

.meas tran vdout0_90ck1010 FIND v(dout0_90) AT=510.025n

.meas tran vdout0_91ck1010 FIND v(dout0_91) AT=510.025n

.meas tran vdout0_92ck1010 FIND v(dout0_92) AT=510.025n

.meas tran vdout0_93ck1010 FIND v(dout0_93) AT=510.025n

.meas tran vdout0_94ck1010 FIND v(dout0_94) AT=510.025n

.meas tran vdout0_95ck1010 FIND v(dout0_95) AT=510.025n

.meas tran vdout0_96ck1010 FIND v(dout0_96) AT=510.025n

.meas tran vdout0_97ck1010 FIND v(dout0_97) AT=510.025n

.meas tran vdout0_98ck1010 FIND v(dout0_98) AT=510.025n

.meas tran vdout0_99ck1010 FIND v(dout0_99) AT=510.025n

.meas tran vdout0_100ck1010 FIND v(dout0_100) AT=510.025n

.meas tran vdout0_101ck1010 FIND v(dout0_101) AT=510.025n

.meas tran vdout0_102ck1010 FIND v(dout0_102) AT=510.025n

.meas tran vdout0_103ck1010 FIND v(dout0_103) AT=510.025n

.meas tran vdout0_104ck1010 FIND v(dout0_104) AT=510.025n

.meas tran vdout0_105ck1010 FIND v(dout0_105) AT=510.025n

.meas tran vdout0_106ck1010 FIND v(dout0_106) AT=510.025n

.meas tran vdout0_107ck1010 FIND v(dout0_107) AT=510.025n

.meas tran vdout0_108ck1010 FIND v(dout0_108) AT=510.025n

.meas tran vdout0_109ck1010 FIND v(dout0_109) AT=510.025n

.meas tran vdout0_110ck1010 FIND v(dout0_110) AT=510.025n

.meas tran vdout0_111ck1010 FIND v(dout0_111) AT=510.025n

.meas tran vdout0_112ck1010 FIND v(dout0_112) AT=510.025n

.meas tran vdout0_113ck1010 FIND v(dout0_113) AT=510.025n

.meas tran vdout0_114ck1010 FIND v(dout0_114) AT=510.025n

.meas tran vdout0_115ck1010 FIND v(dout0_115) AT=510.025n

.meas tran vdout0_116ck1010 FIND v(dout0_116) AT=510.025n

.meas tran vdout0_117ck1010 FIND v(dout0_117) AT=510.025n

.meas tran vdout0_118ck1010 FIND v(dout0_118) AT=510.025n

.meas tran vdout0_119ck1010 FIND v(dout0_119) AT=510.025n

.meas tran vdout0_120ck1010 FIND v(dout0_120) AT=510.025n

.meas tran vdout0_121ck1010 FIND v(dout0_121) AT=510.025n

.meas tran vdout0_122ck1010 FIND v(dout0_122) AT=510.025n

.meas tran vdout0_123ck1010 FIND v(dout0_123) AT=510.025n

.meas tran vdout0_124ck1010 FIND v(dout0_124) AT=510.025n

.meas tran vdout0_125ck1010 FIND v(dout0_125) AT=510.025n

.meas tran vdout0_126ck1010 FIND v(dout0_126) AT=510.025n

.meas tran vdout0_127ck1010 FIND v(dout0_127) AT=510.025n

.meas tran vdout0_128ck1010 FIND v(dout0_128) AT=510.025n

.meas tran vdout0_129ck1010 FIND v(dout0_129) AT=510.025n

.meas tran vdout0_130ck1010 FIND v(dout0_130) AT=510.025n

.meas tran vdout0_131ck1010 FIND v(dout0_131) AT=510.025n

.meas tran vdout0_132ck1010 FIND v(dout0_132) AT=510.025n

.meas tran vdout0_133ck1010 FIND v(dout0_133) AT=510.025n

.meas tran vdout0_134ck1010 FIND v(dout0_134) AT=510.025n

.meas tran vdout0_135ck1010 FIND v(dout0_135) AT=510.025n

.meas tran vdout0_136ck1010 FIND v(dout0_136) AT=510.025n

.meas tran vdout0_137ck1010 FIND v(dout0_137) AT=510.025n

.meas tran vdout0_138ck1010 FIND v(dout0_138) AT=510.025n

.meas tran vdout0_139ck1010 FIND v(dout0_139) AT=510.025n

.meas tran vdout0_140ck1010 FIND v(dout0_140) AT=510.025n

.meas tran vdout0_141ck1010 FIND v(dout0_141) AT=510.025n

.meas tran vdout0_142ck1010 FIND v(dout0_142) AT=510.025n

.meas tran vdout0_143ck1010 FIND v(dout0_143) AT=510.025n

.meas tran vdout0_144ck1010 FIND v(dout0_144) AT=510.025n

.meas tran vdout0_145ck1010 FIND v(dout0_145) AT=510.025n

.meas tran vdout0_146ck1010 FIND v(dout0_146) AT=510.025n

.meas tran vdout0_147ck1010 FIND v(dout0_147) AT=510.025n

.meas tran vdout0_148ck1010 FIND v(dout0_148) AT=510.025n

.meas tran vdout0_149ck1010 FIND v(dout0_149) AT=510.025n

.meas tran vdout0_0ck1020 FIND v(dout0_0) AT=515.025n

.meas tran vdout0_1ck1020 FIND v(dout0_1) AT=515.025n

.meas tran vdout0_2ck1020 FIND v(dout0_2) AT=515.025n

.meas tran vdout0_3ck1020 FIND v(dout0_3) AT=515.025n

.meas tran vdout0_4ck1020 FIND v(dout0_4) AT=515.025n

.meas tran vdout0_5ck1020 FIND v(dout0_5) AT=515.025n

.meas tran vdout0_6ck1020 FIND v(dout0_6) AT=515.025n

.meas tran vdout0_7ck1020 FIND v(dout0_7) AT=515.025n

.meas tran vdout0_8ck1020 FIND v(dout0_8) AT=515.025n

.meas tran vdout0_9ck1020 FIND v(dout0_9) AT=515.025n

.meas tran vdout0_10ck1020 FIND v(dout0_10) AT=515.025n

.meas tran vdout0_11ck1020 FIND v(dout0_11) AT=515.025n

.meas tran vdout0_12ck1020 FIND v(dout0_12) AT=515.025n

.meas tran vdout0_13ck1020 FIND v(dout0_13) AT=515.025n

.meas tran vdout0_14ck1020 FIND v(dout0_14) AT=515.025n

.meas tran vdout0_15ck1020 FIND v(dout0_15) AT=515.025n

.meas tran vdout0_16ck1020 FIND v(dout0_16) AT=515.025n

.meas tran vdout0_17ck1020 FIND v(dout0_17) AT=515.025n

.meas tran vdout0_18ck1020 FIND v(dout0_18) AT=515.025n

.meas tran vdout0_19ck1020 FIND v(dout0_19) AT=515.025n

.meas tran vdout0_20ck1020 FIND v(dout0_20) AT=515.025n

.meas tran vdout0_21ck1020 FIND v(dout0_21) AT=515.025n

.meas tran vdout0_22ck1020 FIND v(dout0_22) AT=515.025n

.meas tran vdout0_23ck1020 FIND v(dout0_23) AT=515.025n

.meas tran vdout0_24ck1020 FIND v(dout0_24) AT=515.025n

.meas tran vdout0_25ck1020 FIND v(dout0_25) AT=515.025n

.meas tran vdout0_26ck1020 FIND v(dout0_26) AT=515.025n

.meas tran vdout0_27ck1020 FIND v(dout0_27) AT=515.025n

.meas tran vdout0_28ck1020 FIND v(dout0_28) AT=515.025n

.meas tran vdout0_29ck1020 FIND v(dout0_29) AT=515.025n

.meas tran vdout0_30ck1020 FIND v(dout0_30) AT=515.025n

.meas tran vdout0_31ck1020 FIND v(dout0_31) AT=515.025n

.meas tran vdout0_32ck1020 FIND v(dout0_32) AT=515.025n

.meas tran vdout0_33ck1020 FIND v(dout0_33) AT=515.025n

.meas tran vdout0_34ck1020 FIND v(dout0_34) AT=515.025n

.meas tran vdout0_35ck1020 FIND v(dout0_35) AT=515.025n

.meas tran vdout0_36ck1020 FIND v(dout0_36) AT=515.025n

.meas tran vdout0_37ck1020 FIND v(dout0_37) AT=515.025n

.meas tran vdout0_38ck1020 FIND v(dout0_38) AT=515.025n

.meas tran vdout0_39ck1020 FIND v(dout0_39) AT=515.025n

.meas tran vdout0_40ck1020 FIND v(dout0_40) AT=515.025n

.meas tran vdout0_41ck1020 FIND v(dout0_41) AT=515.025n

.meas tran vdout0_42ck1020 FIND v(dout0_42) AT=515.025n

.meas tran vdout0_43ck1020 FIND v(dout0_43) AT=515.025n

.meas tran vdout0_44ck1020 FIND v(dout0_44) AT=515.025n

.meas tran vdout0_45ck1020 FIND v(dout0_45) AT=515.025n

.meas tran vdout0_46ck1020 FIND v(dout0_46) AT=515.025n

.meas tran vdout0_47ck1020 FIND v(dout0_47) AT=515.025n

.meas tran vdout0_48ck1020 FIND v(dout0_48) AT=515.025n

.meas tran vdout0_49ck1020 FIND v(dout0_49) AT=515.025n

.meas tran vdout0_50ck1020 FIND v(dout0_50) AT=515.025n

.meas tran vdout0_51ck1020 FIND v(dout0_51) AT=515.025n

.meas tran vdout0_52ck1020 FIND v(dout0_52) AT=515.025n

.meas tran vdout0_53ck1020 FIND v(dout0_53) AT=515.025n

.meas tran vdout0_54ck1020 FIND v(dout0_54) AT=515.025n

.meas tran vdout0_55ck1020 FIND v(dout0_55) AT=515.025n

.meas tran vdout0_56ck1020 FIND v(dout0_56) AT=515.025n

.meas tran vdout0_57ck1020 FIND v(dout0_57) AT=515.025n

.meas tran vdout0_58ck1020 FIND v(dout0_58) AT=515.025n

.meas tran vdout0_59ck1020 FIND v(dout0_59) AT=515.025n

.meas tran vdout0_60ck1020 FIND v(dout0_60) AT=515.025n

.meas tran vdout0_61ck1020 FIND v(dout0_61) AT=515.025n

.meas tran vdout0_62ck1020 FIND v(dout0_62) AT=515.025n

.meas tran vdout0_63ck1020 FIND v(dout0_63) AT=515.025n

.meas tran vdout0_64ck1020 FIND v(dout0_64) AT=515.025n

.meas tran vdout0_65ck1020 FIND v(dout0_65) AT=515.025n

.meas tran vdout0_66ck1020 FIND v(dout0_66) AT=515.025n

.meas tran vdout0_67ck1020 FIND v(dout0_67) AT=515.025n

.meas tran vdout0_68ck1020 FIND v(dout0_68) AT=515.025n

.meas tran vdout0_69ck1020 FIND v(dout0_69) AT=515.025n

.meas tran vdout0_70ck1020 FIND v(dout0_70) AT=515.025n

.meas tran vdout0_71ck1020 FIND v(dout0_71) AT=515.025n

.meas tran vdout0_72ck1020 FIND v(dout0_72) AT=515.025n

.meas tran vdout0_73ck1020 FIND v(dout0_73) AT=515.025n

.meas tran vdout0_74ck1020 FIND v(dout0_74) AT=515.025n

.meas tran vdout0_75ck1020 FIND v(dout0_75) AT=515.025n

.meas tran vdout0_76ck1020 FIND v(dout0_76) AT=515.025n

.meas tran vdout0_77ck1020 FIND v(dout0_77) AT=515.025n

.meas tran vdout0_78ck1020 FIND v(dout0_78) AT=515.025n

.meas tran vdout0_79ck1020 FIND v(dout0_79) AT=515.025n

.meas tran vdout0_80ck1020 FIND v(dout0_80) AT=515.025n

.meas tran vdout0_81ck1020 FIND v(dout0_81) AT=515.025n

.meas tran vdout0_82ck1020 FIND v(dout0_82) AT=515.025n

.meas tran vdout0_83ck1020 FIND v(dout0_83) AT=515.025n

.meas tran vdout0_84ck1020 FIND v(dout0_84) AT=515.025n

.meas tran vdout0_85ck1020 FIND v(dout0_85) AT=515.025n

.meas tran vdout0_86ck1020 FIND v(dout0_86) AT=515.025n

.meas tran vdout0_87ck1020 FIND v(dout0_87) AT=515.025n

.meas tran vdout0_88ck1020 FIND v(dout0_88) AT=515.025n

.meas tran vdout0_89ck1020 FIND v(dout0_89) AT=515.025n

.meas tran vdout0_90ck1020 FIND v(dout0_90) AT=515.025n

.meas tran vdout0_91ck1020 FIND v(dout0_91) AT=515.025n

.meas tran vdout0_92ck1020 FIND v(dout0_92) AT=515.025n

.meas tran vdout0_93ck1020 FIND v(dout0_93) AT=515.025n

.meas tran vdout0_94ck1020 FIND v(dout0_94) AT=515.025n

.meas tran vdout0_95ck1020 FIND v(dout0_95) AT=515.025n

.meas tran vdout0_96ck1020 FIND v(dout0_96) AT=515.025n

.meas tran vdout0_97ck1020 FIND v(dout0_97) AT=515.025n

.meas tran vdout0_98ck1020 FIND v(dout0_98) AT=515.025n

.meas tran vdout0_99ck1020 FIND v(dout0_99) AT=515.025n

.meas tran vdout0_100ck1020 FIND v(dout0_100) AT=515.025n

.meas tran vdout0_101ck1020 FIND v(dout0_101) AT=515.025n

.meas tran vdout0_102ck1020 FIND v(dout0_102) AT=515.025n

.meas tran vdout0_103ck1020 FIND v(dout0_103) AT=515.025n

.meas tran vdout0_104ck1020 FIND v(dout0_104) AT=515.025n

.meas tran vdout0_105ck1020 FIND v(dout0_105) AT=515.025n

.meas tran vdout0_106ck1020 FIND v(dout0_106) AT=515.025n

.meas tran vdout0_107ck1020 FIND v(dout0_107) AT=515.025n

.meas tran vdout0_108ck1020 FIND v(dout0_108) AT=515.025n

.meas tran vdout0_109ck1020 FIND v(dout0_109) AT=515.025n

.meas tran vdout0_110ck1020 FIND v(dout0_110) AT=515.025n

.meas tran vdout0_111ck1020 FIND v(dout0_111) AT=515.025n

.meas tran vdout0_112ck1020 FIND v(dout0_112) AT=515.025n

.meas tran vdout0_113ck1020 FIND v(dout0_113) AT=515.025n

.meas tran vdout0_114ck1020 FIND v(dout0_114) AT=515.025n

.meas tran vdout0_115ck1020 FIND v(dout0_115) AT=515.025n

.meas tran vdout0_116ck1020 FIND v(dout0_116) AT=515.025n

.meas tran vdout0_117ck1020 FIND v(dout0_117) AT=515.025n

.meas tran vdout0_118ck1020 FIND v(dout0_118) AT=515.025n

.meas tran vdout0_119ck1020 FIND v(dout0_119) AT=515.025n

.meas tran vdout0_120ck1020 FIND v(dout0_120) AT=515.025n

.meas tran vdout0_121ck1020 FIND v(dout0_121) AT=515.025n

.meas tran vdout0_122ck1020 FIND v(dout0_122) AT=515.025n

.meas tran vdout0_123ck1020 FIND v(dout0_123) AT=515.025n

.meas tran vdout0_124ck1020 FIND v(dout0_124) AT=515.025n

.meas tran vdout0_125ck1020 FIND v(dout0_125) AT=515.025n

.meas tran vdout0_126ck1020 FIND v(dout0_126) AT=515.025n

.meas tran vdout0_127ck1020 FIND v(dout0_127) AT=515.025n

.meas tran vdout0_128ck1020 FIND v(dout0_128) AT=515.025n

.meas tran vdout0_129ck1020 FIND v(dout0_129) AT=515.025n

.meas tran vdout0_130ck1020 FIND v(dout0_130) AT=515.025n

.meas tran vdout0_131ck1020 FIND v(dout0_131) AT=515.025n

.meas tran vdout0_132ck1020 FIND v(dout0_132) AT=515.025n

.meas tran vdout0_133ck1020 FIND v(dout0_133) AT=515.025n

.meas tran vdout0_134ck1020 FIND v(dout0_134) AT=515.025n

.meas tran vdout0_135ck1020 FIND v(dout0_135) AT=515.025n

.meas tran vdout0_136ck1020 FIND v(dout0_136) AT=515.025n

.meas tran vdout0_137ck1020 FIND v(dout0_137) AT=515.025n

.meas tran vdout0_138ck1020 FIND v(dout0_138) AT=515.025n

.meas tran vdout0_139ck1020 FIND v(dout0_139) AT=515.025n

.meas tran vdout0_140ck1020 FIND v(dout0_140) AT=515.025n

.meas tran vdout0_141ck1020 FIND v(dout0_141) AT=515.025n

.meas tran vdout0_142ck1020 FIND v(dout0_142) AT=515.025n

.meas tran vdout0_143ck1020 FIND v(dout0_143) AT=515.025n

.meas tran vdout0_144ck1020 FIND v(dout0_144) AT=515.025n

.meas tran vdout0_145ck1020 FIND v(dout0_145) AT=515.025n

.meas tran vdout0_146ck1020 FIND v(dout0_146) AT=515.025n

.meas tran vdout0_147ck1020 FIND v(dout0_147) AT=515.025n

.meas tran vdout0_148ck1020 FIND v(dout0_148) AT=515.025n

.meas tran vdout0_149ck1020 FIND v(dout0_149) AT=515.025n

.meas tran vdout0_0ck1030 FIND v(dout0_0) AT=520.025n

.meas tran vdout0_1ck1030 FIND v(dout0_1) AT=520.025n

.meas tran vdout0_2ck1030 FIND v(dout0_2) AT=520.025n

.meas tran vdout0_3ck1030 FIND v(dout0_3) AT=520.025n

.meas tran vdout0_4ck1030 FIND v(dout0_4) AT=520.025n

.meas tran vdout0_5ck1030 FIND v(dout0_5) AT=520.025n

.meas tran vdout0_6ck1030 FIND v(dout0_6) AT=520.025n

.meas tran vdout0_7ck1030 FIND v(dout0_7) AT=520.025n

.meas tran vdout0_8ck1030 FIND v(dout0_8) AT=520.025n

.meas tran vdout0_9ck1030 FIND v(dout0_9) AT=520.025n

.meas tran vdout0_10ck1030 FIND v(dout0_10) AT=520.025n

.meas tran vdout0_11ck1030 FIND v(dout0_11) AT=520.025n

.meas tran vdout0_12ck1030 FIND v(dout0_12) AT=520.025n

.meas tran vdout0_13ck1030 FIND v(dout0_13) AT=520.025n

.meas tran vdout0_14ck1030 FIND v(dout0_14) AT=520.025n

.meas tran vdout0_15ck1030 FIND v(dout0_15) AT=520.025n

.meas tran vdout0_16ck1030 FIND v(dout0_16) AT=520.025n

.meas tran vdout0_17ck1030 FIND v(dout0_17) AT=520.025n

.meas tran vdout0_18ck1030 FIND v(dout0_18) AT=520.025n

.meas tran vdout0_19ck1030 FIND v(dout0_19) AT=520.025n

.meas tran vdout0_20ck1030 FIND v(dout0_20) AT=520.025n

.meas tran vdout0_21ck1030 FIND v(dout0_21) AT=520.025n

.meas tran vdout0_22ck1030 FIND v(dout0_22) AT=520.025n

.meas tran vdout0_23ck1030 FIND v(dout0_23) AT=520.025n

.meas tran vdout0_24ck1030 FIND v(dout0_24) AT=520.025n

.meas tran vdout0_25ck1030 FIND v(dout0_25) AT=520.025n

.meas tran vdout0_26ck1030 FIND v(dout0_26) AT=520.025n

.meas tran vdout0_27ck1030 FIND v(dout0_27) AT=520.025n

.meas tran vdout0_28ck1030 FIND v(dout0_28) AT=520.025n

.meas tran vdout0_29ck1030 FIND v(dout0_29) AT=520.025n

.meas tran vdout0_30ck1030 FIND v(dout0_30) AT=520.025n

.meas tran vdout0_31ck1030 FIND v(dout0_31) AT=520.025n

.meas tran vdout0_32ck1030 FIND v(dout0_32) AT=520.025n

.meas tran vdout0_33ck1030 FIND v(dout0_33) AT=520.025n

.meas tran vdout0_34ck1030 FIND v(dout0_34) AT=520.025n

.meas tran vdout0_35ck1030 FIND v(dout0_35) AT=520.025n

.meas tran vdout0_36ck1030 FIND v(dout0_36) AT=520.025n

.meas tran vdout0_37ck1030 FIND v(dout0_37) AT=520.025n

.meas tran vdout0_38ck1030 FIND v(dout0_38) AT=520.025n

.meas tran vdout0_39ck1030 FIND v(dout0_39) AT=520.025n

.meas tran vdout0_40ck1030 FIND v(dout0_40) AT=520.025n

.meas tran vdout0_41ck1030 FIND v(dout0_41) AT=520.025n

.meas tran vdout0_42ck1030 FIND v(dout0_42) AT=520.025n

.meas tran vdout0_43ck1030 FIND v(dout0_43) AT=520.025n

.meas tran vdout0_44ck1030 FIND v(dout0_44) AT=520.025n

.meas tran vdout0_45ck1030 FIND v(dout0_45) AT=520.025n

.meas tran vdout0_46ck1030 FIND v(dout0_46) AT=520.025n

.meas tran vdout0_47ck1030 FIND v(dout0_47) AT=520.025n

.meas tran vdout0_48ck1030 FIND v(dout0_48) AT=520.025n

.meas tran vdout0_49ck1030 FIND v(dout0_49) AT=520.025n

.meas tran vdout0_50ck1030 FIND v(dout0_50) AT=520.025n

.meas tran vdout0_51ck1030 FIND v(dout0_51) AT=520.025n

.meas tran vdout0_52ck1030 FIND v(dout0_52) AT=520.025n

.meas tran vdout0_53ck1030 FIND v(dout0_53) AT=520.025n

.meas tran vdout0_54ck1030 FIND v(dout0_54) AT=520.025n

.meas tran vdout0_55ck1030 FIND v(dout0_55) AT=520.025n

.meas tran vdout0_56ck1030 FIND v(dout0_56) AT=520.025n

.meas tran vdout0_57ck1030 FIND v(dout0_57) AT=520.025n

.meas tran vdout0_58ck1030 FIND v(dout0_58) AT=520.025n

.meas tran vdout0_59ck1030 FIND v(dout0_59) AT=520.025n

.meas tran vdout0_60ck1030 FIND v(dout0_60) AT=520.025n

.meas tran vdout0_61ck1030 FIND v(dout0_61) AT=520.025n

.meas tran vdout0_62ck1030 FIND v(dout0_62) AT=520.025n

.meas tran vdout0_63ck1030 FIND v(dout0_63) AT=520.025n

.meas tran vdout0_64ck1030 FIND v(dout0_64) AT=520.025n

.meas tran vdout0_65ck1030 FIND v(dout0_65) AT=520.025n

.meas tran vdout0_66ck1030 FIND v(dout0_66) AT=520.025n

.meas tran vdout0_67ck1030 FIND v(dout0_67) AT=520.025n

.meas tran vdout0_68ck1030 FIND v(dout0_68) AT=520.025n

.meas tran vdout0_69ck1030 FIND v(dout0_69) AT=520.025n

.meas tran vdout0_70ck1030 FIND v(dout0_70) AT=520.025n

.meas tran vdout0_71ck1030 FIND v(dout0_71) AT=520.025n

.meas tran vdout0_72ck1030 FIND v(dout0_72) AT=520.025n

.meas tran vdout0_73ck1030 FIND v(dout0_73) AT=520.025n

.meas tran vdout0_74ck1030 FIND v(dout0_74) AT=520.025n

.meas tran vdout0_75ck1030 FIND v(dout0_75) AT=520.025n

.meas tran vdout0_76ck1030 FIND v(dout0_76) AT=520.025n

.meas tran vdout0_77ck1030 FIND v(dout0_77) AT=520.025n

.meas tran vdout0_78ck1030 FIND v(dout0_78) AT=520.025n

.meas tran vdout0_79ck1030 FIND v(dout0_79) AT=520.025n

.meas tran vdout0_80ck1030 FIND v(dout0_80) AT=520.025n

.meas tran vdout0_81ck1030 FIND v(dout0_81) AT=520.025n

.meas tran vdout0_82ck1030 FIND v(dout0_82) AT=520.025n

.meas tran vdout0_83ck1030 FIND v(dout0_83) AT=520.025n

.meas tran vdout0_84ck1030 FIND v(dout0_84) AT=520.025n

.meas tran vdout0_85ck1030 FIND v(dout0_85) AT=520.025n

.meas tran vdout0_86ck1030 FIND v(dout0_86) AT=520.025n

.meas tran vdout0_87ck1030 FIND v(dout0_87) AT=520.025n

.meas tran vdout0_88ck1030 FIND v(dout0_88) AT=520.025n

.meas tran vdout0_89ck1030 FIND v(dout0_89) AT=520.025n

.meas tran vdout0_90ck1030 FIND v(dout0_90) AT=520.025n

.meas tran vdout0_91ck1030 FIND v(dout0_91) AT=520.025n

.meas tran vdout0_92ck1030 FIND v(dout0_92) AT=520.025n

.meas tran vdout0_93ck1030 FIND v(dout0_93) AT=520.025n

.meas tran vdout0_94ck1030 FIND v(dout0_94) AT=520.025n

.meas tran vdout0_95ck1030 FIND v(dout0_95) AT=520.025n

.meas tran vdout0_96ck1030 FIND v(dout0_96) AT=520.025n

.meas tran vdout0_97ck1030 FIND v(dout0_97) AT=520.025n

.meas tran vdout0_98ck1030 FIND v(dout0_98) AT=520.025n

.meas tran vdout0_99ck1030 FIND v(dout0_99) AT=520.025n

.meas tran vdout0_100ck1030 FIND v(dout0_100) AT=520.025n

.meas tran vdout0_101ck1030 FIND v(dout0_101) AT=520.025n

.meas tran vdout0_102ck1030 FIND v(dout0_102) AT=520.025n

.meas tran vdout0_103ck1030 FIND v(dout0_103) AT=520.025n

.meas tran vdout0_104ck1030 FIND v(dout0_104) AT=520.025n

.meas tran vdout0_105ck1030 FIND v(dout0_105) AT=520.025n

.meas tran vdout0_106ck1030 FIND v(dout0_106) AT=520.025n

.meas tran vdout0_107ck1030 FIND v(dout0_107) AT=520.025n

.meas tran vdout0_108ck1030 FIND v(dout0_108) AT=520.025n

.meas tran vdout0_109ck1030 FIND v(dout0_109) AT=520.025n

.meas tran vdout0_110ck1030 FIND v(dout0_110) AT=520.025n

.meas tran vdout0_111ck1030 FIND v(dout0_111) AT=520.025n

.meas tran vdout0_112ck1030 FIND v(dout0_112) AT=520.025n

.meas tran vdout0_113ck1030 FIND v(dout0_113) AT=520.025n

.meas tran vdout0_114ck1030 FIND v(dout0_114) AT=520.025n

.meas tran vdout0_115ck1030 FIND v(dout0_115) AT=520.025n

.meas tran vdout0_116ck1030 FIND v(dout0_116) AT=520.025n

.meas tran vdout0_117ck1030 FIND v(dout0_117) AT=520.025n

.meas tran vdout0_118ck1030 FIND v(dout0_118) AT=520.025n

.meas tran vdout0_119ck1030 FIND v(dout0_119) AT=520.025n

.meas tran vdout0_120ck1030 FIND v(dout0_120) AT=520.025n

.meas tran vdout0_121ck1030 FIND v(dout0_121) AT=520.025n

.meas tran vdout0_122ck1030 FIND v(dout0_122) AT=520.025n

.meas tran vdout0_123ck1030 FIND v(dout0_123) AT=520.025n

.meas tran vdout0_124ck1030 FIND v(dout0_124) AT=520.025n

.meas tran vdout0_125ck1030 FIND v(dout0_125) AT=520.025n

.meas tran vdout0_126ck1030 FIND v(dout0_126) AT=520.025n

.meas tran vdout0_127ck1030 FIND v(dout0_127) AT=520.025n

.meas tran vdout0_128ck1030 FIND v(dout0_128) AT=520.025n

.meas tran vdout0_129ck1030 FIND v(dout0_129) AT=520.025n

.meas tran vdout0_130ck1030 FIND v(dout0_130) AT=520.025n

.meas tran vdout0_131ck1030 FIND v(dout0_131) AT=520.025n

.meas tran vdout0_132ck1030 FIND v(dout0_132) AT=520.025n

.meas tran vdout0_133ck1030 FIND v(dout0_133) AT=520.025n

.meas tran vdout0_134ck1030 FIND v(dout0_134) AT=520.025n

.meas tran vdout0_135ck1030 FIND v(dout0_135) AT=520.025n

.meas tran vdout0_136ck1030 FIND v(dout0_136) AT=520.025n

.meas tran vdout0_137ck1030 FIND v(dout0_137) AT=520.025n

.meas tran vdout0_138ck1030 FIND v(dout0_138) AT=520.025n

.meas tran vdout0_139ck1030 FIND v(dout0_139) AT=520.025n

.meas tran vdout0_140ck1030 FIND v(dout0_140) AT=520.025n

.meas tran vdout0_141ck1030 FIND v(dout0_141) AT=520.025n

.meas tran vdout0_142ck1030 FIND v(dout0_142) AT=520.025n

.meas tran vdout0_143ck1030 FIND v(dout0_143) AT=520.025n

.meas tran vdout0_144ck1030 FIND v(dout0_144) AT=520.025n

.meas tran vdout0_145ck1030 FIND v(dout0_145) AT=520.025n

.meas tran vdout0_146ck1030 FIND v(dout0_146) AT=520.025n

.meas tran vdout0_147ck1030 FIND v(dout0_147) AT=520.025n

.meas tran vdout0_148ck1030 FIND v(dout0_148) AT=520.025n

.meas tran vdout0_149ck1030 FIND v(dout0_149) AT=520.025n

.meas tran vdout0_0ck1070 FIND v(dout0_0) AT=540.025n

.meas tran vdout0_1ck1070 FIND v(dout0_1) AT=540.025n

.meas tran vdout0_2ck1070 FIND v(dout0_2) AT=540.025n

.meas tran vdout0_3ck1070 FIND v(dout0_3) AT=540.025n

.meas tran vdout0_4ck1070 FIND v(dout0_4) AT=540.025n

.meas tran vdout0_5ck1070 FIND v(dout0_5) AT=540.025n

.meas tran vdout0_6ck1070 FIND v(dout0_6) AT=540.025n

.meas tran vdout0_7ck1070 FIND v(dout0_7) AT=540.025n

.meas tran vdout0_8ck1070 FIND v(dout0_8) AT=540.025n

.meas tran vdout0_9ck1070 FIND v(dout0_9) AT=540.025n

.meas tran vdout0_10ck1070 FIND v(dout0_10) AT=540.025n

.meas tran vdout0_11ck1070 FIND v(dout0_11) AT=540.025n

.meas tran vdout0_12ck1070 FIND v(dout0_12) AT=540.025n

.meas tran vdout0_13ck1070 FIND v(dout0_13) AT=540.025n

.meas tran vdout0_14ck1070 FIND v(dout0_14) AT=540.025n

.meas tran vdout0_15ck1070 FIND v(dout0_15) AT=540.025n

.meas tran vdout0_16ck1070 FIND v(dout0_16) AT=540.025n

.meas tran vdout0_17ck1070 FIND v(dout0_17) AT=540.025n

.meas tran vdout0_18ck1070 FIND v(dout0_18) AT=540.025n

.meas tran vdout0_19ck1070 FIND v(dout0_19) AT=540.025n

.meas tran vdout0_20ck1070 FIND v(dout0_20) AT=540.025n

.meas tran vdout0_21ck1070 FIND v(dout0_21) AT=540.025n

.meas tran vdout0_22ck1070 FIND v(dout0_22) AT=540.025n

.meas tran vdout0_23ck1070 FIND v(dout0_23) AT=540.025n

.meas tran vdout0_24ck1070 FIND v(dout0_24) AT=540.025n

.meas tran vdout0_25ck1070 FIND v(dout0_25) AT=540.025n

.meas tran vdout0_26ck1070 FIND v(dout0_26) AT=540.025n

.meas tran vdout0_27ck1070 FIND v(dout0_27) AT=540.025n

.meas tran vdout0_28ck1070 FIND v(dout0_28) AT=540.025n

.meas tran vdout0_29ck1070 FIND v(dout0_29) AT=540.025n

.meas tran vdout0_30ck1070 FIND v(dout0_30) AT=540.025n

.meas tran vdout0_31ck1070 FIND v(dout0_31) AT=540.025n

.meas tran vdout0_32ck1070 FIND v(dout0_32) AT=540.025n

.meas tran vdout0_33ck1070 FIND v(dout0_33) AT=540.025n

.meas tran vdout0_34ck1070 FIND v(dout0_34) AT=540.025n

.meas tran vdout0_35ck1070 FIND v(dout0_35) AT=540.025n

.meas tran vdout0_36ck1070 FIND v(dout0_36) AT=540.025n

.meas tran vdout0_37ck1070 FIND v(dout0_37) AT=540.025n

.meas tran vdout0_38ck1070 FIND v(dout0_38) AT=540.025n

.meas tran vdout0_39ck1070 FIND v(dout0_39) AT=540.025n

.meas tran vdout0_40ck1070 FIND v(dout0_40) AT=540.025n

.meas tran vdout0_41ck1070 FIND v(dout0_41) AT=540.025n

.meas tran vdout0_42ck1070 FIND v(dout0_42) AT=540.025n

.meas tran vdout0_43ck1070 FIND v(dout0_43) AT=540.025n

.meas tran vdout0_44ck1070 FIND v(dout0_44) AT=540.025n

.meas tran vdout0_45ck1070 FIND v(dout0_45) AT=540.025n

.meas tran vdout0_46ck1070 FIND v(dout0_46) AT=540.025n

.meas tran vdout0_47ck1070 FIND v(dout0_47) AT=540.025n

.meas tran vdout0_48ck1070 FIND v(dout0_48) AT=540.025n

.meas tran vdout0_49ck1070 FIND v(dout0_49) AT=540.025n

.meas tran vdout0_50ck1070 FIND v(dout0_50) AT=540.025n

.meas tran vdout0_51ck1070 FIND v(dout0_51) AT=540.025n

.meas tran vdout0_52ck1070 FIND v(dout0_52) AT=540.025n

.meas tran vdout0_53ck1070 FIND v(dout0_53) AT=540.025n

.meas tran vdout0_54ck1070 FIND v(dout0_54) AT=540.025n

.meas tran vdout0_55ck1070 FIND v(dout0_55) AT=540.025n

.meas tran vdout0_56ck1070 FIND v(dout0_56) AT=540.025n

.meas tran vdout0_57ck1070 FIND v(dout0_57) AT=540.025n

.meas tran vdout0_58ck1070 FIND v(dout0_58) AT=540.025n

.meas tran vdout0_59ck1070 FIND v(dout0_59) AT=540.025n

.meas tran vdout0_60ck1070 FIND v(dout0_60) AT=540.025n

.meas tran vdout0_61ck1070 FIND v(dout0_61) AT=540.025n

.meas tran vdout0_62ck1070 FIND v(dout0_62) AT=540.025n

.meas tran vdout0_63ck1070 FIND v(dout0_63) AT=540.025n

.meas tran vdout0_64ck1070 FIND v(dout0_64) AT=540.025n

.meas tran vdout0_65ck1070 FIND v(dout0_65) AT=540.025n

.meas tran vdout0_66ck1070 FIND v(dout0_66) AT=540.025n

.meas tran vdout0_67ck1070 FIND v(dout0_67) AT=540.025n

.meas tran vdout0_68ck1070 FIND v(dout0_68) AT=540.025n

.meas tran vdout0_69ck1070 FIND v(dout0_69) AT=540.025n

.meas tran vdout0_70ck1070 FIND v(dout0_70) AT=540.025n

.meas tran vdout0_71ck1070 FIND v(dout0_71) AT=540.025n

.meas tran vdout0_72ck1070 FIND v(dout0_72) AT=540.025n

.meas tran vdout0_73ck1070 FIND v(dout0_73) AT=540.025n

.meas tran vdout0_74ck1070 FIND v(dout0_74) AT=540.025n

.meas tran vdout0_75ck1070 FIND v(dout0_75) AT=540.025n

.meas tran vdout0_76ck1070 FIND v(dout0_76) AT=540.025n

.meas tran vdout0_77ck1070 FIND v(dout0_77) AT=540.025n

.meas tran vdout0_78ck1070 FIND v(dout0_78) AT=540.025n

.meas tran vdout0_79ck1070 FIND v(dout0_79) AT=540.025n

.meas tran vdout0_80ck1070 FIND v(dout0_80) AT=540.025n

.meas tran vdout0_81ck1070 FIND v(dout0_81) AT=540.025n

.meas tran vdout0_82ck1070 FIND v(dout0_82) AT=540.025n

.meas tran vdout0_83ck1070 FIND v(dout0_83) AT=540.025n

.meas tran vdout0_84ck1070 FIND v(dout0_84) AT=540.025n

.meas tran vdout0_85ck1070 FIND v(dout0_85) AT=540.025n

.meas tran vdout0_86ck1070 FIND v(dout0_86) AT=540.025n

.meas tran vdout0_87ck1070 FIND v(dout0_87) AT=540.025n

.meas tran vdout0_88ck1070 FIND v(dout0_88) AT=540.025n

.meas tran vdout0_89ck1070 FIND v(dout0_89) AT=540.025n

.meas tran vdout0_90ck1070 FIND v(dout0_90) AT=540.025n

.meas tran vdout0_91ck1070 FIND v(dout0_91) AT=540.025n

.meas tran vdout0_92ck1070 FIND v(dout0_92) AT=540.025n

.meas tran vdout0_93ck1070 FIND v(dout0_93) AT=540.025n

.meas tran vdout0_94ck1070 FIND v(dout0_94) AT=540.025n

.meas tran vdout0_95ck1070 FIND v(dout0_95) AT=540.025n

.meas tran vdout0_96ck1070 FIND v(dout0_96) AT=540.025n

.meas tran vdout0_97ck1070 FIND v(dout0_97) AT=540.025n

.meas tran vdout0_98ck1070 FIND v(dout0_98) AT=540.025n

.meas tran vdout0_99ck1070 FIND v(dout0_99) AT=540.025n

.meas tran vdout0_100ck1070 FIND v(dout0_100) AT=540.025n

.meas tran vdout0_101ck1070 FIND v(dout0_101) AT=540.025n

.meas tran vdout0_102ck1070 FIND v(dout0_102) AT=540.025n

.meas tran vdout0_103ck1070 FIND v(dout0_103) AT=540.025n

.meas tran vdout0_104ck1070 FIND v(dout0_104) AT=540.025n

.meas tran vdout0_105ck1070 FIND v(dout0_105) AT=540.025n

.meas tran vdout0_106ck1070 FIND v(dout0_106) AT=540.025n

.meas tran vdout0_107ck1070 FIND v(dout0_107) AT=540.025n

.meas tran vdout0_108ck1070 FIND v(dout0_108) AT=540.025n

.meas tran vdout0_109ck1070 FIND v(dout0_109) AT=540.025n

.meas tran vdout0_110ck1070 FIND v(dout0_110) AT=540.025n

.meas tran vdout0_111ck1070 FIND v(dout0_111) AT=540.025n

.meas tran vdout0_112ck1070 FIND v(dout0_112) AT=540.025n

.meas tran vdout0_113ck1070 FIND v(dout0_113) AT=540.025n

.meas tran vdout0_114ck1070 FIND v(dout0_114) AT=540.025n

.meas tran vdout0_115ck1070 FIND v(dout0_115) AT=540.025n

.meas tran vdout0_116ck1070 FIND v(dout0_116) AT=540.025n

.meas tran vdout0_117ck1070 FIND v(dout0_117) AT=540.025n

.meas tran vdout0_118ck1070 FIND v(dout0_118) AT=540.025n

.meas tran vdout0_119ck1070 FIND v(dout0_119) AT=540.025n

.meas tran vdout0_120ck1070 FIND v(dout0_120) AT=540.025n

.meas tran vdout0_121ck1070 FIND v(dout0_121) AT=540.025n

.meas tran vdout0_122ck1070 FIND v(dout0_122) AT=540.025n

.meas tran vdout0_123ck1070 FIND v(dout0_123) AT=540.025n

.meas tran vdout0_124ck1070 FIND v(dout0_124) AT=540.025n

.meas tran vdout0_125ck1070 FIND v(dout0_125) AT=540.025n

.meas tran vdout0_126ck1070 FIND v(dout0_126) AT=540.025n

.meas tran vdout0_127ck1070 FIND v(dout0_127) AT=540.025n

.meas tran vdout0_128ck1070 FIND v(dout0_128) AT=540.025n

.meas tran vdout0_129ck1070 FIND v(dout0_129) AT=540.025n

.meas tran vdout0_130ck1070 FIND v(dout0_130) AT=540.025n

.meas tran vdout0_131ck1070 FIND v(dout0_131) AT=540.025n

.meas tran vdout0_132ck1070 FIND v(dout0_132) AT=540.025n

.meas tran vdout0_133ck1070 FIND v(dout0_133) AT=540.025n

.meas tran vdout0_134ck1070 FIND v(dout0_134) AT=540.025n

.meas tran vdout0_135ck1070 FIND v(dout0_135) AT=540.025n

.meas tran vdout0_136ck1070 FIND v(dout0_136) AT=540.025n

.meas tran vdout0_137ck1070 FIND v(dout0_137) AT=540.025n

.meas tran vdout0_138ck1070 FIND v(dout0_138) AT=540.025n

.meas tran vdout0_139ck1070 FIND v(dout0_139) AT=540.025n

.meas tran vdout0_140ck1070 FIND v(dout0_140) AT=540.025n

.meas tran vdout0_141ck1070 FIND v(dout0_141) AT=540.025n

.meas tran vdout0_142ck1070 FIND v(dout0_142) AT=540.025n

.meas tran vdout0_143ck1070 FIND v(dout0_143) AT=540.025n

.meas tran vdout0_144ck1070 FIND v(dout0_144) AT=540.025n

.meas tran vdout0_145ck1070 FIND v(dout0_145) AT=540.025n

.meas tran vdout0_146ck1070 FIND v(dout0_146) AT=540.025n

.meas tran vdout0_147ck1070 FIND v(dout0_147) AT=540.025n

.meas tran vdout0_148ck1070 FIND v(dout0_148) AT=540.025n

.meas tran vdout0_149ck1070 FIND v(dout0_149) AT=540.025n

.meas tran vdout0_0ck1120 FIND v(dout0_0) AT=565.025n

.meas tran vdout0_1ck1120 FIND v(dout0_1) AT=565.025n

.meas tran vdout0_2ck1120 FIND v(dout0_2) AT=565.025n

.meas tran vdout0_3ck1120 FIND v(dout0_3) AT=565.025n

.meas tran vdout0_4ck1120 FIND v(dout0_4) AT=565.025n

.meas tran vdout0_5ck1120 FIND v(dout0_5) AT=565.025n

.meas tran vdout0_6ck1120 FIND v(dout0_6) AT=565.025n

.meas tran vdout0_7ck1120 FIND v(dout0_7) AT=565.025n

.meas tran vdout0_8ck1120 FIND v(dout0_8) AT=565.025n

.meas tran vdout0_9ck1120 FIND v(dout0_9) AT=565.025n

.meas tran vdout0_10ck1120 FIND v(dout0_10) AT=565.025n

.meas tran vdout0_11ck1120 FIND v(dout0_11) AT=565.025n

.meas tran vdout0_12ck1120 FIND v(dout0_12) AT=565.025n

.meas tran vdout0_13ck1120 FIND v(dout0_13) AT=565.025n

.meas tran vdout0_14ck1120 FIND v(dout0_14) AT=565.025n

.meas tran vdout0_15ck1120 FIND v(dout0_15) AT=565.025n

.meas tran vdout0_16ck1120 FIND v(dout0_16) AT=565.025n

.meas tran vdout0_17ck1120 FIND v(dout0_17) AT=565.025n

.meas tran vdout0_18ck1120 FIND v(dout0_18) AT=565.025n

.meas tran vdout0_19ck1120 FIND v(dout0_19) AT=565.025n

.meas tran vdout0_20ck1120 FIND v(dout0_20) AT=565.025n

.meas tran vdout0_21ck1120 FIND v(dout0_21) AT=565.025n

.meas tran vdout0_22ck1120 FIND v(dout0_22) AT=565.025n

.meas tran vdout0_23ck1120 FIND v(dout0_23) AT=565.025n

.meas tran vdout0_24ck1120 FIND v(dout0_24) AT=565.025n

.meas tran vdout0_25ck1120 FIND v(dout0_25) AT=565.025n

.meas tran vdout0_26ck1120 FIND v(dout0_26) AT=565.025n

.meas tran vdout0_27ck1120 FIND v(dout0_27) AT=565.025n

.meas tran vdout0_28ck1120 FIND v(dout0_28) AT=565.025n

.meas tran vdout0_29ck1120 FIND v(dout0_29) AT=565.025n

.meas tran vdout0_30ck1120 FIND v(dout0_30) AT=565.025n

.meas tran vdout0_31ck1120 FIND v(dout0_31) AT=565.025n

.meas tran vdout0_32ck1120 FIND v(dout0_32) AT=565.025n

.meas tran vdout0_33ck1120 FIND v(dout0_33) AT=565.025n

.meas tran vdout0_34ck1120 FIND v(dout0_34) AT=565.025n

.meas tran vdout0_35ck1120 FIND v(dout0_35) AT=565.025n

.meas tran vdout0_36ck1120 FIND v(dout0_36) AT=565.025n

.meas tran vdout0_37ck1120 FIND v(dout0_37) AT=565.025n

.meas tran vdout0_38ck1120 FIND v(dout0_38) AT=565.025n

.meas tran vdout0_39ck1120 FIND v(dout0_39) AT=565.025n

.meas tran vdout0_40ck1120 FIND v(dout0_40) AT=565.025n

.meas tran vdout0_41ck1120 FIND v(dout0_41) AT=565.025n

.meas tran vdout0_42ck1120 FIND v(dout0_42) AT=565.025n

.meas tran vdout0_43ck1120 FIND v(dout0_43) AT=565.025n

.meas tran vdout0_44ck1120 FIND v(dout0_44) AT=565.025n

.meas tran vdout0_45ck1120 FIND v(dout0_45) AT=565.025n

.meas tran vdout0_46ck1120 FIND v(dout0_46) AT=565.025n

.meas tran vdout0_47ck1120 FIND v(dout0_47) AT=565.025n

.meas tran vdout0_48ck1120 FIND v(dout0_48) AT=565.025n

.meas tran vdout0_49ck1120 FIND v(dout0_49) AT=565.025n

.meas tran vdout0_50ck1120 FIND v(dout0_50) AT=565.025n

.meas tran vdout0_51ck1120 FIND v(dout0_51) AT=565.025n

.meas tran vdout0_52ck1120 FIND v(dout0_52) AT=565.025n

.meas tran vdout0_53ck1120 FIND v(dout0_53) AT=565.025n

.meas tran vdout0_54ck1120 FIND v(dout0_54) AT=565.025n

.meas tran vdout0_55ck1120 FIND v(dout0_55) AT=565.025n

.meas tran vdout0_56ck1120 FIND v(dout0_56) AT=565.025n

.meas tran vdout0_57ck1120 FIND v(dout0_57) AT=565.025n

.meas tran vdout0_58ck1120 FIND v(dout0_58) AT=565.025n

.meas tran vdout0_59ck1120 FIND v(dout0_59) AT=565.025n

.meas tran vdout0_60ck1120 FIND v(dout0_60) AT=565.025n

.meas tran vdout0_61ck1120 FIND v(dout0_61) AT=565.025n

.meas tran vdout0_62ck1120 FIND v(dout0_62) AT=565.025n

.meas tran vdout0_63ck1120 FIND v(dout0_63) AT=565.025n

.meas tran vdout0_64ck1120 FIND v(dout0_64) AT=565.025n

.meas tran vdout0_65ck1120 FIND v(dout0_65) AT=565.025n

.meas tran vdout0_66ck1120 FIND v(dout0_66) AT=565.025n

.meas tran vdout0_67ck1120 FIND v(dout0_67) AT=565.025n

.meas tran vdout0_68ck1120 FIND v(dout0_68) AT=565.025n

.meas tran vdout0_69ck1120 FIND v(dout0_69) AT=565.025n

.meas tran vdout0_70ck1120 FIND v(dout0_70) AT=565.025n

.meas tran vdout0_71ck1120 FIND v(dout0_71) AT=565.025n

.meas tran vdout0_72ck1120 FIND v(dout0_72) AT=565.025n

.meas tran vdout0_73ck1120 FIND v(dout0_73) AT=565.025n

.meas tran vdout0_74ck1120 FIND v(dout0_74) AT=565.025n

.meas tran vdout0_75ck1120 FIND v(dout0_75) AT=565.025n

.meas tran vdout0_76ck1120 FIND v(dout0_76) AT=565.025n

.meas tran vdout0_77ck1120 FIND v(dout0_77) AT=565.025n

.meas tran vdout0_78ck1120 FIND v(dout0_78) AT=565.025n

.meas tran vdout0_79ck1120 FIND v(dout0_79) AT=565.025n

.meas tran vdout0_80ck1120 FIND v(dout0_80) AT=565.025n

.meas tran vdout0_81ck1120 FIND v(dout0_81) AT=565.025n

.meas tran vdout0_82ck1120 FIND v(dout0_82) AT=565.025n

.meas tran vdout0_83ck1120 FIND v(dout0_83) AT=565.025n

.meas tran vdout0_84ck1120 FIND v(dout0_84) AT=565.025n

.meas tran vdout0_85ck1120 FIND v(dout0_85) AT=565.025n

.meas tran vdout0_86ck1120 FIND v(dout0_86) AT=565.025n

.meas tran vdout0_87ck1120 FIND v(dout0_87) AT=565.025n

.meas tran vdout0_88ck1120 FIND v(dout0_88) AT=565.025n

.meas tran vdout0_89ck1120 FIND v(dout0_89) AT=565.025n

.meas tran vdout0_90ck1120 FIND v(dout0_90) AT=565.025n

.meas tran vdout0_91ck1120 FIND v(dout0_91) AT=565.025n

.meas tran vdout0_92ck1120 FIND v(dout0_92) AT=565.025n

.meas tran vdout0_93ck1120 FIND v(dout0_93) AT=565.025n

.meas tran vdout0_94ck1120 FIND v(dout0_94) AT=565.025n

.meas tran vdout0_95ck1120 FIND v(dout0_95) AT=565.025n

.meas tran vdout0_96ck1120 FIND v(dout0_96) AT=565.025n

.meas tran vdout0_97ck1120 FIND v(dout0_97) AT=565.025n

.meas tran vdout0_98ck1120 FIND v(dout0_98) AT=565.025n

.meas tran vdout0_99ck1120 FIND v(dout0_99) AT=565.025n

.meas tran vdout0_100ck1120 FIND v(dout0_100) AT=565.025n

.meas tran vdout0_101ck1120 FIND v(dout0_101) AT=565.025n

.meas tran vdout0_102ck1120 FIND v(dout0_102) AT=565.025n

.meas tran vdout0_103ck1120 FIND v(dout0_103) AT=565.025n

.meas tran vdout0_104ck1120 FIND v(dout0_104) AT=565.025n

.meas tran vdout0_105ck1120 FIND v(dout0_105) AT=565.025n

.meas tran vdout0_106ck1120 FIND v(dout0_106) AT=565.025n

.meas tran vdout0_107ck1120 FIND v(dout0_107) AT=565.025n

.meas tran vdout0_108ck1120 FIND v(dout0_108) AT=565.025n

.meas tran vdout0_109ck1120 FIND v(dout0_109) AT=565.025n

.meas tran vdout0_110ck1120 FIND v(dout0_110) AT=565.025n

.meas tran vdout0_111ck1120 FIND v(dout0_111) AT=565.025n

.meas tran vdout0_112ck1120 FIND v(dout0_112) AT=565.025n

.meas tran vdout0_113ck1120 FIND v(dout0_113) AT=565.025n

.meas tran vdout0_114ck1120 FIND v(dout0_114) AT=565.025n

.meas tran vdout0_115ck1120 FIND v(dout0_115) AT=565.025n

.meas tran vdout0_116ck1120 FIND v(dout0_116) AT=565.025n

.meas tran vdout0_117ck1120 FIND v(dout0_117) AT=565.025n

.meas tran vdout0_118ck1120 FIND v(dout0_118) AT=565.025n

.meas tran vdout0_119ck1120 FIND v(dout0_119) AT=565.025n

.meas tran vdout0_120ck1120 FIND v(dout0_120) AT=565.025n

.meas tran vdout0_121ck1120 FIND v(dout0_121) AT=565.025n

.meas tran vdout0_122ck1120 FIND v(dout0_122) AT=565.025n

.meas tran vdout0_123ck1120 FIND v(dout0_123) AT=565.025n

.meas tran vdout0_124ck1120 FIND v(dout0_124) AT=565.025n

.meas tran vdout0_125ck1120 FIND v(dout0_125) AT=565.025n

.meas tran vdout0_126ck1120 FIND v(dout0_126) AT=565.025n

.meas tran vdout0_127ck1120 FIND v(dout0_127) AT=565.025n

.meas tran vdout0_128ck1120 FIND v(dout0_128) AT=565.025n

.meas tran vdout0_129ck1120 FIND v(dout0_129) AT=565.025n

.meas tran vdout0_130ck1120 FIND v(dout0_130) AT=565.025n

.meas tran vdout0_131ck1120 FIND v(dout0_131) AT=565.025n

.meas tran vdout0_132ck1120 FIND v(dout0_132) AT=565.025n

.meas tran vdout0_133ck1120 FIND v(dout0_133) AT=565.025n

.meas tran vdout0_134ck1120 FIND v(dout0_134) AT=565.025n

.meas tran vdout0_135ck1120 FIND v(dout0_135) AT=565.025n

.meas tran vdout0_136ck1120 FIND v(dout0_136) AT=565.025n

.meas tran vdout0_137ck1120 FIND v(dout0_137) AT=565.025n

.meas tran vdout0_138ck1120 FIND v(dout0_138) AT=565.025n

.meas tran vdout0_139ck1120 FIND v(dout0_139) AT=565.025n

.meas tran vdout0_140ck1120 FIND v(dout0_140) AT=565.025n

.meas tran vdout0_141ck1120 FIND v(dout0_141) AT=565.025n

.meas tran vdout0_142ck1120 FIND v(dout0_142) AT=565.025n

.meas tran vdout0_143ck1120 FIND v(dout0_143) AT=565.025n

.meas tran vdout0_144ck1120 FIND v(dout0_144) AT=565.025n

.meas tran vdout0_145ck1120 FIND v(dout0_145) AT=565.025n

.meas tran vdout0_146ck1120 FIND v(dout0_146) AT=565.025n

.meas tran vdout0_147ck1120 FIND v(dout0_147) AT=565.025n

.meas tran vdout0_148ck1120 FIND v(dout0_148) AT=565.025n

.meas tran vdout0_149ck1120 FIND v(dout0_149) AT=565.025n

.meas tran vdout0_0ck1130 FIND v(dout0_0) AT=570.025n

.meas tran vdout0_1ck1130 FIND v(dout0_1) AT=570.025n

.meas tran vdout0_2ck1130 FIND v(dout0_2) AT=570.025n

.meas tran vdout0_3ck1130 FIND v(dout0_3) AT=570.025n

.meas tran vdout0_4ck1130 FIND v(dout0_4) AT=570.025n

.meas tran vdout0_5ck1130 FIND v(dout0_5) AT=570.025n

.meas tran vdout0_6ck1130 FIND v(dout0_6) AT=570.025n

.meas tran vdout0_7ck1130 FIND v(dout0_7) AT=570.025n

.meas tran vdout0_8ck1130 FIND v(dout0_8) AT=570.025n

.meas tran vdout0_9ck1130 FIND v(dout0_9) AT=570.025n

.meas tran vdout0_10ck1130 FIND v(dout0_10) AT=570.025n

.meas tran vdout0_11ck1130 FIND v(dout0_11) AT=570.025n

.meas tran vdout0_12ck1130 FIND v(dout0_12) AT=570.025n

.meas tran vdout0_13ck1130 FIND v(dout0_13) AT=570.025n

.meas tran vdout0_14ck1130 FIND v(dout0_14) AT=570.025n

.meas tran vdout0_15ck1130 FIND v(dout0_15) AT=570.025n

.meas tran vdout0_16ck1130 FIND v(dout0_16) AT=570.025n

.meas tran vdout0_17ck1130 FIND v(dout0_17) AT=570.025n

.meas tran vdout0_18ck1130 FIND v(dout0_18) AT=570.025n

.meas tran vdout0_19ck1130 FIND v(dout0_19) AT=570.025n

.meas tran vdout0_20ck1130 FIND v(dout0_20) AT=570.025n

.meas tran vdout0_21ck1130 FIND v(dout0_21) AT=570.025n

.meas tran vdout0_22ck1130 FIND v(dout0_22) AT=570.025n

.meas tran vdout0_23ck1130 FIND v(dout0_23) AT=570.025n

.meas tran vdout0_24ck1130 FIND v(dout0_24) AT=570.025n

.meas tran vdout0_25ck1130 FIND v(dout0_25) AT=570.025n

.meas tran vdout0_26ck1130 FIND v(dout0_26) AT=570.025n

.meas tran vdout0_27ck1130 FIND v(dout0_27) AT=570.025n

.meas tran vdout0_28ck1130 FIND v(dout0_28) AT=570.025n

.meas tran vdout0_29ck1130 FIND v(dout0_29) AT=570.025n

.meas tran vdout0_30ck1130 FIND v(dout0_30) AT=570.025n

.meas tran vdout0_31ck1130 FIND v(dout0_31) AT=570.025n

.meas tran vdout0_32ck1130 FIND v(dout0_32) AT=570.025n

.meas tran vdout0_33ck1130 FIND v(dout0_33) AT=570.025n

.meas tran vdout0_34ck1130 FIND v(dout0_34) AT=570.025n

.meas tran vdout0_35ck1130 FIND v(dout0_35) AT=570.025n

.meas tran vdout0_36ck1130 FIND v(dout0_36) AT=570.025n

.meas tran vdout0_37ck1130 FIND v(dout0_37) AT=570.025n

.meas tran vdout0_38ck1130 FIND v(dout0_38) AT=570.025n

.meas tran vdout0_39ck1130 FIND v(dout0_39) AT=570.025n

.meas tran vdout0_40ck1130 FIND v(dout0_40) AT=570.025n

.meas tran vdout0_41ck1130 FIND v(dout0_41) AT=570.025n

.meas tran vdout0_42ck1130 FIND v(dout0_42) AT=570.025n

.meas tran vdout0_43ck1130 FIND v(dout0_43) AT=570.025n

.meas tran vdout0_44ck1130 FIND v(dout0_44) AT=570.025n

.meas tran vdout0_45ck1130 FIND v(dout0_45) AT=570.025n

.meas tran vdout0_46ck1130 FIND v(dout0_46) AT=570.025n

.meas tran vdout0_47ck1130 FIND v(dout0_47) AT=570.025n

.meas tran vdout0_48ck1130 FIND v(dout0_48) AT=570.025n

.meas tran vdout0_49ck1130 FIND v(dout0_49) AT=570.025n

.meas tran vdout0_50ck1130 FIND v(dout0_50) AT=570.025n

.meas tran vdout0_51ck1130 FIND v(dout0_51) AT=570.025n

.meas tran vdout0_52ck1130 FIND v(dout0_52) AT=570.025n

.meas tran vdout0_53ck1130 FIND v(dout0_53) AT=570.025n

.meas tran vdout0_54ck1130 FIND v(dout0_54) AT=570.025n

.meas tran vdout0_55ck1130 FIND v(dout0_55) AT=570.025n

.meas tran vdout0_56ck1130 FIND v(dout0_56) AT=570.025n

.meas tran vdout0_57ck1130 FIND v(dout0_57) AT=570.025n

.meas tran vdout0_58ck1130 FIND v(dout0_58) AT=570.025n

.meas tran vdout0_59ck1130 FIND v(dout0_59) AT=570.025n

.meas tran vdout0_60ck1130 FIND v(dout0_60) AT=570.025n

.meas tran vdout0_61ck1130 FIND v(dout0_61) AT=570.025n

.meas tran vdout0_62ck1130 FIND v(dout0_62) AT=570.025n

.meas tran vdout0_63ck1130 FIND v(dout0_63) AT=570.025n

.meas tran vdout0_64ck1130 FIND v(dout0_64) AT=570.025n

.meas tran vdout0_65ck1130 FIND v(dout0_65) AT=570.025n

.meas tran vdout0_66ck1130 FIND v(dout0_66) AT=570.025n

.meas tran vdout0_67ck1130 FIND v(dout0_67) AT=570.025n

.meas tran vdout0_68ck1130 FIND v(dout0_68) AT=570.025n

.meas tran vdout0_69ck1130 FIND v(dout0_69) AT=570.025n

.meas tran vdout0_70ck1130 FIND v(dout0_70) AT=570.025n

.meas tran vdout0_71ck1130 FIND v(dout0_71) AT=570.025n

.meas tran vdout0_72ck1130 FIND v(dout0_72) AT=570.025n

.meas tran vdout0_73ck1130 FIND v(dout0_73) AT=570.025n

.meas tran vdout0_74ck1130 FIND v(dout0_74) AT=570.025n

.meas tran vdout0_75ck1130 FIND v(dout0_75) AT=570.025n

.meas tran vdout0_76ck1130 FIND v(dout0_76) AT=570.025n

.meas tran vdout0_77ck1130 FIND v(dout0_77) AT=570.025n

.meas tran vdout0_78ck1130 FIND v(dout0_78) AT=570.025n

.meas tran vdout0_79ck1130 FIND v(dout0_79) AT=570.025n

.meas tran vdout0_80ck1130 FIND v(dout0_80) AT=570.025n

.meas tran vdout0_81ck1130 FIND v(dout0_81) AT=570.025n

.meas tran vdout0_82ck1130 FIND v(dout0_82) AT=570.025n

.meas tran vdout0_83ck1130 FIND v(dout0_83) AT=570.025n

.meas tran vdout0_84ck1130 FIND v(dout0_84) AT=570.025n

.meas tran vdout0_85ck1130 FIND v(dout0_85) AT=570.025n

.meas tran vdout0_86ck1130 FIND v(dout0_86) AT=570.025n

.meas tran vdout0_87ck1130 FIND v(dout0_87) AT=570.025n

.meas tran vdout0_88ck1130 FIND v(dout0_88) AT=570.025n

.meas tran vdout0_89ck1130 FIND v(dout0_89) AT=570.025n

.meas tran vdout0_90ck1130 FIND v(dout0_90) AT=570.025n

.meas tran vdout0_91ck1130 FIND v(dout0_91) AT=570.025n

.meas tran vdout0_92ck1130 FIND v(dout0_92) AT=570.025n

.meas tran vdout0_93ck1130 FIND v(dout0_93) AT=570.025n

.meas tran vdout0_94ck1130 FIND v(dout0_94) AT=570.025n

.meas tran vdout0_95ck1130 FIND v(dout0_95) AT=570.025n

.meas tran vdout0_96ck1130 FIND v(dout0_96) AT=570.025n

.meas tran vdout0_97ck1130 FIND v(dout0_97) AT=570.025n

.meas tran vdout0_98ck1130 FIND v(dout0_98) AT=570.025n

.meas tran vdout0_99ck1130 FIND v(dout0_99) AT=570.025n

.meas tran vdout0_100ck1130 FIND v(dout0_100) AT=570.025n

.meas tran vdout0_101ck1130 FIND v(dout0_101) AT=570.025n

.meas tran vdout0_102ck1130 FIND v(dout0_102) AT=570.025n

.meas tran vdout0_103ck1130 FIND v(dout0_103) AT=570.025n

.meas tran vdout0_104ck1130 FIND v(dout0_104) AT=570.025n

.meas tran vdout0_105ck1130 FIND v(dout0_105) AT=570.025n

.meas tran vdout0_106ck1130 FIND v(dout0_106) AT=570.025n

.meas tran vdout0_107ck1130 FIND v(dout0_107) AT=570.025n

.meas tran vdout0_108ck1130 FIND v(dout0_108) AT=570.025n

.meas tran vdout0_109ck1130 FIND v(dout0_109) AT=570.025n

.meas tran vdout0_110ck1130 FIND v(dout0_110) AT=570.025n

.meas tran vdout0_111ck1130 FIND v(dout0_111) AT=570.025n

.meas tran vdout0_112ck1130 FIND v(dout0_112) AT=570.025n

.meas tran vdout0_113ck1130 FIND v(dout0_113) AT=570.025n

.meas tran vdout0_114ck1130 FIND v(dout0_114) AT=570.025n

.meas tran vdout0_115ck1130 FIND v(dout0_115) AT=570.025n

.meas tran vdout0_116ck1130 FIND v(dout0_116) AT=570.025n

.meas tran vdout0_117ck1130 FIND v(dout0_117) AT=570.025n

.meas tran vdout0_118ck1130 FIND v(dout0_118) AT=570.025n

.meas tran vdout0_119ck1130 FIND v(dout0_119) AT=570.025n

.meas tran vdout0_120ck1130 FIND v(dout0_120) AT=570.025n

.meas tran vdout0_121ck1130 FIND v(dout0_121) AT=570.025n

.meas tran vdout0_122ck1130 FIND v(dout0_122) AT=570.025n

.meas tran vdout0_123ck1130 FIND v(dout0_123) AT=570.025n

.meas tran vdout0_124ck1130 FIND v(dout0_124) AT=570.025n

.meas tran vdout0_125ck1130 FIND v(dout0_125) AT=570.025n

.meas tran vdout0_126ck1130 FIND v(dout0_126) AT=570.025n

.meas tran vdout0_127ck1130 FIND v(dout0_127) AT=570.025n

.meas tran vdout0_128ck1130 FIND v(dout0_128) AT=570.025n

.meas tran vdout0_129ck1130 FIND v(dout0_129) AT=570.025n

.meas tran vdout0_130ck1130 FIND v(dout0_130) AT=570.025n

.meas tran vdout0_131ck1130 FIND v(dout0_131) AT=570.025n

.meas tran vdout0_132ck1130 FIND v(dout0_132) AT=570.025n

.meas tran vdout0_133ck1130 FIND v(dout0_133) AT=570.025n

.meas tran vdout0_134ck1130 FIND v(dout0_134) AT=570.025n

.meas tran vdout0_135ck1130 FIND v(dout0_135) AT=570.025n

.meas tran vdout0_136ck1130 FIND v(dout0_136) AT=570.025n

.meas tran vdout0_137ck1130 FIND v(dout0_137) AT=570.025n

.meas tran vdout0_138ck1130 FIND v(dout0_138) AT=570.025n

.meas tran vdout0_139ck1130 FIND v(dout0_139) AT=570.025n

.meas tran vdout0_140ck1130 FIND v(dout0_140) AT=570.025n

.meas tran vdout0_141ck1130 FIND v(dout0_141) AT=570.025n

.meas tran vdout0_142ck1130 FIND v(dout0_142) AT=570.025n

.meas tran vdout0_143ck1130 FIND v(dout0_143) AT=570.025n

.meas tran vdout0_144ck1130 FIND v(dout0_144) AT=570.025n

.meas tran vdout0_145ck1130 FIND v(dout0_145) AT=570.025n

.meas tran vdout0_146ck1130 FIND v(dout0_146) AT=570.025n

.meas tran vdout0_147ck1130 FIND v(dout0_147) AT=570.025n

.meas tran vdout0_148ck1130 FIND v(dout0_148) AT=570.025n

.meas tran vdout0_149ck1130 FIND v(dout0_149) AT=570.025n

.meas tran vdout0_0ck1140 FIND v(dout0_0) AT=575.025n

.meas tran vdout0_1ck1140 FIND v(dout0_1) AT=575.025n

.meas tran vdout0_2ck1140 FIND v(dout0_2) AT=575.025n

.meas tran vdout0_3ck1140 FIND v(dout0_3) AT=575.025n

.meas tran vdout0_4ck1140 FIND v(dout0_4) AT=575.025n

.meas tran vdout0_5ck1140 FIND v(dout0_5) AT=575.025n

.meas tran vdout0_6ck1140 FIND v(dout0_6) AT=575.025n

.meas tran vdout0_7ck1140 FIND v(dout0_7) AT=575.025n

.meas tran vdout0_8ck1140 FIND v(dout0_8) AT=575.025n

.meas tran vdout0_9ck1140 FIND v(dout0_9) AT=575.025n

.meas tran vdout0_10ck1140 FIND v(dout0_10) AT=575.025n

.meas tran vdout0_11ck1140 FIND v(dout0_11) AT=575.025n

.meas tran vdout0_12ck1140 FIND v(dout0_12) AT=575.025n

.meas tran vdout0_13ck1140 FIND v(dout0_13) AT=575.025n

.meas tran vdout0_14ck1140 FIND v(dout0_14) AT=575.025n

.meas tran vdout0_15ck1140 FIND v(dout0_15) AT=575.025n

.meas tran vdout0_16ck1140 FIND v(dout0_16) AT=575.025n

.meas tran vdout0_17ck1140 FIND v(dout0_17) AT=575.025n

.meas tran vdout0_18ck1140 FIND v(dout0_18) AT=575.025n

.meas tran vdout0_19ck1140 FIND v(dout0_19) AT=575.025n

.meas tran vdout0_20ck1140 FIND v(dout0_20) AT=575.025n

.meas tran vdout0_21ck1140 FIND v(dout0_21) AT=575.025n

.meas tran vdout0_22ck1140 FIND v(dout0_22) AT=575.025n

.meas tran vdout0_23ck1140 FIND v(dout0_23) AT=575.025n

.meas tran vdout0_24ck1140 FIND v(dout0_24) AT=575.025n

.meas tran vdout0_25ck1140 FIND v(dout0_25) AT=575.025n

.meas tran vdout0_26ck1140 FIND v(dout0_26) AT=575.025n

.meas tran vdout0_27ck1140 FIND v(dout0_27) AT=575.025n

.meas tran vdout0_28ck1140 FIND v(dout0_28) AT=575.025n

.meas tran vdout0_29ck1140 FIND v(dout0_29) AT=575.025n

.meas tran vdout0_30ck1140 FIND v(dout0_30) AT=575.025n

.meas tran vdout0_31ck1140 FIND v(dout0_31) AT=575.025n

.meas tran vdout0_32ck1140 FIND v(dout0_32) AT=575.025n

.meas tran vdout0_33ck1140 FIND v(dout0_33) AT=575.025n

.meas tran vdout0_34ck1140 FIND v(dout0_34) AT=575.025n

.meas tran vdout0_35ck1140 FIND v(dout0_35) AT=575.025n

.meas tran vdout0_36ck1140 FIND v(dout0_36) AT=575.025n

.meas tran vdout0_37ck1140 FIND v(dout0_37) AT=575.025n

.meas tran vdout0_38ck1140 FIND v(dout0_38) AT=575.025n

.meas tran vdout0_39ck1140 FIND v(dout0_39) AT=575.025n

.meas tran vdout0_40ck1140 FIND v(dout0_40) AT=575.025n

.meas tran vdout0_41ck1140 FIND v(dout0_41) AT=575.025n

.meas tran vdout0_42ck1140 FIND v(dout0_42) AT=575.025n

.meas tran vdout0_43ck1140 FIND v(dout0_43) AT=575.025n

.meas tran vdout0_44ck1140 FIND v(dout0_44) AT=575.025n

.meas tran vdout0_45ck1140 FIND v(dout0_45) AT=575.025n

.meas tran vdout0_46ck1140 FIND v(dout0_46) AT=575.025n

.meas tran vdout0_47ck1140 FIND v(dout0_47) AT=575.025n

.meas tran vdout0_48ck1140 FIND v(dout0_48) AT=575.025n

.meas tran vdout0_49ck1140 FIND v(dout0_49) AT=575.025n

.meas tran vdout0_50ck1140 FIND v(dout0_50) AT=575.025n

.meas tran vdout0_51ck1140 FIND v(dout0_51) AT=575.025n

.meas tran vdout0_52ck1140 FIND v(dout0_52) AT=575.025n

.meas tran vdout0_53ck1140 FIND v(dout0_53) AT=575.025n

.meas tran vdout0_54ck1140 FIND v(dout0_54) AT=575.025n

.meas tran vdout0_55ck1140 FIND v(dout0_55) AT=575.025n

.meas tran vdout0_56ck1140 FIND v(dout0_56) AT=575.025n

.meas tran vdout0_57ck1140 FIND v(dout0_57) AT=575.025n

.meas tran vdout0_58ck1140 FIND v(dout0_58) AT=575.025n

.meas tran vdout0_59ck1140 FIND v(dout0_59) AT=575.025n

.meas tran vdout0_60ck1140 FIND v(dout0_60) AT=575.025n

.meas tran vdout0_61ck1140 FIND v(dout0_61) AT=575.025n

.meas tran vdout0_62ck1140 FIND v(dout0_62) AT=575.025n

.meas tran vdout0_63ck1140 FIND v(dout0_63) AT=575.025n

.meas tran vdout0_64ck1140 FIND v(dout0_64) AT=575.025n

.meas tran vdout0_65ck1140 FIND v(dout0_65) AT=575.025n

.meas tran vdout0_66ck1140 FIND v(dout0_66) AT=575.025n

.meas tran vdout0_67ck1140 FIND v(dout0_67) AT=575.025n

.meas tran vdout0_68ck1140 FIND v(dout0_68) AT=575.025n

.meas tran vdout0_69ck1140 FIND v(dout0_69) AT=575.025n

.meas tran vdout0_70ck1140 FIND v(dout0_70) AT=575.025n

.meas tran vdout0_71ck1140 FIND v(dout0_71) AT=575.025n

.meas tran vdout0_72ck1140 FIND v(dout0_72) AT=575.025n

.meas tran vdout0_73ck1140 FIND v(dout0_73) AT=575.025n

.meas tran vdout0_74ck1140 FIND v(dout0_74) AT=575.025n

.meas tran vdout0_75ck1140 FIND v(dout0_75) AT=575.025n

.meas tran vdout0_76ck1140 FIND v(dout0_76) AT=575.025n

.meas tran vdout0_77ck1140 FIND v(dout0_77) AT=575.025n

.meas tran vdout0_78ck1140 FIND v(dout0_78) AT=575.025n

.meas tran vdout0_79ck1140 FIND v(dout0_79) AT=575.025n

.meas tran vdout0_80ck1140 FIND v(dout0_80) AT=575.025n

.meas tran vdout0_81ck1140 FIND v(dout0_81) AT=575.025n

.meas tran vdout0_82ck1140 FIND v(dout0_82) AT=575.025n

.meas tran vdout0_83ck1140 FIND v(dout0_83) AT=575.025n

.meas tran vdout0_84ck1140 FIND v(dout0_84) AT=575.025n

.meas tran vdout0_85ck1140 FIND v(dout0_85) AT=575.025n

.meas tran vdout0_86ck1140 FIND v(dout0_86) AT=575.025n

.meas tran vdout0_87ck1140 FIND v(dout0_87) AT=575.025n

.meas tran vdout0_88ck1140 FIND v(dout0_88) AT=575.025n

.meas tran vdout0_89ck1140 FIND v(dout0_89) AT=575.025n

.meas tran vdout0_90ck1140 FIND v(dout0_90) AT=575.025n

.meas tran vdout0_91ck1140 FIND v(dout0_91) AT=575.025n

.meas tran vdout0_92ck1140 FIND v(dout0_92) AT=575.025n

.meas tran vdout0_93ck1140 FIND v(dout0_93) AT=575.025n

.meas tran vdout0_94ck1140 FIND v(dout0_94) AT=575.025n

.meas tran vdout0_95ck1140 FIND v(dout0_95) AT=575.025n

.meas tran vdout0_96ck1140 FIND v(dout0_96) AT=575.025n

.meas tran vdout0_97ck1140 FIND v(dout0_97) AT=575.025n

.meas tran vdout0_98ck1140 FIND v(dout0_98) AT=575.025n

.meas tran vdout0_99ck1140 FIND v(dout0_99) AT=575.025n

.meas tran vdout0_100ck1140 FIND v(dout0_100) AT=575.025n

.meas tran vdout0_101ck1140 FIND v(dout0_101) AT=575.025n

.meas tran vdout0_102ck1140 FIND v(dout0_102) AT=575.025n

.meas tran vdout0_103ck1140 FIND v(dout0_103) AT=575.025n

.meas tran vdout0_104ck1140 FIND v(dout0_104) AT=575.025n

.meas tran vdout0_105ck1140 FIND v(dout0_105) AT=575.025n

.meas tran vdout0_106ck1140 FIND v(dout0_106) AT=575.025n

.meas tran vdout0_107ck1140 FIND v(dout0_107) AT=575.025n

.meas tran vdout0_108ck1140 FIND v(dout0_108) AT=575.025n

.meas tran vdout0_109ck1140 FIND v(dout0_109) AT=575.025n

.meas tran vdout0_110ck1140 FIND v(dout0_110) AT=575.025n

.meas tran vdout0_111ck1140 FIND v(dout0_111) AT=575.025n

.meas tran vdout0_112ck1140 FIND v(dout0_112) AT=575.025n

.meas tran vdout0_113ck1140 FIND v(dout0_113) AT=575.025n

.meas tran vdout0_114ck1140 FIND v(dout0_114) AT=575.025n

.meas tran vdout0_115ck1140 FIND v(dout0_115) AT=575.025n

.meas tran vdout0_116ck1140 FIND v(dout0_116) AT=575.025n

.meas tran vdout0_117ck1140 FIND v(dout0_117) AT=575.025n

.meas tran vdout0_118ck1140 FIND v(dout0_118) AT=575.025n

.meas tran vdout0_119ck1140 FIND v(dout0_119) AT=575.025n

.meas tran vdout0_120ck1140 FIND v(dout0_120) AT=575.025n

.meas tran vdout0_121ck1140 FIND v(dout0_121) AT=575.025n

.meas tran vdout0_122ck1140 FIND v(dout0_122) AT=575.025n

.meas tran vdout0_123ck1140 FIND v(dout0_123) AT=575.025n

.meas tran vdout0_124ck1140 FIND v(dout0_124) AT=575.025n

.meas tran vdout0_125ck1140 FIND v(dout0_125) AT=575.025n

.meas tran vdout0_126ck1140 FIND v(dout0_126) AT=575.025n

.meas tran vdout0_127ck1140 FIND v(dout0_127) AT=575.025n

.meas tran vdout0_128ck1140 FIND v(dout0_128) AT=575.025n

.meas tran vdout0_129ck1140 FIND v(dout0_129) AT=575.025n

.meas tran vdout0_130ck1140 FIND v(dout0_130) AT=575.025n

.meas tran vdout0_131ck1140 FIND v(dout0_131) AT=575.025n

.meas tran vdout0_132ck1140 FIND v(dout0_132) AT=575.025n

.meas tran vdout0_133ck1140 FIND v(dout0_133) AT=575.025n

.meas tran vdout0_134ck1140 FIND v(dout0_134) AT=575.025n

.meas tran vdout0_135ck1140 FIND v(dout0_135) AT=575.025n

.meas tran vdout0_136ck1140 FIND v(dout0_136) AT=575.025n

.meas tran vdout0_137ck1140 FIND v(dout0_137) AT=575.025n

.meas tran vdout0_138ck1140 FIND v(dout0_138) AT=575.025n

.meas tran vdout0_139ck1140 FIND v(dout0_139) AT=575.025n

.meas tran vdout0_140ck1140 FIND v(dout0_140) AT=575.025n

.meas tran vdout0_141ck1140 FIND v(dout0_141) AT=575.025n

.meas tran vdout0_142ck1140 FIND v(dout0_142) AT=575.025n

.meas tran vdout0_143ck1140 FIND v(dout0_143) AT=575.025n

.meas tran vdout0_144ck1140 FIND v(dout0_144) AT=575.025n

.meas tran vdout0_145ck1140 FIND v(dout0_145) AT=575.025n

.meas tran vdout0_146ck1140 FIND v(dout0_146) AT=575.025n

.meas tran vdout0_147ck1140 FIND v(dout0_147) AT=575.025n

.meas tran vdout0_148ck1140 FIND v(dout0_148) AT=575.025n

.meas tran vdout0_149ck1140 FIND v(dout0_149) AT=575.025n

.meas tran vdout0_0ck1150 FIND v(dout0_0) AT=580.025n

.meas tran vdout0_1ck1150 FIND v(dout0_1) AT=580.025n

.meas tran vdout0_2ck1150 FIND v(dout0_2) AT=580.025n

.meas tran vdout0_3ck1150 FIND v(dout0_3) AT=580.025n

.meas tran vdout0_4ck1150 FIND v(dout0_4) AT=580.025n

.meas tran vdout0_5ck1150 FIND v(dout0_5) AT=580.025n

.meas tran vdout0_6ck1150 FIND v(dout0_6) AT=580.025n

.meas tran vdout0_7ck1150 FIND v(dout0_7) AT=580.025n

.meas tran vdout0_8ck1150 FIND v(dout0_8) AT=580.025n

.meas tran vdout0_9ck1150 FIND v(dout0_9) AT=580.025n

.meas tran vdout0_10ck1150 FIND v(dout0_10) AT=580.025n

.meas tran vdout0_11ck1150 FIND v(dout0_11) AT=580.025n

.meas tran vdout0_12ck1150 FIND v(dout0_12) AT=580.025n

.meas tran vdout0_13ck1150 FIND v(dout0_13) AT=580.025n

.meas tran vdout0_14ck1150 FIND v(dout0_14) AT=580.025n

.meas tran vdout0_15ck1150 FIND v(dout0_15) AT=580.025n

.meas tran vdout0_16ck1150 FIND v(dout0_16) AT=580.025n

.meas tran vdout0_17ck1150 FIND v(dout0_17) AT=580.025n

.meas tran vdout0_18ck1150 FIND v(dout0_18) AT=580.025n

.meas tran vdout0_19ck1150 FIND v(dout0_19) AT=580.025n

.meas tran vdout0_20ck1150 FIND v(dout0_20) AT=580.025n

.meas tran vdout0_21ck1150 FIND v(dout0_21) AT=580.025n

.meas tran vdout0_22ck1150 FIND v(dout0_22) AT=580.025n

.meas tran vdout0_23ck1150 FIND v(dout0_23) AT=580.025n

.meas tran vdout0_24ck1150 FIND v(dout0_24) AT=580.025n

.meas tran vdout0_25ck1150 FIND v(dout0_25) AT=580.025n

.meas tran vdout0_26ck1150 FIND v(dout0_26) AT=580.025n

.meas tran vdout0_27ck1150 FIND v(dout0_27) AT=580.025n

.meas tran vdout0_28ck1150 FIND v(dout0_28) AT=580.025n

.meas tran vdout0_29ck1150 FIND v(dout0_29) AT=580.025n

.meas tran vdout0_30ck1150 FIND v(dout0_30) AT=580.025n

.meas tran vdout0_31ck1150 FIND v(dout0_31) AT=580.025n

.meas tran vdout0_32ck1150 FIND v(dout0_32) AT=580.025n

.meas tran vdout0_33ck1150 FIND v(dout0_33) AT=580.025n

.meas tran vdout0_34ck1150 FIND v(dout0_34) AT=580.025n

.meas tran vdout0_35ck1150 FIND v(dout0_35) AT=580.025n

.meas tran vdout0_36ck1150 FIND v(dout0_36) AT=580.025n

.meas tran vdout0_37ck1150 FIND v(dout0_37) AT=580.025n

.meas tran vdout0_38ck1150 FIND v(dout0_38) AT=580.025n

.meas tran vdout0_39ck1150 FIND v(dout0_39) AT=580.025n

.meas tran vdout0_40ck1150 FIND v(dout0_40) AT=580.025n

.meas tran vdout0_41ck1150 FIND v(dout0_41) AT=580.025n

.meas tran vdout0_42ck1150 FIND v(dout0_42) AT=580.025n

.meas tran vdout0_43ck1150 FIND v(dout0_43) AT=580.025n

.meas tran vdout0_44ck1150 FIND v(dout0_44) AT=580.025n

.meas tran vdout0_45ck1150 FIND v(dout0_45) AT=580.025n

.meas tran vdout0_46ck1150 FIND v(dout0_46) AT=580.025n

.meas tran vdout0_47ck1150 FIND v(dout0_47) AT=580.025n

.meas tran vdout0_48ck1150 FIND v(dout0_48) AT=580.025n

.meas tran vdout0_49ck1150 FIND v(dout0_49) AT=580.025n

.meas tran vdout0_50ck1150 FIND v(dout0_50) AT=580.025n

.meas tran vdout0_51ck1150 FIND v(dout0_51) AT=580.025n

.meas tran vdout0_52ck1150 FIND v(dout0_52) AT=580.025n

.meas tran vdout0_53ck1150 FIND v(dout0_53) AT=580.025n

.meas tran vdout0_54ck1150 FIND v(dout0_54) AT=580.025n

.meas tran vdout0_55ck1150 FIND v(dout0_55) AT=580.025n

.meas tran vdout0_56ck1150 FIND v(dout0_56) AT=580.025n

.meas tran vdout0_57ck1150 FIND v(dout0_57) AT=580.025n

.meas tran vdout0_58ck1150 FIND v(dout0_58) AT=580.025n

.meas tran vdout0_59ck1150 FIND v(dout0_59) AT=580.025n

.meas tran vdout0_60ck1150 FIND v(dout0_60) AT=580.025n

.meas tran vdout0_61ck1150 FIND v(dout0_61) AT=580.025n

.meas tran vdout0_62ck1150 FIND v(dout0_62) AT=580.025n

.meas tran vdout0_63ck1150 FIND v(dout0_63) AT=580.025n

.meas tran vdout0_64ck1150 FIND v(dout0_64) AT=580.025n

.meas tran vdout0_65ck1150 FIND v(dout0_65) AT=580.025n

.meas tran vdout0_66ck1150 FIND v(dout0_66) AT=580.025n

.meas tran vdout0_67ck1150 FIND v(dout0_67) AT=580.025n

.meas tran vdout0_68ck1150 FIND v(dout0_68) AT=580.025n

.meas tran vdout0_69ck1150 FIND v(dout0_69) AT=580.025n

.meas tran vdout0_70ck1150 FIND v(dout0_70) AT=580.025n

.meas tran vdout0_71ck1150 FIND v(dout0_71) AT=580.025n

.meas tran vdout0_72ck1150 FIND v(dout0_72) AT=580.025n

.meas tran vdout0_73ck1150 FIND v(dout0_73) AT=580.025n

.meas tran vdout0_74ck1150 FIND v(dout0_74) AT=580.025n

.meas tran vdout0_75ck1150 FIND v(dout0_75) AT=580.025n

.meas tran vdout0_76ck1150 FIND v(dout0_76) AT=580.025n

.meas tran vdout0_77ck1150 FIND v(dout0_77) AT=580.025n

.meas tran vdout0_78ck1150 FIND v(dout0_78) AT=580.025n

.meas tran vdout0_79ck1150 FIND v(dout0_79) AT=580.025n

.meas tran vdout0_80ck1150 FIND v(dout0_80) AT=580.025n

.meas tran vdout0_81ck1150 FIND v(dout0_81) AT=580.025n

.meas tran vdout0_82ck1150 FIND v(dout0_82) AT=580.025n

.meas tran vdout0_83ck1150 FIND v(dout0_83) AT=580.025n

.meas tran vdout0_84ck1150 FIND v(dout0_84) AT=580.025n

.meas tran vdout0_85ck1150 FIND v(dout0_85) AT=580.025n

.meas tran vdout0_86ck1150 FIND v(dout0_86) AT=580.025n

.meas tran vdout0_87ck1150 FIND v(dout0_87) AT=580.025n

.meas tran vdout0_88ck1150 FIND v(dout0_88) AT=580.025n

.meas tran vdout0_89ck1150 FIND v(dout0_89) AT=580.025n

.meas tran vdout0_90ck1150 FIND v(dout0_90) AT=580.025n

.meas tran vdout0_91ck1150 FIND v(dout0_91) AT=580.025n

.meas tran vdout0_92ck1150 FIND v(dout0_92) AT=580.025n

.meas tran vdout0_93ck1150 FIND v(dout0_93) AT=580.025n

.meas tran vdout0_94ck1150 FIND v(dout0_94) AT=580.025n

.meas tran vdout0_95ck1150 FIND v(dout0_95) AT=580.025n

.meas tran vdout0_96ck1150 FIND v(dout0_96) AT=580.025n

.meas tran vdout0_97ck1150 FIND v(dout0_97) AT=580.025n

.meas tran vdout0_98ck1150 FIND v(dout0_98) AT=580.025n

.meas tran vdout0_99ck1150 FIND v(dout0_99) AT=580.025n

.meas tran vdout0_100ck1150 FIND v(dout0_100) AT=580.025n

.meas tran vdout0_101ck1150 FIND v(dout0_101) AT=580.025n

.meas tran vdout0_102ck1150 FIND v(dout0_102) AT=580.025n

.meas tran vdout0_103ck1150 FIND v(dout0_103) AT=580.025n

.meas tran vdout0_104ck1150 FIND v(dout0_104) AT=580.025n

.meas tran vdout0_105ck1150 FIND v(dout0_105) AT=580.025n

.meas tran vdout0_106ck1150 FIND v(dout0_106) AT=580.025n

.meas tran vdout0_107ck1150 FIND v(dout0_107) AT=580.025n

.meas tran vdout0_108ck1150 FIND v(dout0_108) AT=580.025n

.meas tran vdout0_109ck1150 FIND v(dout0_109) AT=580.025n

.meas tran vdout0_110ck1150 FIND v(dout0_110) AT=580.025n

.meas tran vdout0_111ck1150 FIND v(dout0_111) AT=580.025n

.meas tran vdout0_112ck1150 FIND v(dout0_112) AT=580.025n

.meas tran vdout0_113ck1150 FIND v(dout0_113) AT=580.025n

.meas tran vdout0_114ck1150 FIND v(dout0_114) AT=580.025n

.meas tran vdout0_115ck1150 FIND v(dout0_115) AT=580.025n

.meas tran vdout0_116ck1150 FIND v(dout0_116) AT=580.025n

.meas tran vdout0_117ck1150 FIND v(dout0_117) AT=580.025n

.meas tran vdout0_118ck1150 FIND v(dout0_118) AT=580.025n

.meas tran vdout0_119ck1150 FIND v(dout0_119) AT=580.025n

.meas tran vdout0_120ck1150 FIND v(dout0_120) AT=580.025n

.meas tran vdout0_121ck1150 FIND v(dout0_121) AT=580.025n

.meas tran vdout0_122ck1150 FIND v(dout0_122) AT=580.025n

.meas tran vdout0_123ck1150 FIND v(dout0_123) AT=580.025n

.meas tran vdout0_124ck1150 FIND v(dout0_124) AT=580.025n

.meas tran vdout0_125ck1150 FIND v(dout0_125) AT=580.025n

.meas tran vdout0_126ck1150 FIND v(dout0_126) AT=580.025n

.meas tran vdout0_127ck1150 FIND v(dout0_127) AT=580.025n

.meas tran vdout0_128ck1150 FIND v(dout0_128) AT=580.025n

.meas tran vdout0_129ck1150 FIND v(dout0_129) AT=580.025n

.meas tran vdout0_130ck1150 FIND v(dout0_130) AT=580.025n

.meas tran vdout0_131ck1150 FIND v(dout0_131) AT=580.025n

.meas tran vdout0_132ck1150 FIND v(dout0_132) AT=580.025n

.meas tran vdout0_133ck1150 FIND v(dout0_133) AT=580.025n

.meas tran vdout0_134ck1150 FIND v(dout0_134) AT=580.025n

.meas tran vdout0_135ck1150 FIND v(dout0_135) AT=580.025n

.meas tran vdout0_136ck1150 FIND v(dout0_136) AT=580.025n

.meas tran vdout0_137ck1150 FIND v(dout0_137) AT=580.025n

.meas tran vdout0_138ck1150 FIND v(dout0_138) AT=580.025n

.meas tran vdout0_139ck1150 FIND v(dout0_139) AT=580.025n

.meas tran vdout0_140ck1150 FIND v(dout0_140) AT=580.025n

.meas tran vdout0_141ck1150 FIND v(dout0_141) AT=580.025n

.meas tran vdout0_142ck1150 FIND v(dout0_142) AT=580.025n

.meas tran vdout0_143ck1150 FIND v(dout0_143) AT=580.025n

.meas tran vdout0_144ck1150 FIND v(dout0_144) AT=580.025n

.meas tran vdout0_145ck1150 FIND v(dout0_145) AT=580.025n

.meas tran vdout0_146ck1150 FIND v(dout0_146) AT=580.025n

.meas tran vdout0_147ck1150 FIND v(dout0_147) AT=580.025n

.meas tran vdout0_148ck1150 FIND v(dout0_148) AT=580.025n

.meas tran vdout0_149ck1150 FIND v(dout0_149) AT=580.025n

.meas tran vdout0_0ck1160 FIND v(dout0_0) AT=585.025n

.meas tran vdout0_1ck1160 FIND v(dout0_1) AT=585.025n

.meas tran vdout0_2ck1160 FIND v(dout0_2) AT=585.025n

.meas tran vdout0_3ck1160 FIND v(dout0_3) AT=585.025n

.meas tran vdout0_4ck1160 FIND v(dout0_4) AT=585.025n

.meas tran vdout0_5ck1160 FIND v(dout0_5) AT=585.025n

.meas tran vdout0_6ck1160 FIND v(dout0_6) AT=585.025n

.meas tran vdout0_7ck1160 FIND v(dout0_7) AT=585.025n

.meas tran vdout0_8ck1160 FIND v(dout0_8) AT=585.025n

.meas tran vdout0_9ck1160 FIND v(dout0_9) AT=585.025n

.meas tran vdout0_10ck1160 FIND v(dout0_10) AT=585.025n

.meas tran vdout0_11ck1160 FIND v(dout0_11) AT=585.025n

.meas tran vdout0_12ck1160 FIND v(dout0_12) AT=585.025n

.meas tran vdout0_13ck1160 FIND v(dout0_13) AT=585.025n

.meas tran vdout0_14ck1160 FIND v(dout0_14) AT=585.025n

.meas tran vdout0_15ck1160 FIND v(dout0_15) AT=585.025n

.meas tran vdout0_16ck1160 FIND v(dout0_16) AT=585.025n

.meas tran vdout0_17ck1160 FIND v(dout0_17) AT=585.025n

.meas tran vdout0_18ck1160 FIND v(dout0_18) AT=585.025n

.meas tran vdout0_19ck1160 FIND v(dout0_19) AT=585.025n

.meas tran vdout0_20ck1160 FIND v(dout0_20) AT=585.025n

.meas tran vdout0_21ck1160 FIND v(dout0_21) AT=585.025n

.meas tran vdout0_22ck1160 FIND v(dout0_22) AT=585.025n

.meas tran vdout0_23ck1160 FIND v(dout0_23) AT=585.025n

.meas tran vdout0_24ck1160 FIND v(dout0_24) AT=585.025n

.meas tran vdout0_25ck1160 FIND v(dout0_25) AT=585.025n

.meas tran vdout0_26ck1160 FIND v(dout0_26) AT=585.025n

.meas tran vdout0_27ck1160 FIND v(dout0_27) AT=585.025n

.meas tran vdout0_28ck1160 FIND v(dout0_28) AT=585.025n

.meas tran vdout0_29ck1160 FIND v(dout0_29) AT=585.025n

.meas tran vdout0_30ck1160 FIND v(dout0_30) AT=585.025n

.meas tran vdout0_31ck1160 FIND v(dout0_31) AT=585.025n

.meas tran vdout0_32ck1160 FIND v(dout0_32) AT=585.025n

.meas tran vdout0_33ck1160 FIND v(dout0_33) AT=585.025n

.meas tran vdout0_34ck1160 FIND v(dout0_34) AT=585.025n

.meas tran vdout0_35ck1160 FIND v(dout0_35) AT=585.025n

.meas tran vdout0_36ck1160 FIND v(dout0_36) AT=585.025n

.meas tran vdout0_37ck1160 FIND v(dout0_37) AT=585.025n

.meas tran vdout0_38ck1160 FIND v(dout0_38) AT=585.025n

.meas tran vdout0_39ck1160 FIND v(dout0_39) AT=585.025n

.meas tran vdout0_40ck1160 FIND v(dout0_40) AT=585.025n

.meas tran vdout0_41ck1160 FIND v(dout0_41) AT=585.025n

.meas tran vdout0_42ck1160 FIND v(dout0_42) AT=585.025n

.meas tran vdout0_43ck1160 FIND v(dout0_43) AT=585.025n

.meas tran vdout0_44ck1160 FIND v(dout0_44) AT=585.025n

.meas tran vdout0_45ck1160 FIND v(dout0_45) AT=585.025n

.meas tran vdout0_46ck1160 FIND v(dout0_46) AT=585.025n

.meas tran vdout0_47ck1160 FIND v(dout0_47) AT=585.025n

.meas tran vdout0_48ck1160 FIND v(dout0_48) AT=585.025n

.meas tran vdout0_49ck1160 FIND v(dout0_49) AT=585.025n

.meas tran vdout0_50ck1160 FIND v(dout0_50) AT=585.025n

.meas tran vdout0_51ck1160 FIND v(dout0_51) AT=585.025n

.meas tran vdout0_52ck1160 FIND v(dout0_52) AT=585.025n

.meas tran vdout0_53ck1160 FIND v(dout0_53) AT=585.025n

.meas tran vdout0_54ck1160 FIND v(dout0_54) AT=585.025n

.meas tran vdout0_55ck1160 FIND v(dout0_55) AT=585.025n

.meas tran vdout0_56ck1160 FIND v(dout0_56) AT=585.025n

.meas tran vdout0_57ck1160 FIND v(dout0_57) AT=585.025n

.meas tran vdout0_58ck1160 FIND v(dout0_58) AT=585.025n

.meas tran vdout0_59ck1160 FIND v(dout0_59) AT=585.025n

.meas tran vdout0_60ck1160 FIND v(dout0_60) AT=585.025n

.meas tran vdout0_61ck1160 FIND v(dout0_61) AT=585.025n

.meas tran vdout0_62ck1160 FIND v(dout0_62) AT=585.025n

.meas tran vdout0_63ck1160 FIND v(dout0_63) AT=585.025n

.meas tran vdout0_64ck1160 FIND v(dout0_64) AT=585.025n

.meas tran vdout0_65ck1160 FIND v(dout0_65) AT=585.025n

.meas tran vdout0_66ck1160 FIND v(dout0_66) AT=585.025n

.meas tran vdout0_67ck1160 FIND v(dout0_67) AT=585.025n

.meas tran vdout0_68ck1160 FIND v(dout0_68) AT=585.025n

.meas tran vdout0_69ck1160 FIND v(dout0_69) AT=585.025n

.meas tran vdout0_70ck1160 FIND v(dout0_70) AT=585.025n

.meas tran vdout0_71ck1160 FIND v(dout0_71) AT=585.025n

.meas tran vdout0_72ck1160 FIND v(dout0_72) AT=585.025n

.meas tran vdout0_73ck1160 FIND v(dout0_73) AT=585.025n

.meas tran vdout0_74ck1160 FIND v(dout0_74) AT=585.025n

.meas tran vdout0_75ck1160 FIND v(dout0_75) AT=585.025n

.meas tran vdout0_76ck1160 FIND v(dout0_76) AT=585.025n

.meas tran vdout0_77ck1160 FIND v(dout0_77) AT=585.025n

.meas tran vdout0_78ck1160 FIND v(dout0_78) AT=585.025n

.meas tran vdout0_79ck1160 FIND v(dout0_79) AT=585.025n

.meas tran vdout0_80ck1160 FIND v(dout0_80) AT=585.025n

.meas tran vdout0_81ck1160 FIND v(dout0_81) AT=585.025n

.meas tran vdout0_82ck1160 FIND v(dout0_82) AT=585.025n

.meas tran vdout0_83ck1160 FIND v(dout0_83) AT=585.025n

.meas tran vdout0_84ck1160 FIND v(dout0_84) AT=585.025n

.meas tran vdout0_85ck1160 FIND v(dout0_85) AT=585.025n

.meas tran vdout0_86ck1160 FIND v(dout0_86) AT=585.025n

.meas tran vdout0_87ck1160 FIND v(dout0_87) AT=585.025n

.meas tran vdout0_88ck1160 FIND v(dout0_88) AT=585.025n

.meas tran vdout0_89ck1160 FIND v(dout0_89) AT=585.025n

.meas tran vdout0_90ck1160 FIND v(dout0_90) AT=585.025n

.meas tran vdout0_91ck1160 FIND v(dout0_91) AT=585.025n

.meas tran vdout0_92ck1160 FIND v(dout0_92) AT=585.025n

.meas tran vdout0_93ck1160 FIND v(dout0_93) AT=585.025n

.meas tran vdout0_94ck1160 FIND v(dout0_94) AT=585.025n

.meas tran vdout0_95ck1160 FIND v(dout0_95) AT=585.025n

.meas tran vdout0_96ck1160 FIND v(dout0_96) AT=585.025n

.meas tran vdout0_97ck1160 FIND v(dout0_97) AT=585.025n

.meas tran vdout0_98ck1160 FIND v(dout0_98) AT=585.025n

.meas tran vdout0_99ck1160 FIND v(dout0_99) AT=585.025n

.meas tran vdout0_100ck1160 FIND v(dout0_100) AT=585.025n

.meas tran vdout0_101ck1160 FIND v(dout0_101) AT=585.025n

.meas tran vdout0_102ck1160 FIND v(dout0_102) AT=585.025n

.meas tran vdout0_103ck1160 FIND v(dout0_103) AT=585.025n

.meas tran vdout0_104ck1160 FIND v(dout0_104) AT=585.025n

.meas tran vdout0_105ck1160 FIND v(dout0_105) AT=585.025n

.meas tran vdout0_106ck1160 FIND v(dout0_106) AT=585.025n

.meas tran vdout0_107ck1160 FIND v(dout0_107) AT=585.025n

.meas tran vdout0_108ck1160 FIND v(dout0_108) AT=585.025n

.meas tran vdout0_109ck1160 FIND v(dout0_109) AT=585.025n

.meas tran vdout0_110ck1160 FIND v(dout0_110) AT=585.025n

.meas tran vdout0_111ck1160 FIND v(dout0_111) AT=585.025n

.meas tran vdout0_112ck1160 FIND v(dout0_112) AT=585.025n

.meas tran vdout0_113ck1160 FIND v(dout0_113) AT=585.025n

.meas tran vdout0_114ck1160 FIND v(dout0_114) AT=585.025n

.meas tran vdout0_115ck1160 FIND v(dout0_115) AT=585.025n

.meas tran vdout0_116ck1160 FIND v(dout0_116) AT=585.025n

.meas tran vdout0_117ck1160 FIND v(dout0_117) AT=585.025n

.meas tran vdout0_118ck1160 FIND v(dout0_118) AT=585.025n

.meas tran vdout0_119ck1160 FIND v(dout0_119) AT=585.025n

.meas tran vdout0_120ck1160 FIND v(dout0_120) AT=585.025n

.meas tran vdout0_121ck1160 FIND v(dout0_121) AT=585.025n

.meas tran vdout0_122ck1160 FIND v(dout0_122) AT=585.025n

.meas tran vdout0_123ck1160 FIND v(dout0_123) AT=585.025n

.meas tran vdout0_124ck1160 FIND v(dout0_124) AT=585.025n

.meas tran vdout0_125ck1160 FIND v(dout0_125) AT=585.025n

.meas tran vdout0_126ck1160 FIND v(dout0_126) AT=585.025n

.meas tran vdout0_127ck1160 FIND v(dout0_127) AT=585.025n

.meas tran vdout0_128ck1160 FIND v(dout0_128) AT=585.025n

.meas tran vdout0_129ck1160 FIND v(dout0_129) AT=585.025n

.meas tran vdout0_130ck1160 FIND v(dout0_130) AT=585.025n

.meas tran vdout0_131ck1160 FIND v(dout0_131) AT=585.025n

.meas tran vdout0_132ck1160 FIND v(dout0_132) AT=585.025n

.meas tran vdout0_133ck1160 FIND v(dout0_133) AT=585.025n

.meas tran vdout0_134ck1160 FIND v(dout0_134) AT=585.025n

.meas tran vdout0_135ck1160 FIND v(dout0_135) AT=585.025n

.meas tran vdout0_136ck1160 FIND v(dout0_136) AT=585.025n

.meas tran vdout0_137ck1160 FIND v(dout0_137) AT=585.025n

.meas tran vdout0_138ck1160 FIND v(dout0_138) AT=585.025n

.meas tran vdout0_139ck1160 FIND v(dout0_139) AT=585.025n

.meas tran vdout0_140ck1160 FIND v(dout0_140) AT=585.025n

.meas tran vdout0_141ck1160 FIND v(dout0_141) AT=585.025n

.meas tran vdout0_142ck1160 FIND v(dout0_142) AT=585.025n

.meas tran vdout0_143ck1160 FIND v(dout0_143) AT=585.025n

.meas tran vdout0_144ck1160 FIND v(dout0_144) AT=585.025n

.meas tran vdout0_145ck1160 FIND v(dout0_145) AT=585.025n

.meas tran vdout0_146ck1160 FIND v(dout0_146) AT=585.025n

.meas tran vdout0_147ck1160 FIND v(dout0_147) AT=585.025n

.meas tran vdout0_148ck1160 FIND v(dout0_148) AT=585.025n

.meas tran vdout0_149ck1160 FIND v(dout0_149) AT=585.025n

.meas tran vdout0_0ck1180 FIND v(dout0_0) AT=595.025n

.meas tran vdout0_1ck1180 FIND v(dout0_1) AT=595.025n

.meas tran vdout0_2ck1180 FIND v(dout0_2) AT=595.025n

.meas tran vdout0_3ck1180 FIND v(dout0_3) AT=595.025n

.meas tran vdout0_4ck1180 FIND v(dout0_4) AT=595.025n

.meas tran vdout0_5ck1180 FIND v(dout0_5) AT=595.025n

.meas tran vdout0_6ck1180 FIND v(dout0_6) AT=595.025n

.meas tran vdout0_7ck1180 FIND v(dout0_7) AT=595.025n

.meas tran vdout0_8ck1180 FIND v(dout0_8) AT=595.025n

.meas tran vdout0_9ck1180 FIND v(dout0_9) AT=595.025n

.meas tran vdout0_10ck1180 FIND v(dout0_10) AT=595.025n

.meas tran vdout0_11ck1180 FIND v(dout0_11) AT=595.025n

.meas tran vdout0_12ck1180 FIND v(dout0_12) AT=595.025n

.meas tran vdout0_13ck1180 FIND v(dout0_13) AT=595.025n

.meas tran vdout0_14ck1180 FIND v(dout0_14) AT=595.025n

.meas tran vdout0_15ck1180 FIND v(dout0_15) AT=595.025n

.meas tran vdout0_16ck1180 FIND v(dout0_16) AT=595.025n

.meas tran vdout0_17ck1180 FIND v(dout0_17) AT=595.025n

.meas tran vdout0_18ck1180 FIND v(dout0_18) AT=595.025n

.meas tran vdout0_19ck1180 FIND v(dout0_19) AT=595.025n

.meas tran vdout0_20ck1180 FIND v(dout0_20) AT=595.025n

.meas tran vdout0_21ck1180 FIND v(dout0_21) AT=595.025n

.meas tran vdout0_22ck1180 FIND v(dout0_22) AT=595.025n

.meas tran vdout0_23ck1180 FIND v(dout0_23) AT=595.025n

.meas tran vdout0_24ck1180 FIND v(dout0_24) AT=595.025n

.meas tran vdout0_25ck1180 FIND v(dout0_25) AT=595.025n

.meas tran vdout0_26ck1180 FIND v(dout0_26) AT=595.025n

.meas tran vdout0_27ck1180 FIND v(dout0_27) AT=595.025n

.meas tran vdout0_28ck1180 FIND v(dout0_28) AT=595.025n

.meas tran vdout0_29ck1180 FIND v(dout0_29) AT=595.025n

.meas tran vdout0_30ck1180 FIND v(dout0_30) AT=595.025n

.meas tran vdout0_31ck1180 FIND v(dout0_31) AT=595.025n

.meas tran vdout0_32ck1180 FIND v(dout0_32) AT=595.025n

.meas tran vdout0_33ck1180 FIND v(dout0_33) AT=595.025n

.meas tran vdout0_34ck1180 FIND v(dout0_34) AT=595.025n

.meas tran vdout0_35ck1180 FIND v(dout0_35) AT=595.025n

.meas tran vdout0_36ck1180 FIND v(dout0_36) AT=595.025n

.meas tran vdout0_37ck1180 FIND v(dout0_37) AT=595.025n

.meas tran vdout0_38ck1180 FIND v(dout0_38) AT=595.025n

.meas tran vdout0_39ck1180 FIND v(dout0_39) AT=595.025n

.meas tran vdout0_40ck1180 FIND v(dout0_40) AT=595.025n

.meas tran vdout0_41ck1180 FIND v(dout0_41) AT=595.025n

.meas tran vdout0_42ck1180 FIND v(dout0_42) AT=595.025n

.meas tran vdout0_43ck1180 FIND v(dout0_43) AT=595.025n

.meas tran vdout0_44ck1180 FIND v(dout0_44) AT=595.025n

.meas tran vdout0_45ck1180 FIND v(dout0_45) AT=595.025n

.meas tran vdout0_46ck1180 FIND v(dout0_46) AT=595.025n

.meas tran vdout0_47ck1180 FIND v(dout0_47) AT=595.025n

.meas tran vdout0_48ck1180 FIND v(dout0_48) AT=595.025n

.meas tran vdout0_49ck1180 FIND v(dout0_49) AT=595.025n

.meas tran vdout0_50ck1180 FIND v(dout0_50) AT=595.025n

.meas tran vdout0_51ck1180 FIND v(dout0_51) AT=595.025n

.meas tran vdout0_52ck1180 FIND v(dout0_52) AT=595.025n

.meas tran vdout0_53ck1180 FIND v(dout0_53) AT=595.025n

.meas tran vdout0_54ck1180 FIND v(dout0_54) AT=595.025n

.meas tran vdout0_55ck1180 FIND v(dout0_55) AT=595.025n

.meas tran vdout0_56ck1180 FIND v(dout0_56) AT=595.025n

.meas tran vdout0_57ck1180 FIND v(dout0_57) AT=595.025n

.meas tran vdout0_58ck1180 FIND v(dout0_58) AT=595.025n

.meas tran vdout0_59ck1180 FIND v(dout0_59) AT=595.025n

.meas tran vdout0_60ck1180 FIND v(dout0_60) AT=595.025n

.meas tran vdout0_61ck1180 FIND v(dout0_61) AT=595.025n

.meas tran vdout0_62ck1180 FIND v(dout0_62) AT=595.025n

.meas tran vdout0_63ck1180 FIND v(dout0_63) AT=595.025n

.meas tran vdout0_64ck1180 FIND v(dout0_64) AT=595.025n

.meas tran vdout0_65ck1180 FIND v(dout0_65) AT=595.025n

.meas tran vdout0_66ck1180 FIND v(dout0_66) AT=595.025n

.meas tran vdout0_67ck1180 FIND v(dout0_67) AT=595.025n

.meas tran vdout0_68ck1180 FIND v(dout0_68) AT=595.025n

.meas tran vdout0_69ck1180 FIND v(dout0_69) AT=595.025n

.meas tran vdout0_70ck1180 FIND v(dout0_70) AT=595.025n

.meas tran vdout0_71ck1180 FIND v(dout0_71) AT=595.025n

.meas tran vdout0_72ck1180 FIND v(dout0_72) AT=595.025n

.meas tran vdout0_73ck1180 FIND v(dout0_73) AT=595.025n

.meas tran vdout0_74ck1180 FIND v(dout0_74) AT=595.025n

.meas tran vdout0_75ck1180 FIND v(dout0_75) AT=595.025n

.meas tran vdout0_76ck1180 FIND v(dout0_76) AT=595.025n

.meas tran vdout0_77ck1180 FIND v(dout0_77) AT=595.025n

.meas tran vdout0_78ck1180 FIND v(dout0_78) AT=595.025n

.meas tran vdout0_79ck1180 FIND v(dout0_79) AT=595.025n

.meas tran vdout0_80ck1180 FIND v(dout0_80) AT=595.025n

.meas tran vdout0_81ck1180 FIND v(dout0_81) AT=595.025n

.meas tran vdout0_82ck1180 FIND v(dout0_82) AT=595.025n

.meas tran vdout0_83ck1180 FIND v(dout0_83) AT=595.025n

.meas tran vdout0_84ck1180 FIND v(dout0_84) AT=595.025n

.meas tran vdout0_85ck1180 FIND v(dout0_85) AT=595.025n

.meas tran vdout0_86ck1180 FIND v(dout0_86) AT=595.025n

.meas tran vdout0_87ck1180 FIND v(dout0_87) AT=595.025n

.meas tran vdout0_88ck1180 FIND v(dout0_88) AT=595.025n

.meas tran vdout0_89ck1180 FIND v(dout0_89) AT=595.025n

.meas tran vdout0_90ck1180 FIND v(dout0_90) AT=595.025n

.meas tran vdout0_91ck1180 FIND v(dout0_91) AT=595.025n

.meas tran vdout0_92ck1180 FIND v(dout0_92) AT=595.025n

.meas tran vdout0_93ck1180 FIND v(dout0_93) AT=595.025n

.meas tran vdout0_94ck1180 FIND v(dout0_94) AT=595.025n

.meas tran vdout0_95ck1180 FIND v(dout0_95) AT=595.025n

.meas tran vdout0_96ck1180 FIND v(dout0_96) AT=595.025n

.meas tran vdout0_97ck1180 FIND v(dout0_97) AT=595.025n

.meas tran vdout0_98ck1180 FIND v(dout0_98) AT=595.025n

.meas tran vdout0_99ck1180 FIND v(dout0_99) AT=595.025n

.meas tran vdout0_100ck1180 FIND v(dout0_100) AT=595.025n

.meas tran vdout0_101ck1180 FIND v(dout0_101) AT=595.025n

.meas tran vdout0_102ck1180 FIND v(dout0_102) AT=595.025n

.meas tran vdout0_103ck1180 FIND v(dout0_103) AT=595.025n

.meas tran vdout0_104ck1180 FIND v(dout0_104) AT=595.025n

.meas tran vdout0_105ck1180 FIND v(dout0_105) AT=595.025n

.meas tran vdout0_106ck1180 FIND v(dout0_106) AT=595.025n

.meas tran vdout0_107ck1180 FIND v(dout0_107) AT=595.025n

.meas tran vdout0_108ck1180 FIND v(dout0_108) AT=595.025n

.meas tran vdout0_109ck1180 FIND v(dout0_109) AT=595.025n

.meas tran vdout0_110ck1180 FIND v(dout0_110) AT=595.025n

.meas tran vdout0_111ck1180 FIND v(dout0_111) AT=595.025n

.meas tran vdout0_112ck1180 FIND v(dout0_112) AT=595.025n

.meas tran vdout0_113ck1180 FIND v(dout0_113) AT=595.025n

.meas tran vdout0_114ck1180 FIND v(dout0_114) AT=595.025n

.meas tran vdout0_115ck1180 FIND v(dout0_115) AT=595.025n

.meas tran vdout0_116ck1180 FIND v(dout0_116) AT=595.025n

.meas tran vdout0_117ck1180 FIND v(dout0_117) AT=595.025n

.meas tran vdout0_118ck1180 FIND v(dout0_118) AT=595.025n

.meas tran vdout0_119ck1180 FIND v(dout0_119) AT=595.025n

.meas tran vdout0_120ck1180 FIND v(dout0_120) AT=595.025n

.meas tran vdout0_121ck1180 FIND v(dout0_121) AT=595.025n

.meas tran vdout0_122ck1180 FIND v(dout0_122) AT=595.025n

.meas tran vdout0_123ck1180 FIND v(dout0_123) AT=595.025n

.meas tran vdout0_124ck1180 FIND v(dout0_124) AT=595.025n

.meas tran vdout0_125ck1180 FIND v(dout0_125) AT=595.025n

.meas tran vdout0_126ck1180 FIND v(dout0_126) AT=595.025n

.meas tran vdout0_127ck1180 FIND v(dout0_127) AT=595.025n

.meas tran vdout0_128ck1180 FIND v(dout0_128) AT=595.025n

.meas tran vdout0_129ck1180 FIND v(dout0_129) AT=595.025n

.meas tran vdout0_130ck1180 FIND v(dout0_130) AT=595.025n

.meas tran vdout0_131ck1180 FIND v(dout0_131) AT=595.025n

.meas tran vdout0_132ck1180 FIND v(dout0_132) AT=595.025n

.meas tran vdout0_133ck1180 FIND v(dout0_133) AT=595.025n

.meas tran vdout0_134ck1180 FIND v(dout0_134) AT=595.025n

.meas tran vdout0_135ck1180 FIND v(dout0_135) AT=595.025n

.meas tran vdout0_136ck1180 FIND v(dout0_136) AT=595.025n

.meas tran vdout0_137ck1180 FIND v(dout0_137) AT=595.025n

.meas tran vdout0_138ck1180 FIND v(dout0_138) AT=595.025n

.meas tran vdout0_139ck1180 FIND v(dout0_139) AT=595.025n

.meas tran vdout0_140ck1180 FIND v(dout0_140) AT=595.025n

.meas tran vdout0_141ck1180 FIND v(dout0_141) AT=595.025n

.meas tran vdout0_142ck1180 FIND v(dout0_142) AT=595.025n

.meas tran vdout0_143ck1180 FIND v(dout0_143) AT=595.025n

.meas tran vdout0_144ck1180 FIND v(dout0_144) AT=595.025n

.meas tran vdout0_145ck1180 FIND v(dout0_145) AT=595.025n

.meas tran vdout0_146ck1180 FIND v(dout0_146) AT=595.025n

.meas tran vdout0_147ck1180 FIND v(dout0_147) AT=595.025n

.meas tran vdout0_148ck1180 FIND v(dout0_148) AT=595.025n

.meas tran vdout0_149ck1180 FIND v(dout0_149) AT=595.025n

.meas tran vdout0_0ck1190 FIND v(dout0_0) AT=600.025n

.meas tran vdout0_1ck1190 FIND v(dout0_1) AT=600.025n

.meas tran vdout0_2ck1190 FIND v(dout0_2) AT=600.025n

.meas tran vdout0_3ck1190 FIND v(dout0_3) AT=600.025n

.meas tran vdout0_4ck1190 FIND v(dout0_4) AT=600.025n

.meas tran vdout0_5ck1190 FIND v(dout0_5) AT=600.025n

.meas tran vdout0_6ck1190 FIND v(dout0_6) AT=600.025n

.meas tran vdout0_7ck1190 FIND v(dout0_7) AT=600.025n

.meas tran vdout0_8ck1190 FIND v(dout0_8) AT=600.025n

.meas tran vdout0_9ck1190 FIND v(dout0_9) AT=600.025n

.meas tran vdout0_10ck1190 FIND v(dout0_10) AT=600.025n

.meas tran vdout0_11ck1190 FIND v(dout0_11) AT=600.025n

.meas tran vdout0_12ck1190 FIND v(dout0_12) AT=600.025n

.meas tran vdout0_13ck1190 FIND v(dout0_13) AT=600.025n

.meas tran vdout0_14ck1190 FIND v(dout0_14) AT=600.025n

.meas tran vdout0_15ck1190 FIND v(dout0_15) AT=600.025n

.meas tran vdout0_16ck1190 FIND v(dout0_16) AT=600.025n

.meas tran vdout0_17ck1190 FIND v(dout0_17) AT=600.025n

.meas tran vdout0_18ck1190 FIND v(dout0_18) AT=600.025n

.meas tran vdout0_19ck1190 FIND v(dout0_19) AT=600.025n

.meas tran vdout0_20ck1190 FIND v(dout0_20) AT=600.025n

.meas tran vdout0_21ck1190 FIND v(dout0_21) AT=600.025n

.meas tran vdout0_22ck1190 FIND v(dout0_22) AT=600.025n

.meas tran vdout0_23ck1190 FIND v(dout0_23) AT=600.025n

.meas tran vdout0_24ck1190 FIND v(dout0_24) AT=600.025n

.meas tran vdout0_25ck1190 FIND v(dout0_25) AT=600.025n

.meas tran vdout0_26ck1190 FIND v(dout0_26) AT=600.025n

.meas tran vdout0_27ck1190 FIND v(dout0_27) AT=600.025n

.meas tran vdout0_28ck1190 FIND v(dout0_28) AT=600.025n

.meas tran vdout0_29ck1190 FIND v(dout0_29) AT=600.025n

.meas tran vdout0_30ck1190 FIND v(dout0_30) AT=600.025n

.meas tran vdout0_31ck1190 FIND v(dout0_31) AT=600.025n

.meas tran vdout0_32ck1190 FIND v(dout0_32) AT=600.025n

.meas tran vdout0_33ck1190 FIND v(dout0_33) AT=600.025n

.meas tran vdout0_34ck1190 FIND v(dout0_34) AT=600.025n

.meas tran vdout0_35ck1190 FIND v(dout0_35) AT=600.025n

.meas tran vdout0_36ck1190 FIND v(dout0_36) AT=600.025n

.meas tran vdout0_37ck1190 FIND v(dout0_37) AT=600.025n

.meas tran vdout0_38ck1190 FIND v(dout0_38) AT=600.025n

.meas tran vdout0_39ck1190 FIND v(dout0_39) AT=600.025n

.meas tran vdout0_40ck1190 FIND v(dout0_40) AT=600.025n

.meas tran vdout0_41ck1190 FIND v(dout0_41) AT=600.025n

.meas tran vdout0_42ck1190 FIND v(dout0_42) AT=600.025n

.meas tran vdout0_43ck1190 FIND v(dout0_43) AT=600.025n

.meas tran vdout0_44ck1190 FIND v(dout0_44) AT=600.025n

.meas tran vdout0_45ck1190 FIND v(dout0_45) AT=600.025n

.meas tran vdout0_46ck1190 FIND v(dout0_46) AT=600.025n

.meas tran vdout0_47ck1190 FIND v(dout0_47) AT=600.025n

.meas tran vdout0_48ck1190 FIND v(dout0_48) AT=600.025n

.meas tran vdout0_49ck1190 FIND v(dout0_49) AT=600.025n

.meas tran vdout0_50ck1190 FIND v(dout0_50) AT=600.025n

.meas tran vdout0_51ck1190 FIND v(dout0_51) AT=600.025n

.meas tran vdout0_52ck1190 FIND v(dout0_52) AT=600.025n

.meas tran vdout0_53ck1190 FIND v(dout0_53) AT=600.025n

.meas tran vdout0_54ck1190 FIND v(dout0_54) AT=600.025n

.meas tran vdout0_55ck1190 FIND v(dout0_55) AT=600.025n

.meas tran vdout0_56ck1190 FIND v(dout0_56) AT=600.025n

.meas tran vdout0_57ck1190 FIND v(dout0_57) AT=600.025n

.meas tran vdout0_58ck1190 FIND v(dout0_58) AT=600.025n

.meas tran vdout0_59ck1190 FIND v(dout0_59) AT=600.025n

.meas tran vdout0_60ck1190 FIND v(dout0_60) AT=600.025n

.meas tran vdout0_61ck1190 FIND v(dout0_61) AT=600.025n

.meas tran vdout0_62ck1190 FIND v(dout0_62) AT=600.025n

.meas tran vdout0_63ck1190 FIND v(dout0_63) AT=600.025n

.meas tran vdout0_64ck1190 FIND v(dout0_64) AT=600.025n

.meas tran vdout0_65ck1190 FIND v(dout0_65) AT=600.025n

.meas tran vdout0_66ck1190 FIND v(dout0_66) AT=600.025n

.meas tran vdout0_67ck1190 FIND v(dout0_67) AT=600.025n

.meas tran vdout0_68ck1190 FIND v(dout0_68) AT=600.025n

.meas tran vdout0_69ck1190 FIND v(dout0_69) AT=600.025n

.meas tran vdout0_70ck1190 FIND v(dout0_70) AT=600.025n

.meas tran vdout0_71ck1190 FIND v(dout0_71) AT=600.025n

.meas tran vdout0_72ck1190 FIND v(dout0_72) AT=600.025n

.meas tran vdout0_73ck1190 FIND v(dout0_73) AT=600.025n

.meas tran vdout0_74ck1190 FIND v(dout0_74) AT=600.025n

.meas tran vdout0_75ck1190 FIND v(dout0_75) AT=600.025n

.meas tran vdout0_76ck1190 FIND v(dout0_76) AT=600.025n

.meas tran vdout0_77ck1190 FIND v(dout0_77) AT=600.025n

.meas tran vdout0_78ck1190 FIND v(dout0_78) AT=600.025n

.meas tran vdout0_79ck1190 FIND v(dout0_79) AT=600.025n

.meas tran vdout0_80ck1190 FIND v(dout0_80) AT=600.025n

.meas tran vdout0_81ck1190 FIND v(dout0_81) AT=600.025n

.meas tran vdout0_82ck1190 FIND v(dout0_82) AT=600.025n

.meas tran vdout0_83ck1190 FIND v(dout0_83) AT=600.025n

.meas tran vdout0_84ck1190 FIND v(dout0_84) AT=600.025n

.meas tran vdout0_85ck1190 FIND v(dout0_85) AT=600.025n

.meas tran vdout0_86ck1190 FIND v(dout0_86) AT=600.025n

.meas tran vdout0_87ck1190 FIND v(dout0_87) AT=600.025n

.meas tran vdout0_88ck1190 FIND v(dout0_88) AT=600.025n

.meas tran vdout0_89ck1190 FIND v(dout0_89) AT=600.025n

.meas tran vdout0_90ck1190 FIND v(dout0_90) AT=600.025n

.meas tran vdout0_91ck1190 FIND v(dout0_91) AT=600.025n

.meas tran vdout0_92ck1190 FIND v(dout0_92) AT=600.025n

.meas tran vdout0_93ck1190 FIND v(dout0_93) AT=600.025n

.meas tran vdout0_94ck1190 FIND v(dout0_94) AT=600.025n

.meas tran vdout0_95ck1190 FIND v(dout0_95) AT=600.025n

.meas tran vdout0_96ck1190 FIND v(dout0_96) AT=600.025n

.meas tran vdout0_97ck1190 FIND v(dout0_97) AT=600.025n

.meas tran vdout0_98ck1190 FIND v(dout0_98) AT=600.025n

.meas tran vdout0_99ck1190 FIND v(dout0_99) AT=600.025n

.meas tran vdout0_100ck1190 FIND v(dout0_100) AT=600.025n

.meas tran vdout0_101ck1190 FIND v(dout0_101) AT=600.025n

.meas tran vdout0_102ck1190 FIND v(dout0_102) AT=600.025n

.meas tran vdout0_103ck1190 FIND v(dout0_103) AT=600.025n

.meas tran vdout0_104ck1190 FIND v(dout0_104) AT=600.025n

.meas tran vdout0_105ck1190 FIND v(dout0_105) AT=600.025n

.meas tran vdout0_106ck1190 FIND v(dout0_106) AT=600.025n

.meas tran vdout0_107ck1190 FIND v(dout0_107) AT=600.025n

.meas tran vdout0_108ck1190 FIND v(dout0_108) AT=600.025n

.meas tran vdout0_109ck1190 FIND v(dout0_109) AT=600.025n

.meas tran vdout0_110ck1190 FIND v(dout0_110) AT=600.025n

.meas tran vdout0_111ck1190 FIND v(dout0_111) AT=600.025n

.meas tran vdout0_112ck1190 FIND v(dout0_112) AT=600.025n

.meas tran vdout0_113ck1190 FIND v(dout0_113) AT=600.025n

.meas tran vdout0_114ck1190 FIND v(dout0_114) AT=600.025n

.meas tran vdout0_115ck1190 FIND v(dout0_115) AT=600.025n

.meas tran vdout0_116ck1190 FIND v(dout0_116) AT=600.025n

.meas tran vdout0_117ck1190 FIND v(dout0_117) AT=600.025n

.meas tran vdout0_118ck1190 FIND v(dout0_118) AT=600.025n

.meas tran vdout0_119ck1190 FIND v(dout0_119) AT=600.025n

.meas tran vdout0_120ck1190 FIND v(dout0_120) AT=600.025n

.meas tran vdout0_121ck1190 FIND v(dout0_121) AT=600.025n

.meas tran vdout0_122ck1190 FIND v(dout0_122) AT=600.025n

.meas tran vdout0_123ck1190 FIND v(dout0_123) AT=600.025n

.meas tran vdout0_124ck1190 FIND v(dout0_124) AT=600.025n

.meas tran vdout0_125ck1190 FIND v(dout0_125) AT=600.025n

.meas tran vdout0_126ck1190 FIND v(dout0_126) AT=600.025n

.meas tran vdout0_127ck1190 FIND v(dout0_127) AT=600.025n

.meas tran vdout0_128ck1190 FIND v(dout0_128) AT=600.025n

.meas tran vdout0_129ck1190 FIND v(dout0_129) AT=600.025n

.meas tran vdout0_130ck1190 FIND v(dout0_130) AT=600.025n

.meas tran vdout0_131ck1190 FIND v(dout0_131) AT=600.025n

.meas tran vdout0_132ck1190 FIND v(dout0_132) AT=600.025n

.meas tran vdout0_133ck1190 FIND v(dout0_133) AT=600.025n

.meas tran vdout0_134ck1190 FIND v(dout0_134) AT=600.025n

.meas tran vdout0_135ck1190 FIND v(dout0_135) AT=600.025n

.meas tran vdout0_136ck1190 FIND v(dout0_136) AT=600.025n

.meas tran vdout0_137ck1190 FIND v(dout0_137) AT=600.025n

.meas tran vdout0_138ck1190 FIND v(dout0_138) AT=600.025n

.meas tran vdout0_139ck1190 FIND v(dout0_139) AT=600.025n

.meas tran vdout0_140ck1190 FIND v(dout0_140) AT=600.025n

.meas tran vdout0_141ck1190 FIND v(dout0_141) AT=600.025n

.meas tran vdout0_142ck1190 FIND v(dout0_142) AT=600.025n

.meas tran vdout0_143ck1190 FIND v(dout0_143) AT=600.025n

.meas tran vdout0_144ck1190 FIND v(dout0_144) AT=600.025n

.meas tran vdout0_145ck1190 FIND v(dout0_145) AT=600.025n

.meas tran vdout0_146ck1190 FIND v(dout0_146) AT=600.025n

.meas tran vdout0_147ck1190 FIND v(dout0_147) AT=600.025n

.meas tran vdout0_148ck1190 FIND v(dout0_148) AT=600.025n

.meas tran vdout0_149ck1190 FIND v(dout0_149) AT=600.025n

.meas tran vdout0_0ck1210 FIND v(dout0_0) AT=610.025n

.meas tran vdout0_1ck1210 FIND v(dout0_1) AT=610.025n

.meas tran vdout0_2ck1210 FIND v(dout0_2) AT=610.025n

.meas tran vdout0_3ck1210 FIND v(dout0_3) AT=610.025n

.meas tran vdout0_4ck1210 FIND v(dout0_4) AT=610.025n

.meas tran vdout0_5ck1210 FIND v(dout0_5) AT=610.025n

.meas tran vdout0_6ck1210 FIND v(dout0_6) AT=610.025n

.meas tran vdout0_7ck1210 FIND v(dout0_7) AT=610.025n

.meas tran vdout0_8ck1210 FIND v(dout0_8) AT=610.025n

.meas tran vdout0_9ck1210 FIND v(dout0_9) AT=610.025n

.meas tran vdout0_10ck1210 FIND v(dout0_10) AT=610.025n

.meas tran vdout0_11ck1210 FIND v(dout0_11) AT=610.025n

.meas tran vdout0_12ck1210 FIND v(dout0_12) AT=610.025n

.meas tran vdout0_13ck1210 FIND v(dout0_13) AT=610.025n

.meas tran vdout0_14ck1210 FIND v(dout0_14) AT=610.025n

.meas tran vdout0_15ck1210 FIND v(dout0_15) AT=610.025n

.meas tran vdout0_16ck1210 FIND v(dout0_16) AT=610.025n

.meas tran vdout0_17ck1210 FIND v(dout0_17) AT=610.025n

.meas tran vdout0_18ck1210 FIND v(dout0_18) AT=610.025n

.meas tran vdout0_19ck1210 FIND v(dout0_19) AT=610.025n

.meas tran vdout0_20ck1210 FIND v(dout0_20) AT=610.025n

.meas tran vdout0_21ck1210 FIND v(dout0_21) AT=610.025n

.meas tran vdout0_22ck1210 FIND v(dout0_22) AT=610.025n

.meas tran vdout0_23ck1210 FIND v(dout0_23) AT=610.025n

.meas tran vdout0_24ck1210 FIND v(dout0_24) AT=610.025n

.meas tran vdout0_25ck1210 FIND v(dout0_25) AT=610.025n

.meas tran vdout0_26ck1210 FIND v(dout0_26) AT=610.025n

.meas tran vdout0_27ck1210 FIND v(dout0_27) AT=610.025n

.meas tran vdout0_28ck1210 FIND v(dout0_28) AT=610.025n

.meas tran vdout0_29ck1210 FIND v(dout0_29) AT=610.025n

.meas tran vdout0_30ck1210 FIND v(dout0_30) AT=610.025n

.meas tran vdout0_31ck1210 FIND v(dout0_31) AT=610.025n

.meas tran vdout0_32ck1210 FIND v(dout0_32) AT=610.025n

.meas tran vdout0_33ck1210 FIND v(dout0_33) AT=610.025n

.meas tran vdout0_34ck1210 FIND v(dout0_34) AT=610.025n

.meas tran vdout0_35ck1210 FIND v(dout0_35) AT=610.025n

.meas tran vdout0_36ck1210 FIND v(dout0_36) AT=610.025n

.meas tran vdout0_37ck1210 FIND v(dout0_37) AT=610.025n

.meas tran vdout0_38ck1210 FIND v(dout0_38) AT=610.025n

.meas tran vdout0_39ck1210 FIND v(dout0_39) AT=610.025n

.meas tran vdout0_40ck1210 FIND v(dout0_40) AT=610.025n

.meas tran vdout0_41ck1210 FIND v(dout0_41) AT=610.025n

.meas tran vdout0_42ck1210 FIND v(dout0_42) AT=610.025n

.meas tran vdout0_43ck1210 FIND v(dout0_43) AT=610.025n

.meas tran vdout0_44ck1210 FIND v(dout0_44) AT=610.025n

.meas tran vdout0_45ck1210 FIND v(dout0_45) AT=610.025n

.meas tran vdout0_46ck1210 FIND v(dout0_46) AT=610.025n

.meas tran vdout0_47ck1210 FIND v(dout0_47) AT=610.025n

.meas tran vdout0_48ck1210 FIND v(dout0_48) AT=610.025n

.meas tran vdout0_49ck1210 FIND v(dout0_49) AT=610.025n

.meas tran vdout0_50ck1210 FIND v(dout0_50) AT=610.025n

.meas tran vdout0_51ck1210 FIND v(dout0_51) AT=610.025n

.meas tran vdout0_52ck1210 FIND v(dout0_52) AT=610.025n

.meas tran vdout0_53ck1210 FIND v(dout0_53) AT=610.025n

.meas tran vdout0_54ck1210 FIND v(dout0_54) AT=610.025n

.meas tran vdout0_55ck1210 FIND v(dout0_55) AT=610.025n

.meas tran vdout0_56ck1210 FIND v(dout0_56) AT=610.025n

.meas tran vdout0_57ck1210 FIND v(dout0_57) AT=610.025n

.meas tran vdout0_58ck1210 FIND v(dout0_58) AT=610.025n

.meas tran vdout0_59ck1210 FIND v(dout0_59) AT=610.025n

.meas tran vdout0_60ck1210 FIND v(dout0_60) AT=610.025n

.meas tran vdout0_61ck1210 FIND v(dout0_61) AT=610.025n

.meas tran vdout0_62ck1210 FIND v(dout0_62) AT=610.025n

.meas tran vdout0_63ck1210 FIND v(dout0_63) AT=610.025n

.meas tran vdout0_64ck1210 FIND v(dout0_64) AT=610.025n

.meas tran vdout0_65ck1210 FIND v(dout0_65) AT=610.025n

.meas tran vdout0_66ck1210 FIND v(dout0_66) AT=610.025n

.meas tran vdout0_67ck1210 FIND v(dout0_67) AT=610.025n

.meas tran vdout0_68ck1210 FIND v(dout0_68) AT=610.025n

.meas tran vdout0_69ck1210 FIND v(dout0_69) AT=610.025n

.meas tran vdout0_70ck1210 FIND v(dout0_70) AT=610.025n

.meas tran vdout0_71ck1210 FIND v(dout0_71) AT=610.025n

.meas tran vdout0_72ck1210 FIND v(dout0_72) AT=610.025n

.meas tran vdout0_73ck1210 FIND v(dout0_73) AT=610.025n

.meas tran vdout0_74ck1210 FIND v(dout0_74) AT=610.025n

.meas tran vdout0_75ck1210 FIND v(dout0_75) AT=610.025n

.meas tran vdout0_76ck1210 FIND v(dout0_76) AT=610.025n

.meas tran vdout0_77ck1210 FIND v(dout0_77) AT=610.025n

.meas tran vdout0_78ck1210 FIND v(dout0_78) AT=610.025n

.meas tran vdout0_79ck1210 FIND v(dout0_79) AT=610.025n

.meas tran vdout0_80ck1210 FIND v(dout0_80) AT=610.025n

.meas tran vdout0_81ck1210 FIND v(dout0_81) AT=610.025n

.meas tran vdout0_82ck1210 FIND v(dout0_82) AT=610.025n

.meas tran vdout0_83ck1210 FIND v(dout0_83) AT=610.025n

.meas tran vdout0_84ck1210 FIND v(dout0_84) AT=610.025n

.meas tran vdout0_85ck1210 FIND v(dout0_85) AT=610.025n

.meas tran vdout0_86ck1210 FIND v(dout0_86) AT=610.025n

.meas tran vdout0_87ck1210 FIND v(dout0_87) AT=610.025n

.meas tran vdout0_88ck1210 FIND v(dout0_88) AT=610.025n

.meas tran vdout0_89ck1210 FIND v(dout0_89) AT=610.025n

.meas tran vdout0_90ck1210 FIND v(dout0_90) AT=610.025n

.meas tran vdout0_91ck1210 FIND v(dout0_91) AT=610.025n

.meas tran vdout0_92ck1210 FIND v(dout0_92) AT=610.025n

.meas tran vdout0_93ck1210 FIND v(dout0_93) AT=610.025n

.meas tran vdout0_94ck1210 FIND v(dout0_94) AT=610.025n

.meas tran vdout0_95ck1210 FIND v(dout0_95) AT=610.025n

.meas tran vdout0_96ck1210 FIND v(dout0_96) AT=610.025n

.meas tran vdout0_97ck1210 FIND v(dout0_97) AT=610.025n

.meas tran vdout0_98ck1210 FIND v(dout0_98) AT=610.025n

.meas tran vdout0_99ck1210 FIND v(dout0_99) AT=610.025n

.meas tran vdout0_100ck1210 FIND v(dout0_100) AT=610.025n

.meas tran vdout0_101ck1210 FIND v(dout0_101) AT=610.025n

.meas tran vdout0_102ck1210 FIND v(dout0_102) AT=610.025n

.meas tran vdout0_103ck1210 FIND v(dout0_103) AT=610.025n

.meas tran vdout0_104ck1210 FIND v(dout0_104) AT=610.025n

.meas tran vdout0_105ck1210 FIND v(dout0_105) AT=610.025n

.meas tran vdout0_106ck1210 FIND v(dout0_106) AT=610.025n

.meas tran vdout0_107ck1210 FIND v(dout0_107) AT=610.025n

.meas tran vdout0_108ck1210 FIND v(dout0_108) AT=610.025n

.meas tran vdout0_109ck1210 FIND v(dout0_109) AT=610.025n

.meas tran vdout0_110ck1210 FIND v(dout0_110) AT=610.025n

.meas tran vdout0_111ck1210 FIND v(dout0_111) AT=610.025n

.meas tran vdout0_112ck1210 FIND v(dout0_112) AT=610.025n

.meas tran vdout0_113ck1210 FIND v(dout0_113) AT=610.025n

.meas tran vdout0_114ck1210 FIND v(dout0_114) AT=610.025n

.meas tran vdout0_115ck1210 FIND v(dout0_115) AT=610.025n

.meas tran vdout0_116ck1210 FIND v(dout0_116) AT=610.025n

.meas tran vdout0_117ck1210 FIND v(dout0_117) AT=610.025n

.meas tran vdout0_118ck1210 FIND v(dout0_118) AT=610.025n

.meas tran vdout0_119ck1210 FIND v(dout0_119) AT=610.025n

.meas tran vdout0_120ck1210 FIND v(dout0_120) AT=610.025n

.meas tran vdout0_121ck1210 FIND v(dout0_121) AT=610.025n

.meas tran vdout0_122ck1210 FIND v(dout0_122) AT=610.025n

.meas tran vdout0_123ck1210 FIND v(dout0_123) AT=610.025n

.meas tran vdout0_124ck1210 FIND v(dout0_124) AT=610.025n

.meas tran vdout0_125ck1210 FIND v(dout0_125) AT=610.025n

.meas tran vdout0_126ck1210 FIND v(dout0_126) AT=610.025n

.meas tran vdout0_127ck1210 FIND v(dout0_127) AT=610.025n

.meas tran vdout0_128ck1210 FIND v(dout0_128) AT=610.025n

.meas tran vdout0_129ck1210 FIND v(dout0_129) AT=610.025n

.meas tran vdout0_130ck1210 FIND v(dout0_130) AT=610.025n

.meas tran vdout0_131ck1210 FIND v(dout0_131) AT=610.025n

.meas tran vdout0_132ck1210 FIND v(dout0_132) AT=610.025n

.meas tran vdout0_133ck1210 FIND v(dout0_133) AT=610.025n

.meas tran vdout0_134ck1210 FIND v(dout0_134) AT=610.025n

.meas tran vdout0_135ck1210 FIND v(dout0_135) AT=610.025n

.meas tran vdout0_136ck1210 FIND v(dout0_136) AT=610.025n

.meas tran vdout0_137ck1210 FIND v(dout0_137) AT=610.025n

.meas tran vdout0_138ck1210 FIND v(dout0_138) AT=610.025n

.meas tran vdout0_139ck1210 FIND v(dout0_139) AT=610.025n

.meas tran vdout0_140ck1210 FIND v(dout0_140) AT=610.025n

.meas tran vdout0_141ck1210 FIND v(dout0_141) AT=610.025n

.meas tran vdout0_142ck1210 FIND v(dout0_142) AT=610.025n

.meas tran vdout0_143ck1210 FIND v(dout0_143) AT=610.025n

.meas tran vdout0_144ck1210 FIND v(dout0_144) AT=610.025n

.meas tran vdout0_145ck1210 FIND v(dout0_145) AT=610.025n

.meas tran vdout0_146ck1210 FIND v(dout0_146) AT=610.025n

.meas tran vdout0_147ck1210 FIND v(dout0_147) AT=610.025n

.meas tran vdout0_148ck1210 FIND v(dout0_148) AT=610.025n

.meas tran vdout0_149ck1210 FIND v(dout0_149) AT=610.025n

.meas tran vdout0_0ck1230 FIND v(dout0_0) AT=620.025n

.meas tran vdout0_1ck1230 FIND v(dout0_1) AT=620.025n

.meas tran vdout0_2ck1230 FIND v(dout0_2) AT=620.025n

.meas tran vdout0_3ck1230 FIND v(dout0_3) AT=620.025n

.meas tran vdout0_4ck1230 FIND v(dout0_4) AT=620.025n

.meas tran vdout0_5ck1230 FIND v(dout0_5) AT=620.025n

.meas tran vdout0_6ck1230 FIND v(dout0_6) AT=620.025n

.meas tran vdout0_7ck1230 FIND v(dout0_7) AT=620.025n

.meas tran vdout0_8ck1230 FIND v(dout0_8) AT=620.025n

.meas tran vdout0_9ck1230 FIND v(dout0_9) AT=620.025n

.meas tran vdout0_10ck1230 FIND v(dout0_10) AT=620.025n

.meas tran vdout0_11ck1230 FIND v(dout0_11) AT=620.025n

.meas tran vdout0_12ck1230 FIND v(dout0_12) AT=620.025n

.meas tran vdout0_13ck1230 FIND v(dout0_13) AT=620.025n

.meas tran vdout0_14ck1230 FIND v(dout0_14) AT=620.025n

.meas tran vdout0_15ck1230 FIND v(dout0_15) AT=620.025n

.meas tran vdout0_16ck1230 FIND v(dout0_16) AT=620.025n

.meas tran vdout0_17ck1230 FIND v(dout0_17) AT=620.025n

.meas tran vdout0_18ck1230 FIND v(dout0_18) AT=620.025n

.meas tran vdout0_19ck1230 FIND v(dout0_19) AT=620.025n

.meas tran vdout0_20ck1230 FIND v(dout0_20) AT=620.025n

.meas tran vdout0_21ck1230 FIND v(dout0_21) AT=620.025n

.meas tran vdout0_22ck1230 FIND v(dout0_22) AT=620.025n

.meas tran vdout0_23ck1230 FIND v(dout0_23) AT=620.025n

.meas tran vdout0_24ck1230 FIND v(dout0_24) AT=620.025n

.meas tran vdout0_25ck1230 FIND v(dout0_25) AT=620.025n

.meas tran vdout0_26ck1230 FIND v(dout0_26) AT=620.025n

.meas tran vdout0_27ck1230 FIND v(dout0_27) AT=620.025n

.meas tran vdout0_28ck1230 FIND v(dout0_28) AT=620.025n

.meas tran vdout0_29ck1230 FIND v(dout0_29) AT=620.025n

.meas tran vdout0_30ck1230 FIND v(dout0_30) AT=620.025n

.meas tran vdout0_31ck1230 FIND v(dout0_31) AT=620.025n

.meas tran vdout0_32ck1230 FIND v(dout0_32) AT=620.025n

.meas tran vdout0_33ck1230 FIND v(dout0_33) AT=620.025n

.meas tran vdout0_34ck1230 FIND v(dout0_34) AT=620.025n

.meas tran vdout0_35ck1230 FIND v(dout0_35) AT=620.025n

.meas tran vdout0_36ck1230 FIND v(dout0_36) AT=620.025n

.meas tran vdout0_37ck1230 FIND v(dout0_37) AT=620.025n

.meas tran vdout0_38ck1230 FIND v(dout0_38) AT=620.025n

.meas tran vdout0_39ck1230 FIND v(dout0_39) AT=620.025n

.meas tran vdout0_40ck1230 FIND v(dout0_40) AT=620.025n

.meas tran vdout0_41ck1230 FIND v(dout0_41) AT=620.025n

.meas tran vdout0_42ck1230 FIND v(dout0_42) AT=620.025n

.meas tran vdout0_43ck1230 FIND v(dout0_43) AT=620.025n

.meas tran vdout0_44ck1230 FIND v(dout0_44) AT=620.025n

.meas tran vdout0_45ck1230 FIND v(dout0_45) AT=620.025n

.meas tran vdout0_46ck1230 FIND v(dout0_46) AT=620.025n

.meas tran vdout0_47ck1230 FIND v(dout0_47) AT=620.025n

.meas tran vdout0_48ck1230 FIND v(dout0_48) AT=620.025n

.meas tran vdout0_49ck1230 FIND v(dout0_49) AT=620.025n

.meas tran vdout0_50ck1230 FIND v(dout0_50) AT=620.025n

.meas tran vdout0_51ck1230 FIND v(dout0_51) AT=620.025n

.meas tran vdout0_52ck1230 FIND v(dout0_52) AT=620.025n

.meas tran vdout0_53ck1230 FIND v(dout0_53) AT=620.025n

.meas tran vdout0_54ck1230 FIND v(dout0_54) AT=620.025n

.meas tran vdout0_55ck1230 FIND v(dout0_55) AT=620.025n

.meas tran vdout0_56ck1230 FIND v(dout0_56) AT=620.025n

.meas tran vdout0_57ck1230 FIND v(dout0_57) AT=620.025n

.meas tran vdout0_58ck1230 FIND v(dout0_58) AT=620.025n

.meas tran vdout0_59ck1230 FIND v(dout0_59) AT=620.025n

.meas tran vdout0_60ck1230 FIND v(dout0_60) AT=620.025n

.meas tran vdout0_61ck1230 FIND v(dout0_61) AT=620.025n

.meas tran vdout0_62ck1230 FIND v(dout0_62) AT=620.025n

.meas tran vdout0_63ck1230 FIND v(dout0_63) AT=620.025n

.meas tran vdout0_64ck1230 FIND v(dout0_64) AT=620.025n

.meas tran vdout0_65ck1230 FIND v(dout0_65) AT=620.025n

.meas tran vdout0_66ck1230 FIND v(dout0_66) AT=620.025n

.meas tran vdout0_67ck1230 FIND v(dout0_67) AT=620.025n

.meas tran vdout0_68ck1230 FIND v(dout0_68) AT=620.025n

.meas tran vdout0_69ck1230 FIND v(dout0_69) AT=620.025n

.meas tran vdout0_70ck1230 FIND v(dout0_70) AT=620.025n

.meas tran vdout0_71ck1230 FIND v(dout0_71) AT=620.025n

.meas tran vdout0_72ck1230 FIND v(dout0_72) AT=620.025n

.meas tran vdout0_73ck1230 FIND v(dout0_73) AT=620.025n

.meas tran vdout0_74ck1230 FIND v(dout0_74) AT=620.025n

.meas tran vdout0_75ck1230 FIND v(dout0_75) AT=620.025n

.meas tran vdout0_76ck1230 FIND v(dout0_76) AT=620.025n

.meas tran vdout0_77ck1230 FIND v(dout0_77) AT=620.025n

.meas tran vdout0_78ck1230 FIND v(dout0_78) AT=620.025n

.meas tran vdout0_79ck1230 FIND v(dout0_79) AT=620.025n

.meas tran vdout0_80ck1230 FIND v(dout0_80) AT=620.025n

.meas tran vdout0_81ck1230 FIND v(dout0_81) AT=620.025n

.meas tran vdout0_82ck1230 FIND v(dout0_82) AT=620.025n

.meas tran vdout0_83ck1230 FIND v(dout0_83) AT=620.025n

.meas tran vdout0_84ck1230 FIND v(dout0_84) AT=620.025n

.meas tran vdout0_85ck1230 FIND v(dout0_85) AT=620.025n

.meas tran vdout0_86ck1230 FIND v(dout0_86) AT=620.025n

.meas tran vdout0_87ck1230 FIND v(dout0_87) AT=620.025n

.meas tran vdout0_88ck1230 FIND v(dout0_88) AT=620.025n

.meas tran vdout0_89ck1230 FIND v(dout0_89) AT=620.025n

.meas tran vdout0_90ck1230 FIND v(dout0_90) AT=620.025n

.meas tran vdout0_91ck1230 FIND v(dout0_91) AT=620.025n

.meas tran vdout0_92ck1230 FIND v(dout0_92) AT=620.025n

.meas tran vdout0_93ck1230 FIND v(dout0_93) AT=620.025n

.meas tran vdout0_94ck1230 FIND v(dout0_94) AT=620.025n

.meas tran vdout0_95ck1230 FIND v(dout0_95) AT=620.025n

.meas tran vdout0_96ck1230 FIND v(dout0_96) AT=620.025n

.meas tran vdout0_97ck1230 FIND v(dout0_97) AT=620.025n

.meas tran vdout0_98ck1230 FIND v(dout0_98) AT=620.025n

.meas tran vdout0_99ck1230 FIND v(dout0_99) AT=620.025n

.meas tran vdout0_100ck1230 FIND v(dout0_100) AT=620.025n

.meas tran vdout0_101ck1230 FIND v(dout0_101) AT=620.025n

.meas tran vdout0_102ck1230 FIND v(dout0_102) AT=620.025n

.meas tran vdout0_103ck1230 FIND v(dout0_103) AT=620.025n

.meas tran vdout0_104ck1230 FIND v(dout0_104) AT=620.025n

.meas tran vdout0_105ck1230 FIND v(dout0_105) AT=620.025n

.meas tran vdout0_106ck1230 FIND v(dout0_106) AT=620.025n

.meas tran vdout0_107ck1230 FIND v(dout0_107) AT=620.025n

.meas tran vdout0_108ck1230 FIND v(dout0_108) AT=620.025n

.meas tran vdout0_109ck1230 FIND v(dout0_109) AT=620.025n

.meas tran vdout0_110ck1230 FIND v(dout0_110) AT=620.025n

.meas tran vdout0_111ck1230 FIND v(dout0_111) AT=620.025n

.meas tran vdout0_112ck1230 FIND v(dout0_112) AT=620.025n

.meas tran vdout0_113ck1230 FIND v(dout0_113) AT=620.025n

.meas tran vdout0_114ck1230 FIND v(dout0_114) AT=620.025n

.meas tran vdout0_115ck1230 FIND v(dout0_115) AT=620.025n

.meas tran vdout0_116ck1230 FIND v(dout0_116) AT=620.025n

.meas tran vdout0_117ck1230 FIND v(dout0_117) AT=620.025n

.meas tran vdout0_118ck1230 FIND v(dout0_118) AT=620.025n

.meas tran vdout0_119ck1230 FIND v(dout0_119) AT=620.025n

.meas tran vdout0_120ck1230 FIND v(dout0_120) AT=620.025n

.meas tran vdout0_121ck1230 FIND v(dout0_121) AT=620.025n

.meas tran vdout0_122ck1230 FIND v(dout0_122) AT=620.025n

.meas tran vdout0_123ck1230 FIND v(dout0_123) AT=620.025n

.meas tran vdout0_124ck1230 FIND v(dout0_124) AT=620.025n

.meas tran vdout0_125ck1230 FIND v(dout0_125) AT=620.025n

.meas tran vdout0_126ck1230 FIND v(dout0_126) AT=620.025n

.meas tran vdout0_127ck1230 FIND v(dout0_127) AT=620.025n

.meas tran vdout0_128ck1230 FIND v(dout0_128) AT=620.025n

.meas tran vdout0_129ck1230 FIND v(dout0_129) AT=620.025n

.meas tran vdout0_130ck1230 FIND v(dout0_130) AT=620.025n

.meas tran vdout0_131ck1230 FIND v(dout0_131) AT=620.025n

.meas tran vdout0_132ck1230 FIND v(dout0_132) AT=620.025n

.meas tran vdout0_133ck1230 FIND v(dout0_133) AT=620.025n

.meas tran vdout0_134ck1230 FIND v(dout0_134) AT=620.025n

.meas tran vdout0_135ck1230 FIND v(dout0_135) AT=620.025n

.meas tran vdout0_136ck1230 FIND v(dout0_136) AT=620.025n

.meas tran vdout0_137ck1230 FIND v(dout0_137) AT=620.025n

.meas tran vdout0_138ck1230 FIND v(dout0_138) AT=620.025n

.meas tran vdout0_139ck1230 FIND v(dout0_139) AT=620.025n

.meas tran vdout0_140ck1230 FIND v(dout0_140) AT=620.025n

.meas tran vdout0_141ck1230 FIND v(dout0_141) AT=620.025n

.meas tran vdout0_142ck1230 FIND v(dout0_142) AT=620.025n

.meas tran vdout0_143ck1230 FIND v(dout0_143) AT=620.025n

.meas tran vdout0_144ck1230 FIND v(dout0_144) AT=620.025n

.meas tran vdout0_145ck1230 FIND v(dout0_145) AT=620.025n

.meas tran vdout0_146ck1230 FIND v(dout0_146) AT=620.025n

.meas tran vdout0_147ck1230 FIND v(dout0_147) AT=620.025n

.meas tran vdout0_148ck1230 FIND v(dout0_148) AT=620.025n

.meas tran vdout0_149ck1230 FIND v(dout0_149) AT=620.025n

.meas tran vdout0_0ck1240 FIND v(dout0_0) AT=625.025n

.meas tran vdout0_1ck1240 FIND v(dout0_1) AT=625.025n

.meas tran vdout0_2ck1240 FIND v(dout0_2) AT=625.025n

.meas tran vdout0_3ck1240 FIND v(dout0_3) AT=625.025n

.meas tran vdout0_4ck1240 FIND v(dout0_4) AT=625.025n

.meas tran vdout0_5ck1240 FIND v(dout0_5) AT=625.025n

.meas tran vdout0_6ck1240 FIND v(dout0_6) AT=625.025n

.meas tran vdout0_7ck1240 FIND v(dout0_7) AT=625.025n

.meas tran vdout0_8ck1240 FIND v(dout0_8) AT=625.025n

.meas tran vdout0_9ck1240 FIND v(dout0_9) AT=625.025n

.meas tran vdout0_10ck1240 FIND v(dout0_10) AT=625.025n

.meas tran vdout0_11ck1240 FIND v(dout0_11) AT=625.025n

.meas tran vdout0_12ck1240 FIND v(dout0_12) AT=625.025n

.meas tran vdout0_13ck1240 FIND v(dout0_13) AT=625.025n

.meas tran vdout0_14ck1240 FIND v(dout0_14) AT=625.025n

.meas tran vdout0_15ck1240 FIND v(dout0_15) AT=625.025n

.meas tran vdout0_16ck1240 FIND v(dout0_16) AT=625.025n

.meas tran vdout0_17ck1240 FIND v(dout0_17) AT=625.025n

.meas tran vdout0_18ck1240 FIND v(dout0_18) AT=625.025n

.meas tran vdout0_19ck1240 FIND v(dout0_19) AT=625.025n

.meas tran vdout0_20ck1240 FIND v(dout0_20) AT=625.025n

.meas tran vdout0_21ck1240 FIND v(dout0_21) AT=625.025n

.meas tran vdout0_22ck1240 FIND v(dout0_22) AT=625.025n

.meas tran vdout0_23ck1240 FIND v(dout0_23) AT=625.025n

.meas tran vdout0_24ck1240 FIND v(dout0_24) AT=625.025n

.meas tran vdout0_25ck1240 FIND v(dout0_25) AT=625.025n

.meas tran vdout0_26ck1240 FIND v(dout0_26) AT=625.025n

.meas tran vdout0_27ck1240 FIND v(dout0_27) AT=625.025n

.meas tran vdout0_28ck1240 FIND v(dout0_28) AT=625.025n

.meas tran vdout0_29ck1240 FIND v(dout0_29) AT=625.025n

.meas tran vdout0_30ck1240 FIND v(dout0_30) AT=625.025n

.meas tran vdout0_31ck1240 FIND v(dout0_31) AT=625.025n

.meas tran vdout0_32ck1240 FIND v(dout0_32) AT=625.025n

.meas tran vdout0_33ck1240 FIND v(dout0_33) AT=625.025n

.meas tran vdout0_34ck1240 FIND v(dout0_34) AT=625.025n

.meas tran vdout0_35ck1240 FIND v(dout0_35) AT=625.025n

.meas tran vdout0_36ck1240 FIND v(dout0_36) AT=625.025n

.meas tran vdout0_37ck1240 FIND v(dout0_37) AT=625.025n

.meas tran vdout0_38ck1240 FIND v(dout0_38) AT=625.025n

.meas tran vdout0_39ck1240 FIND v(dout0_39) AT=625.025n

.meas tran vdout0_40ck1240 FIND v(dout0_40) AT=625.025n

.meas tran vdout0_41ck1240 FIND v(dout0_41) AT=625.025n

.meas tran vdout0_42ck1240 FIND v(dout0_42) AT=625.025n

.meas tran vdout0_43ck1240 FIND v(dout0_43) AT=625.025n

.meas tran vdout0_44ck1240 FIND v(dout0_44) AT=625.025n

.meas tran vdout0_45ck1240 FIND v(dout0_45) AT=625.025n

.meas tran vdout0_46ck1240 FIND v(dout0_46) AT=625.025n

.meas tran vdout0_47ck1240 FIND v(dout0_47) AT=625.025n

.meas tran vdout0_48ck1240 FIND v(dout0_48) AT=625.025n

.meas tran vdout0_49ck1240 FIND v(dout0_49) AT=625.025n

.meas tran vdout0_50ck1240 FIND v(dout0_50) AT=625.025n

.meas tran vdout0_51ck1240 FIND v(dout0_51) AT=625.025n

.meas tran vdout0_52ck1240 FIND v(dout0_52) AT=625.025n

.meas tran vdout0_53ck1240 FIND v(dout0_53) AT=625.025n

.meas tran vdout0_54ck1240 FIND v(dout0_54) AT=625.025n

.meas tran vdout0_55ck1240 FIND v(dout0_55) AT=625.025n

.meas tran vdout0_56ck1240 FIND v(dout0_56) AT=625.025n

.meas tran vdout0_57ck1240 FIND v(dout0_57) AT=625.025n

.meas tran vdout0_58ck1240 FIND v(dout0_58) AT=625.025n

.meas tran vdout0_59ck1240 FIND v(dout0_59) AT=625.025n

.meas tran vdout0_60ck1240 FIND v(dout0_60) AT=625.025n

.meas tran vdout0_61ck1240 FIND v(dout0_61) AT=625.025n

.meas tran vdout0_62ck1240 FIND v(dout0_62) AT=625.025n

.meas tran vdout0_63ck1240 FIND v(dout0_63) AT=625.025n

.meas tran vdout0_64ck1240 FIND v(dout0_64) AT=625.025n

.meas tran vdout0_65ck1240 FIND v(dout0_65) AT=625.025n

.meas tran vdout0_66ck1240 FIND v(dout0_66) AT=625.025n

.meas tran vdout0_67ck1240 FIND v(dout0_67) AT=625.025n

.meas tran vdout0_68ck1240 FIND v(dout0_68) AT=625.025n

.meas tran vdout0_69ck1240 FIND v(dout0_69) AT=625.025n

.meas tran vdout0_70ck1240 FIND v(dout0_70) AT=625.025n

.meas tran vdout0_71ck1240 FIND v(dout0_71) AT=625.025n

.meas tran vdout0_72ck1240 FIND v(dout0_72) AT=625.025n

.meas tran vdout0_73ck1240 FIND v(dout0_73) AT=625.025n

.meas tran vdout0_74ck1240 FIND v(dout0_74) AT=625.025n

.meas tran vdout0_75ck1240 FIND v(dout0_75) AT=625.025n

.meas tran vdout0_76ck1240 FIND v(dout0_76) AT=625.025n

.meas tran vdout0_77ck1240 FIND v(dout0_77) AT=625.025n

.meas tran vdout0_78ck1240 FIND v(dout0_78) AT=625.025n

.meas tran vdout0_79ck1240 FIND v(dout0_79) AT=625.025n

.meas tran vdout0_80ck1240 FIND v(dout0_80) AT=625.025n

.meas tran vdout0_81ck1240 FIND v(dout0_81) AT=625.025n

.meas tran vdout0_82ck1240 FIND v(dout0_82) AT=625.025n

.meas tran vdout0_83ck1240 FIND v(dout0_83) AT=625.025n

.meas tran vdout0_84ck1240 FIND v(dout0_84) AT=625.025n

.meas tran vdout0_85ck1240 FIND v(dout0_85) AT=625.025n

.meas tran vdout0_86ck1240 FIND v(dout0_86) AT=625.025n

.meas tran vdout0_87ck1240 FIND v(dout0_87) AT=625.025n

.meas tran vdout0_88ck1240 FIND v(dout0_88) AT=625.025n

.meas tran vdout0_89ck1240 FIND v(dout0_89) AT=625.025n

.meas tran vdout0_90ck1240 FIND v(dout0_90) AT=625.025n

.meas tran vdout0_91ck1240 FIND v(dout0_91) AT=625.025n

.meas tran vdout0_92ck1240 FIND v(dout0_92) AT=625.025n

.meas tran vdout0_93ck1240 FIND v(dout0_93) AT=625.025n

.meas tran vdout0_94ck1240 FIND v(dout0_94) AT=625.025n

.meas tran vdout0_95ck1240 FIND v(dout0_95) AT=625.025n

.meas tran vdout0_96ck1240 FIND v(dout0_96) AT=625.025n

.meas tran vdout0_97ck1240 FIND v(dout0_97) AT=625.025n

.meas tran vdout0_98ck1240 FIND v(dout0_98) AT=625.025n

.meas tran vdout0_99ck1240 FIND v(dout0_99) AT=625.025n

.meas tran vdout0_100ck1240 FIND v(dout0_100) AT=625.025n

.meas tran vdout0_101ck1240 FIND v(dout0_101) AT=625.025n

.meas tran vdout0_102ck1240 FIND v(dout0_102) AT=625.025n

.meas tran vdout0_103ck1240 FIND v(dout0_103) AT=625.025n

.meas tran vdout0_104ck1240 FIND v(dout0_104) AT=625.025n

.meas tran vdout0_105ck1240 FIND v(dout0_105) AT=625.025n

.meas tran vdout0_106ck1240 FIND v(dout0_106) AT=625.025n

.meas tran vdout0_107ck1240 FIND v(dout0_107) AT=625.025n

.meas tran vdout0_108ck1240 FIND v(dout0_108) AT=625.025n

.meas tran vdout0_109ck1240 FIND v(dout0_109) AT=625.025n

.meas tran vdout0_110ck1240 FIND v(dout0_110) AT=625.025n

.meas tran vdout0_111ck1240 FIND v(dout0_111) AT=625.025n

.meas tran vdout0_112ck1240 FIND v(dout0_112) AT=625.025n

.meas tran vdout0_113ck1240 FIND v(dout0_113) AT=625.025n

.meas tran vdout0_114ck1240 FIND v(dout0_114) AT=625.025n

.meas tran vdout0_115ck1240 FIND v(dout0_115) AT=625.025n

.meas tran vdout0_116ck1240 FIND v(dout0_116) AT=625.025n

.meas tran vdout0_117ck1240 FIND v(dout0_117) AT=625.025n

.meas tran vdout0_118ck1240 FIND v(dout0_118) AT=625.025n

.meas tran vdout0_119ck1240 FIND v(dout0_119) AT=625.025n

.meas tran vdout0_120ck1240 FIND v(dout0_120) AT=625.025n

.meas tran vdout0_121ck1240 FIND v(dout0_121) AT=625.025n

.meas tran vdout0_122ck1240 FIND v(dout0_122) AT=625.025n

.meas tran vdout0_123ck1240 FIND v(dout0_123) AT=625.025n

.meas tran vdout0_124ck1240 FIND v(dout0_124) AT=625.025n

.meas tran vdout0_125ck1240 FIND v(dout0_125) AT=625.025n

.meas tran vdout0_126ck1240 FIND v(dout0_126) AT=625.025n

.meas tran vdout0_127ck1240 FIND v(dout0_127) AT=625.025n

.meas tran vdout0_128ck1240 FIND v(dout0_128) AT=625.025n

.meas tran vdout0_129ck1240 FIND v(dout0_129) AT=625.025n

.meas tran vdout0_130ck1240 FIND v(dout0_130) AT=625.025n

.meas tran vdout0_131ck1240 FIND v(dout0_131) AT=625.025n

.meas tran vdout0_132ck1240 FIND v(dout0_132) AT=625.025n

.meas tran vdout0_133ck1240 FIND v(dout0_133) AT=625.025n

.meas tran vdout0_134ck1240 FIND v(dout0_134) AT=625.025n

.meas tran vdout0_135ck1240 FIND v(dout0_135) AT=625.025n

.meas tran vdout0_136ck1240 FIND v(dout0_136) AT=625.025n

.meas tran vdout0_137ck1240 FIND v(dout0_137) AT=625.025n

.meas tran vdout0_138ck1240 FIND v(dout0_138) AT=625.025n

.meas tran vdout0_139ck1240 FIND v(dout0_139) AT=625.025n

.meas tran vdout0_140ck1240 FIND v(dout0_140) AT=625.025n

.meas tran vdout0_141ck1240 FIND v(dout0_141) AT=625.025n

.meas tran vdout0_142ck1240 FIND v(dout0_142) AT=625.025n

.meas tran vdout0_143ck1240 FIND v(dout0_143) AT=625.025n

.meas tran vdout0_144ck1240 FIND v(dout0_144) AT=625.025n

.meas tran vdout0_145ck1240 FIND v(dout0_145) AT=625.025n

.meas tran vdout0_146ck1240 FIND v(dout0_146) AT=625.025n

.meas tran vdout0_147ck1240 FIND v(dout0_147) AT=625.025n

.meas tran vdout0_148ck1240 FIND v(dout0_148) AT=625.025n

.meas tran vdout0_149ck1240 FIND v(dout0_149) AT=625.025n

.meas tran vdout0_0ck1270 FIND v(dout0_0) AT=640.025n

.meas tran vdout0_1ck1270 FIND v(dout0_1) AT=640.025n

.meas tran vdout0_2ck1270 FIND v(dout0_2) AT=640.025n

.meas tran vdout0_3ck1270 FIND v(dout0_3) AT=640.025n

.meas tran vdout0_4ck1270 FIND v(dout0_4) AT=640.025n

.meas tran vdout0_5ck1270 FIND v(dout0_5) AT=640.025n

.meas tran vdout0_6ck1270 FIND v(dout0_6) AT=640.025n

.meas tran vdout0_7ck1270 FIND v(dout0_7) AT=640.025n

.meas tran vdout0_8ck1270 FIND v(dout0_8) AT=640.025n

.meas tran vdout0_9ck1270 FIND v(dout0_9) AT=640.025n

.meas tran vdout0_10ck1270 FIND v(dout0_10) AT=640.025n

.meas tran vdout0_11ck1270 FIND v(dout0_11) AT=640.025n

.meas tran vdout0_12ck1270 FIND v(dout0_12) AT=640.025n

.meas tran vdout0_13ck1270 FIND v(dout0_13) AT=640.025n

.meas tran vdout0_14ck1270 FIND v(dout0_14) AT=640.025n

.meas tran vdout0_15ck1270 FIND v(dout0_15) AT=640.025n

.meas tran vdout0_16ck1270 FIND v(dout0_16) AT=640.025n

.meas tran vdout0_17ck1270 FIND v(dout0_17) AT=640.025n

.meas tran vdout0_18ck1270 FIND v(dout0_18) AT=640.025n

.meas tran vdout0_19ck1270 FIND v(dout0_19) AT=640.025n

.meas tran vdout0_20ck1270 FIND v(dout0_20) AT=640.025n

.meas tran vdout0_21ck1270 FIND v(dout0_21) AT=640.025n

.meas tran vdout0_22ck1270 FIND v(dout0_22) AT=640.025n

.meas tran vdout0_23ck1270 FIND v(dout0_23) AT=640.025n

.meas tran vdout0_24ck1270 FIND v(dout0_24) AT=640.025n

.meas tran vdout0_25ck1270 FIND v(dout0_25) AT=640.025n

.meas tran vdout0_26ck1270 FIND v(dout0_26) AT=640.025n

.meas tran vdout0_27ck1270 FIND v(dout0_27) AT=640.025n

.meas tran vdout0_28ck1270 FIND v(dout0_28) AT=640.025n

.meas tran vdout0_29ck1270 FIND v(dout0_29) AT=640.025n

.meas tran vdout0_30ck1270 FIND v(dout0_30) AT=640.025n

.meas tran vdout0_31ck1270 FIND v(dout0_31) AT=640.025n

.meas tran vdout0_32ck1270 FIND v(dout0_32) AT=640.025n

.meas tran vdout0_33ck1270 FIND v(dout0_33) AT=640.025n

.meas tran vdout0_34ck1270 FIND v(dout0_34) AT=640.025n

.meas tran vdout0_35ck1270 FIND v(dout0_35) AT=640.025n

.meas tran vdout0_36ck1270 FIND v(dout0_36) AT=640.025n

.meas tran vdout0_37ck1270 FIND v(dout0_37) AT=640.025n

.meas tran vdout0_38ck1270 FIND v(dout0_38) AT=640.025n

.meas tran vdout0_39ck1270 FIND v(dout0_39) AT=640.025n

.meas tran vdout0_40ck1270 FIND v(dout0_40) AT=640.025n

.meas tran vdout0_41ck1270 FIND v(dout0_41) AT=640.025n

.meas tran vdout0_42ck1270 FIND v(dout0_42) AT=640.025n

.meas tran vdout0_43ck1270 FIND v(dout0_43) AT=640.025n

.meas tran vdout0_44ck1270 FIND v(dout0_44) AT=640.025n

.meas tran vdout0_45ck1270 FIND v(dout0_45) AT=640.025n

.meas tran vdout0_46ck1270 FIND v(dout0_46) AT=640.025n

.meas tran vdout0_47ck1270 FIND v(dout0_47) AT=640.025n

.meas tran vdout0_48ck1270 FIND v(dout0_48) AT=640.025n

.meas tran vdout0_49ck1270 FIND v(dout0_49) AT=640.025n

.meas tran vdout0_50ck1270 FIND v(dout0_50) AT=640.025n

.meas tran vdout0_51ck1270 FIND v(dout0_51) AT=640.025n

.meas tran vdout0_52ck1270 FIND v(dout0_52) AT=640.025n

.meas tran vdout0_53ck1270 FIND v(dout0_53) AT=640.025n

.meas tran vdout0_54ck1270 FIND v(dout0_54) AT=640.025n

.meas tran vdout0_55ck1270 FIND v(dout0_55) AT=640.025n

.meas tran vdout0_56ck1270 FIND v(dout0_56) AT=640.025n

.meas tran vdout0_57ck1270 FIND v(dout0_57) AT=640.025n

.meas tran vdout0_58ck1270 FIND v(dout0_58) AT=640.025n

.meas tran vdout0_59ck1270 FIND v(dout0_59) AT=640.025n

.meas tran vdout0_60ck1270 FIND v(dout0_60) AT=640.025n

.meas tran vdout0_61ck1270 FIND v(dout0_61) AT=640.025n

.meas tran vdout0_62ck1270 FIND v(dout0_62) AT=640.025n

.meas tran vdout0_63ck1270 FIND v(dout0_63) AT=640.025n

.meas tran vdout0_64ck1270 FIND v(dout0_64) AT=640.025n

.meas tran vdout0_65ck1270 FIND v(dout0_65) AT=640.025n

.meas tran vdout0_66ck1270 FIND v(dout0_66) AT=640.025n

.meas tran vdout0_67ck1270 FIND v(dout0_67) AT=640.025n

.meas tran vdout0_68ck1270 FIND v(dout0_68) AT=640.025n

.meas tran vdout0_69ck1270 FIND v(dout0_69) AT=640.025n

.meas tran vdout0_70ck1270 FIND v(dout0_70) AT=640.025n

.meas tran vdout0_71ck1270 FIND v(dout0_71) AT=640.025n

.meas tran vdout0_72ck1270 FIND v(dout0_72) AT=640.025n

.meas tran vdout0_73ck1270 FIND v(dout0_73) AT=640.025n

.meas tran vdout0_74ck1270 FIND v(dout0_74) AT=640.025n

.meas tran vdout0_75ck1270 FIND v(dout0_75) AT=640.025n

.meas tran vdout0_76ck1270 FIND v(dout0_76) AT=640.025n

.meas tran vdout0_77ck1270 FIND v(dout0_77) AT=640.025n

.meas tran vdout0_78ck1270 FIND v(dout0_78) AT=640.025n

.meas tran vdout0_79ck1270 FIND v(dout0_79) AT=640.025n

.meas tran vdout0_80ck1270 FIND v(dout0_80) AT=640.025n

.meas tran vdout0_81ck1270 FIND v(dout0_81) AT=640.025n

.meas tran vdout0_82ck1270 FIND v(dout0_82) AT=640.025n

.meas tran vdout0_83ck1270 FIND v(dout0_83) AT=640.025n

.meas tran vdout0_84ck1270 FIND v(dout0_84) AT=640.025n

.meas tran vdout0_85ck1270 FIND v(dout0_85) AT=640.025n

.meas tran vdout0_86ck1270 FIND v(dout0_86) AT=640.025n

.meas tran vdout0_87ck1270 FIND v(dout0_87) AT=640.025n

.meas tran vdout0_88ck1270 FIND v(dout0_88) AT=640.025n

.meas tran vdout0_89ck1270 FIND v(dout0_89) AT=640.025n

.meas tran vdout0_90ck1270 FIND v(dout0_90) AT=640.025n

.meas tran vdout0_91ck1270 FIND v(dout0_91) AT=640.025n

.meas tran vdout0_92ck1270 FIND v(dout0_92) AT=640.025n

.meas tran vdout0_93ck1270 FIND v(dout0_93) AT=640.025n

.meas tran vdout0_94ck1270 FIND v(dout0_94) AT=640.025n

.meas tran vdout0_95ck1270 FIND v(dout0_95) AT=640.025n

.meas tran vdout0_96ck1270 FIND v(dout0_96) AT=640.025n

.meas tran vdout0_97ck1270 FIND v(dout0_97) AT=640.025n

.meas tran vdout0_98ck1270 FIND v(dout0_98) AT=640.025n

.meas tran vdout0_99ck1270 FIND v(dout0_99) AT=640.025n

.meas tran vdout0_100ck1270 FIND v(dout0_100) AT=640.025n

.meas tran vdout0_101ck1270 FIND v(dout0_101) AT=640.025n

.meas tran vdout0_102ck1270 FIND v(dout0_102) AT=640.025n

.meas tran vdout0_103ck1270 FIND v(dout0_103) AT=640.025n

.meas tran vdout0_104ck1270 FIND v(dout0_104) AT=640.025n

.meas tran vdout0_105ck1270 FIND v(dout0_105) AT=640.025n

.meas tran vdout0_106ck1270 FIND v(dout0_106) AT=640.025n

.meas tran vdout0_107ck1270 FIND v(dout0_107) AT=640.025n

.meas tran vdout0_108ck1270 FIND v(dout0_108) AT=640.025n

.meas tran vdout0_109ck1270 FIND v(dout0_109) AT=640.025n

.meas tran vdout0_110ck1270 FIND v(dout0_110) AT=640.025n

.meas tran vdout0_111ck1270 FIND v(dout0_111) AT=640.025n

.meas tran vdout0_112ck1270 FIND v(dout0_112) AT=640.025n

.meas tran vdout0_113ck1270 FIND v(dout0_113) AT=640.025n

.meas tran vdout0_114ck1270 FIND v(dout0_114) AT=640.025n

.meas tran vdout0_115ck1270 FIND v(dout0_115) AT=640.025n

.meas tran vdout0_116ck1270 FIND v(dout0_116) AT=640.025n

.meas tran vdout0_117ck1270 FIND v(dout0_117) AT=640.025n

.meas tran vdout0_118ck1270 FIND v(dout0_118) AT=640.025n

.meas tran vdout0_119ck1270 FIND v(dout0_119) AT=640.025n

.meas tran vdout0_120ck1270 FIND v(dout0_120) AT=640.025n

.meas tran vdout0_121ck1270 FIND v(dout0_121) AT=640.025n

.meas tran vdout0_122ck1270 FIND v(dout0_122) AT=640.025n

.meas tran vdout0_123ck1270 FIND v(dout0_123) AT=640.025n

.meas tran vdout0_124ck1270 FIND v(dout0_124) AT=640.025n

.meas tran vdout0_125ck1270 FIND v(dout0_125) AT=640.025n

.meas tran vdout0_126ck1270 FIND v(dout0_126) AT=640.025n

.meas tran vdout0_127ck1270 FIND v(dout0_127) AT=640.025n

.meas tran vdout0_128ck1270 FIND v(dout0_128) AT=640.025n

.meas tran vdout0_129ck1270 FIND v(dout0_129) AT=640.025n

.meas tran vdout0_130ck1270 FIND v(dout0_130) AT=640.025n

.meas tran vdout0_131ck1270 FIND v(dout0_131) AT=640.025n

.meas tran vdout0_132ck1270 FIND v(dout0_132) AT=640.025n

.meas tran vdout0_133ck1270 FIND v(dout0_133) AT=640.025n

.meas tran vdout0_134ck1270 FIND v(dout0_134) AT=640.025n

.meas tran vdout0_135ck1270 FIND v(dout0_135) AT=640.025n

.meas tran vdout0_136ck1270 FIND v(dout0_136) AT=640.025n

.meas tran vdout0_137ck1270 FIND v(dout0_137) AT=640.025n

.meas tran vdout0_138ck1270 FIND v(dout0_138) AT=640.025n

.meas tran vdout0_139ck1270 FIND v(dout0_139) AT=640.025n

.meas tran vdout0_140ck1270 FIND v(dout0_140) AT=640.025n

.meas tran vdout0_141ck1270 FIND v(dout0_141) AT=640.025n

.meas tran vdout0_142ck1270 FIND v(dout0_142) AT=640.025n

.meas tran vdout0_143ck1270 FIND v(dout0_143) AT=640.025n

.meas tran vdout0_144ck1270 FIND v(dout0_144) AT=640.025n

.meas tran vdout0_145ck1270 FIND v(dout0_145) AT=640.025n

.meas tran vdout0_146ck1270 FIND v(dout0_146) AT=640.025n

.meas tran vdout0_147ck1270 FIND v(dout0_147) AT=640.025n

.meas tran vdout0_148ck1270 FIND v(dout0_148) AT=640.025n

.meas tran vdout0_149ck1270 FIND v(dout0_149) AT=640.025n

.meas tran vdout0_0ck1290 FIND v(dout0_0) AT=650.025n

.meas tran vdout0_1ck1290 FIND v(dout0_1) AT=650.025n

.meas tran vdout0_2ck1290 FIND v(dout0_2) AT=650.025n

.meas tran vdout0_3ck1290 FIND v(dout0_3) AT=650.025n

.meas tran vdout0_4ck1290 FIND v(dout0_4) AT=650.025n

.meas tran vdout0_5ck1290 FIND v(dout0_5) AT=650.025n

.meas tran vdout0_6ck1290 FIND v(dout0_6) AT=650.025n

.meas tran vdout0_7ck1290 FIND v(dout0_7) AT=650.025n

.meas tran vdout0_8ck1290 FIND v(dout0_8) AT=650.025n

.meas tran vdout0_9ck1290 FIND v(dout0_9) AT=650.025n

.meas tran vdout0_10ck1290 FIND v(dout0_10) AT=650.025n

.meas tran vdout0_11ck1290 FIND v(dout0_11) AT=650.025n

.meas tran vdout0_12ck1290 FIND v(dout0_12) AT=650.025n

.meas tran vdout0_13ck1290 FIND v(dout0_13) AT=650.025n

.meas tran vdout0_14ck1290 FIND v(dout0_14) AT=650.025n

.meas tran vdout0_15ck1290 FIND v(dout0_15) AT=650.025n

.meas tran vdout0_16ck1290 FIND v(dout0_16) AT=650.025n

.meas tran vdout0_17ck1290 FIND v(dout0_17) AT=650.025n

.meas tran vdout0_18ck1290 FIND v(dout0_18) AT=650.025n

.meas tran vdout0_19ck1290 FIND v(dout0_19) AT=650.025n

.meas tran vdout0_20ck1290 FIND v(dout0_20) AT=650.025n

.meas tran vdout0_21ck1290 FIND v(dout0_21) AT=650.025n

.meas tran vdout0_22ck1290 FIND v(dout0_22) AT=650.025n

.meas tran vdout0_23ck1290 FIND v(dout0_23) AT=650.025n

.meas tran vdout0_24ck1290 FIND v(dout0_24) AT=650.025n

.meas tran vdout0_25ck1290 FIND v(dout0_25) AT=650.025n

.meas tran vdout0_26ck1290 FIND v(dout0_26) AT=650.025n

.meas tran vdout0_27ck1290 FIND v(dout0_27) AT=650.025n

.meas tran vdout0_28ck1290 FIND v(dout0_28) AT=650.025n

.meas tran vdout0_29ck1290 FIND v(dout0_29) AT=650.025n

.meas tran vdout0_30ck1290 FIND v(dout0_30) AT=650.025n

.meas tran vdout0_31ck1290 FIND v(dout0_31) AT=650.025n

.meas tran vdout0_32ck1290 FIND v(dout0_32) AT=650.025n

.meas tran vdout0_33ck1290 FIND v(dout0_33) AT=650.025n

.meas tran vdout0_34ck1290 FIND v(dout0_34) AT=650.025n

.meas tran vdout0_35ck1290 FIND v(dout0_35) AT=650.025n

.meas tran vdout0_36ck1290 FIND v(dout0_36) AT=650.025n

.meas tran vdout0_37ck1290 FIND v(dout0_37) AT=650.025n

.meas tran vdout0_38ck1290 FIND v(dout0_38) AT=650.025n

.meas tran vdout0_39ck1290 FIND v(dout0_39) AT=650.025n

.meas tran vdout0_40ck1290 FIND v(dout0_40) AT=650.025n

.meas tran vdout0_41ck1290 FIND v(dout0_41) AT=650.025n

.meas tran vdout0_42ck1290 FIND v(dout0_42) AT=650.025n

.meas tran vdout0_43ck1290 FIND v(dout0_43) AT=650.025n

.meas tran vdout0_44ck1290 FIND v(dout0_44) AT=650.025n

.meas tran vdout0_45ck1290 FIND v(dout0_45) AT=650.025n

.meas tran vdout0_46ck1290 FIND v(dout0_46) AT=650.025n

.meas tran vdout0_47ck1290 FIND v(dout0_47) AT=650.025n

.meas tran vdout0_48ck1290 FIND v(dout0_48) AT=650.025n

.meas tran vdout0_49ck1290 FIND v(dout0_49) AT=650.025n

.meas tran vdout0_50ck1290 FIND v(dout0_50) AT=650.025n

.meas tran vdout0_51ck1290 FIND v(dout0_51) AT=650.025n

.meas tran vdout0_52ck1290 FIND v(dout0_52) AT=650.025n

.meas tran vdout0_53ck1290 FIND v(dout0_53) AT=650.025n

.meas tran vdout0_54ck1290 FIND v(dout0_54) AT=650.025n

.meas tran vdout0_55ck1290 FIND v(dout0_55) AT=650.025n

.meas tran vdout0_56ck1290 FIND v(dout0_56) AT=650.025n

.meas tran vdout0_57ck1290 FIND v(dout0_57) AT=650.025n

.meas tran vdout0_58ck1290 FIND v(dout0_58) AT=650.025n

.meas tran vdout0_59ck1290 FIND v(dout0_59) AT=650.025n

.meas tran vdout0_60ck1290 FIND v(dout0_60) AT=650.025n

.meas tran vdout0_61ck1290 FIND v(dout0_61) AT=650.025n

.meas tran vdout0_62ck1290 FIND v(dout0_62) AT=650.025n

.meas tran vdout0_63ck1290 FIND v(dout0_63) AT=650.025n

.meas tran vdout0_64ck1290 FIND v(dout0_64) AT=650.025n

.meas tran vdout0_65ck1290 FIND v(dout0_65) AT=650.025n

.meas tran vdout0_66ck1290 FIND v(dout0_66) AT=650.025n

.meas tran vdout0_67ck1290 FIND v(dout0_67) AT=650.025n

.meas tran vdout0_68ck1290 FIND v(dout0_68) AT=650.025n

.meas tran vdout0_69ck1290 FIND v(dout0_69) AT=650.025n

.meas tran vdout0_70ck1290 FIND v(dout0_70) AT=650.025n

.meas tran vdout0_71ck1290 FIND v(dout0_71) AT=650.025n

.meas tran vdout0_72ck1290 FIND v(dout0_72) AT=650.025n

.meas tran vdout0_73ck1290 FIND v(dout0_73) AT=650.025n

.meas tran vdout0_74ck1290 FIND v(dout0_74) AT=650.025n

.meas tran vdout0_75ck1290 FIND v(dout0_75) AT=650.025n

.meas tran vdout0_76ck1290 FIND v(dout0_76) AT=650.025n

.meas tran vdout0_77ck1290 FIND v(dout0_77) AT=650.025n

.meas tran vdout0_78ck1290 FIND v(dout0_78) AT=650.025n

.meas tran vdout0_79ck1290 FIND v(dout0_79) AT=650.025n

.meas tran vdout0_80ck1290 FIND v(dout0_80) AT=650.025n

.meas tran vdout0_81ck1290 FIND v(dout0_81) AT=650.025n

.meas tran vdout0_82ck1290 FIND v(dout0_82) AT=650.025n

.meas tran vdout0_83ck1290 FIND v(dout0_83) AT=650.025n

.meas tran vdout0_84ck1290 FIND v(dout0_84) AT=650.025n

.meas tran vdout0_85ck1290 FIND v(dout0_85) AT=650.025n

.meas tran vdout0_86ck1290 FIND v(dout0_86) AT=650.025n

.meas tran vdout0_87ck1290 FIND v(dout0_87) AT=650.025n

.meas tran vdout0_88ck1290 FIND v(dout0_88) AT=650.025n

.meas tran vdout0_89ck1290 FIND v(dout0_89) AT=650.025n

.meas tran vdout0_90ck1290 FIND v(dout0_90) AT=650.025n

.meas tran vdout0_91ck1290 FIND v(dout0_91) AT=650.025n

.meas tran vdout0_92ck1290 FIND v(dout0_92) AT=650.025n

.meas tran vdout0_93ck1290 FIND v(dout0_93) AT=650.025n

.meas tran vdout0_94ck1290 FIND v(dout0_94) AT=650.025n

.meas tran vdout0_95ck1290 FIND v(dout0_95) AT=650.025n

.meas tran vdout0_96ck1290 FIND v(dout0_96) AT=650.025n

.meas tran vdout0_97ck1290 FIND v(dout0_97) AT=650.025n

.meas tran vdout0_98ck1290 FIND v(dout0_98) AT=650.025n

.meas tran vdout0_99ck1290 FIND v(dout0_99) AT=650.025n

.meas tran vdout0_100ck1290 FIND v(dout0_100) AT=650.025n

.meas tran vdout0_101ck1290 FIND v(dout0_101) AT=650.025n

.meas tran vdout0_102ck1290 FIND v(dout0_102) AT=650.025n

.meas tran vdout0_103ck1290 FIND v(dout0_103) AT=650.025n

.meas tran vdout0_104ck1290 FIND v(dout0_104) AT=650.025n

.meas tran vdout0_105ck1290 FIND v(dout0_105) AT=650.025n

.meas tran vdout0_106ck1290 FIND v(dout0_106) AT=650.025n

.meas tran vdout0_107ck1290 FIND v(dout0_107) AT=650.025n

.meas tran vdout0_108ck1290 FIND v(dout0_108) AT=650.025n

.meas tran vdout0_109ck1290 FIND v(dout0_109) AT=650.025n

.meas tran vdout0_110ck1290 FIND v(dout0_110) AT=650.025n

.meas tran vdout0_111ck1290 FIND v(dout0_111) AT=650.025n

.meas tran vdout0_112ck1290 FIND v(dout0_112) AT=650.025n

.meas tran vdout0_113ck1290 FIND v(dout0_113) AT=650.025n

.meas tran vdout0_114ck1290 FIND v(dout0_114) AT=650.025n

.meas tran vdout0_115ck1290 FIND v(dout0_115) AT=650.025n

.meas tran vdout0_116ck1290 FIND v(dout0_116) AT=650.025n

.meas tran vdout0_117ck1290 FIND v(dout0_117) AT=650.025n

.meas tran vdout0_118ck1290 FIND v(dout0_118) AT=650.025n

.meas tran vdout0_119ck1290 FIND v(dout0_119) AT=650.025n

.meas tran vdout0_120ck1290 FIND v(dout0_120) AT=650.025n

.meas tran vdout0_121ck1290 FIND v(dout0_121) AT=650.025n

.meas tran vdout0_122ck1290 FIND v(dout0_122) AT=650.025n

.meas tran vdout0_123ck1290 FIND v(dout0_123) AT=650.025n

.meas tran vdout0_124ck1290 FIND v(dout0_124) AT=650.025n

.meas tran vdout0_125ck1290 FIND v(dout0_125) AT=650.025n

.meas tran vdout0_126ck1290 FIND v(dout0_126) AT=650.025n

.meas tran vdout0_127ck1290 FIND v(dout0_127) AT=650.025n

.meas tran vdout0_128ck1290 FIND v(dout0_128) AT=650.025n

.meas tran vdout0_129ck1290 FIND v(dout0_129) AT=650.025n

.meas tran vdout0_130ck1290 FIND v(dout0_130) AT=650.025n

.meas tran vdout0_131ck1290 FIND v(dout0_131) AT=650.025n

.meas tran vdout0_132ck1290 FIND v(dout0_132) AT=650.025n

.meas tran vdout0_133ck1290 FIND v(dout0_133) AT=650.025n

.meas tran vdout0_134ck1290 FIND v(dout0_134) AT=650.025n

.meas tran vdout0_135ck1290 FIND v(dout0_135) AT=650.025n

.meas tran vdout0_136ck1290 FIND v(dout0_136) AT=650.025n

.meas tran vdout0_137ck1290 FIND v(dout0_137) AT=650.025n

.meas tran vdout0_138ck1290 FIND v(dout0_138) AT=650.025n

.meas tran vdout0_139ck1290 FIND v(dout0_139) AT=650.025n

.meas tran vdout0_140ck1290 FIND v(dout0_140) AT=650.025n

.meas tran vdout0_141ck1290 FIND v(dout0_141) AT=650.025n

.meas tran vdout0_142ck1290 FIND v(dout0_142) AT=650.025n

.meas tran vdout0_143ck1290 FIND v(dout0_143) AT=650.025n

.meas tran vdout0_144ck1290 FIND v(dout0_144) AT=650.025n

.meas tran vdout0_145ck1290 FIND v(dout0_145) AT=650.025n

.meas tran vdout0_146ck1290 FIND v(dout0_146) AT=650.025n

.meas tran vdout0_147ck1290 FIND v(dout0_147) AT=650.025n

.meas tran vdout0_148ck1290 FIND v(dout0_148) AT=650.025n

.meas tran vdout0_149ck1290 FIND v(dout0_149) AT=650.025n

.meas tran vdout0_0ck1300 FIND v(dout0_0) AT=655.025n

.meas tran vdout0_1ck1300 FIND v(dout0_1) AT=655.025n

.meas tran vdout0_2ck1300 FIND v(dout0_2) AT=655.025n

.meas tran vdout0_3ck1300 FIND v(dout0_3) AT=655.025n

.meas tran vdout0_4ck1300 FIND v(dout0_4) AT=655.025n

.meas tran vdout0_5ck1300 FIND v(dout0_5) AT=655.025n

.meas tran vdout0_6ck1300 FIND v(dout0_6) AT=655.025n

.meas tran vdout0_7ck1300 FIND v(dout0_7) AT=655.025n

.meas tran vdout0_8ck1300 FIND v(dout0_8) AT=655.025n

.meas tran vdout0_9ck1300 FIND v(dout0_9) AT=655.025n

.meas tran vdout0_10ck1300 FIND v(dout0_10) AT=655.025n

.meas tran vdout0_11ck1300 FIND v(dout0_11) AT=655.025n

.meas tran vdout0_12ck1300 FIND v(dout0_12) AT=655.025n

.meas tran vdout0_13ck1300 FIND v(dout0_13) AT=655.025n

.meas tran vdout0_14ck1300 FIND v(dout0_14) AT=655.025n

.meas tran vdout0_15ck1300 FIND v(dout0_15) AT=655.025n

.meas tran vdout0_16ck1300 FIND v(dout0_16) AT=655.025n

.meas tran vdout0_17ck1300 FIND v(dout0_17) AT=655.025n

.meas tran vdout0_18ck1300 FIND v(dout0_18) AT=655.025n

.meas tran vdout0_19ck1300 FIND v(dout0_19) AT=655.025n

.meas tran vdout0_20ck1300 FIND v(dout0_20) AT=655.025n

.meas tran vdout0_21ck1300 FIND v(dout0_21) AT=655.025n

.meas tran vdout0_22ck1300 FIND v(dout0_22) AT=655.025n

.meas tran vdout0_23ck1300 FIND v(dout0_23) AT=655.025n

.meas tran vdout0_24ck1300 FIND v(dout0_24) AT=655.025n

.meas tran vdout0_25ck1300 FIND v(dout0_25) AT=655.025n

.meas tran vdout0_26ck1300 FIND v(dout0_26) AT=655.025n

.meas tran vdout0_27ck1300 FIND v(dout0_27) AT=655.025n

.meas tran vdout0_28ck1300 FIND v(dout0_28) AT=655.025n

.meas tran vdout0_29ck1300 FIND v(dout0_29) AT=655.025n

.meas tran vdout0_30ck1300 FIND v(dout0_30) AT=655.025n

.meas tran vdout0_31ck1300 FIND v(dout0_31) AT=655.025n

.meas tran vdout0_32ck1300 FIND v(dout0_32) AT=655.025n

.meas tran vdout0_33ck1300 FIND v(dout0_33) AT=655.025n

.meas tran vdout0_34ck1300 FIND v(dout0_34) AT=655.025n

.meas tran vdout0_35ck1300 FIND v(dout0_35) AT=655.025n

.meas tran vdout0_36ck1300 FIND v(dout0_36) AT=655.025n

.meas tran vdout0_37ck1300 FIND v(dout0_37) AT=655.025n

.meas tran vdout0_38ck1300 FIND v(dout0_38) AT=655.025n

.meas tran vdout0_39ck1300 FIND v(dout0_39) AT=655.025n

.meas tran vdout0_40ck1300 FIND v(dout0_40) AT=655.025n

.meas tran vdout0_41ck1300 FIND v(dout0_41) AT=655.025n

.meas tran vdout0_42ck1300 FIND v(dout0_42) AT=655.025n

.meas tran vdout0_43ck1300 FIND v(dout0_43) AT=655.025n

.meas tran vdout0_44ck1300 FIND v(dout0_44) AT=655.025n

.meas tran vdout0_45ck1300 FIND v(dout0_45) AT=655.025n

.meas tran vdout0_46ck1300 FIND v(dout0_46) AT=655.025n

.meas tran vdout0_47ck1300 FIND v(dout0_47) AT=655.025n

.meas tran vdout0_48ck1300 FIND v(dout0_48) AT=655.025n

.meas tran vdout0_49ck1300 FIND v(dout0_49) AT=655.025n

.meas tran vdout0_50ck1300 FIND v(dout0_50) AT=655.025n

.meas tran vdout0_51ck1300 FIND v(dout0_51) AT=655.025n

.meas tran vdout0_52ck1300 FIND v(dout0_52) AT=655.025n

.meas tran vdout0_53ck1300 FIND v(dout0_53) AT=655.025n

.meas tran vdout0_54ck1300 FIND v(dout0_54) AT=655.025n

.meas tran vdout0_55ck1300 FIND v(dout0_55) AT=655.025n

.meas tran vdout0_56ck1300 FIND v(dout0_56) AT=655.025n

.meas tran vdout0_57ck1300 FIND v(dout0_57) AT=655.025n

.meas tran vdout0_58ck1300 FIND v(dout0_58) AT=655.025n

.meas tran vdout0_59ck1300 FIND v(dout0_59) AT=655.025n

.meas tran vdout0_60ck1300 FIND v(dout0_60) AT=655.025n

.meas tran vdout0_61ck1300 FIND v(dout0_61) AT=655.025n

.meas tran vdout0_62ck1300 FIND v(dout0_62) AT=655.025n

.meas tran vdout0_63ck1300 FIND v(dout0_63) AT=655.025n

.meas tran vdout0_64ck1300 FIND v(dout0_64) AT=655.025n

.meas tran vdout0_65ck1300 FIND v(dout0_65) AT=655.025n

.meas tran vdout0_66ck1300 FIND v(dout0_66) AT=655.025n

.meas tran vdout0_67ck1300 FIND v(dout0_67) AT=655.025n

.meas tran vdout0_68ck1300 FIND v(dout0_68) AT=655.025n

.meas tran vdout0_69ck1300 FIND v(dout0_69) AT=655.025n

.meas tran vdout0_70ck1300 FIND v(dout0_70) AT=655.025n

.meas tran vdout0_71ck1300 FIND v(dout0_71) AT=655.025n

.meas tran vdout0_72ck1300 FIND v(dout0_72) AT=655.025n

.meas tran vdout0_73ck1300 FIND v(dout0_73) AT=655.025n

.meas tran vdout0_74ck1300 FIND v(dout0_74) AT=655.025n

.meas tran vdout0_75ck1300 FIND v(dout0_75) AT=655.025n

.meas tran vdout0_76ck1300 FIND v(dout0_76) AT=655.025n

.meas tran vdout0_77ck1300 FIND v(dout0_77) AT=655.025n

.meas tran vdout0_78ck1300 FIND v(dout0_78) AT=655.025n

.meas tran vdout0_79ck1300 FIND v(dout0_79) AT=655.025n

.meas tran vdout0_80ck1300 FIND v(dout0_80) AT=655.025n

.meas tran vdout0_81ck1300 FIND v(dout0_81) AT=655.025n

.meas tran vdout0_82ck1300 FIND v(dout0_82) AT=655.025n

.meas tran vdout0_83ck1300 FIND v(dout0_83) AT=655.025n

.meas tran vdout0_84ck1300 FIND v(dout0_84) AT=655.025n

.meas tran vdout0_85ck1300 FIND v(dout0_85) AT=655.025n

.meas tran vdout0_86ck1300 FIND v(dout0_86) AT=655.025n

.meas tran vdout0_87ck1300 FIND v(dout0_87) AT=655.025n

.meas tran vdout0_88ck1300 FIND v(dout0_88) AT=655.025n

.meas tran vdout0_89ck1300 FIND v(dout0_89) AT=655.025n

.meas tran vdout0_90ck1300 FIND v(dout0_90) AT=655.025n

.meas tran vdout0_91ck1300 FIND v(dout0_91) AT=655.025n

.meas tran vdout0_92ck1300 FIND v(dout0_92) AT=655.025n

.meas tran vdout0_93ck1300 FIND v(dout0_93) AT=655.025n

.meas tran vdout0_94ck1300 FIND v(dout0_94) AT=655.025n

.meas tran vdout0_95ck1300 FIND v(dout0_95) AT=655.025n

.meas tran vdout0_96ck1300 FIND v(dout0_96) AT=655.025n

.meas tran vdout0_97ck1300 FIND v(dout0_97) AT=655.025n

.meas tran vdout0_98ck1300 FIND v(dout0_98) AT=655.025n

.meas tran vdout0_99ck1300 FIND v(dout0_99) AT=655.025n

.meas tran vdout0_100ck1300 FIND v(dout0_100) AT=655.025n

.meas tran vdout0_101ck1300 FIND v(dout0_101) AT=655.025n

.meas tran vdout0_102ck1300 FIND v(dout0_102) AT=655.025n

.meas tran vdout0_103ck1300 FIND v(dout0_103) AT=655.025n

.meas tran vdout0_104ck1300 FIND v(dout0_104) AT=655.025n

.meas tran vdout0_105ck1300 FIND v(dout0_105) AT=655.025n

.meas tran vdout0_106ck1300 FIND v(dout0_106) AT=655.025n

.meas tran vdout0_107ck1300 FIND v(dout0_107) AT=655.025n

.meas tran vdout0_108ck1300 FIND v(dout0_108) AT=655.025n

.meas tran vdout0_109ck1300 FIND v(dout0_109) AT=655.025n

.meas tran vdout0_110ck1300 FIND v(dout0_110) AT=655.025n

.meas tran vdout0_111ck1300 FIND v(dout0_111) AT=655.025n

.meas tran vdout0_112ck1300 FIND v(dout0_112) AT=655.025n

.meas tran vdout0_113ck1300 FIND v(dout0_113) AT=655.025n

.meas tran vdout0_114ck1300 FIND v(dout0_114) AT=655.025n

.meas tran vdout0_115ck1300 FIND v(dout0_115) AT=655.025n

.meas tran vdout0_116ck1300 FIND v(dout0_116) AT=655.025n

.meas tran vdout0_117ck1300 FIND v(dout0_117) AT=655.025n

.meas tran vdout0_118ck1300 FIND v(dout0_118) AT=655.025n

.meas tran vdout0_119ck1300 FIND v(dout0_119) AT=655.025n

.meas tran vdout0_120ck1300 FIND v(dout0_120) AT=655.025n

.meas tran vdout0_121ck1300 FIND v(dout0_121) AT=655.025n

.meas tran vdout0_122ck1300 FIND v(dout0_122) AT=655.025n

.meas tran vdout0_123ck1300 FIND v(dout0_123) AT=655.025n

.meas tran vdout0_124ck1300 FIND v(dout0_124) AT=655.025n

.meas tran vdout0_125ck1300 FIND v(dout0_125) AT=655.025n

.meas tran vdout0_126ck1300 FIND v(dout0_126) AT=655.025n

.meas tran vdout0_127ck1300 FIND v(dout0_127) AT=655.025n

.meas tran vdout0_128ck1300 FIND v(dout0_128) AT=655.025n

.meas tran vdout0_129ck1300 FIND v(dout0_129) AT=655.025n

.meas tran vdout0_130ck1300 FIND v(dout0_130) AT=655.025n

.meas tran vdout0_131ck1300 FIND v(dout0_131) AT=655.025n

.meas tran vdout0_132ck1300 FIND v(dout0_132) AT=655.025n

.meas tran vdout0_133ck1300 FIND v(dout0_133) AT=655.025n

.meas tran vdout0_134ck1300 FIND v(dout0_134) AT=655.025n

.meas tran vdout0_135ck1300 FIND v(dout0_135) AT=655.025n

.meas tran vdout0_136ck1300 FIND v(dout0_136) AT=655.025n

.meas tran vdout0_137ck1300 FIND v(dout0_137) AT=655.025n

.meas tran vdout0_138ck1300 FIND v(dout0_138) AT=655.025n

.meas tran vdout0_139ck1300 FIND v(dout0_139) AT=655.025n

.meas tran vdout0_140ck1300 FIND v(dout0_140) AT=655.025n

.meas tran vdout0_141ck1300 FIND v(dout0_141) AT=655.025n

.meas tran vdout0_142ck1300 FIND v(dout0_142) AT=655.025n

.meas tran vdout0_143ck1300 FIND v(dout0_143) AT=655.025n

.meas tran vdout0_144ck1300 FIND v(dout0_144) AT=655.025n

.meas tran vdout0_145ck1300 FIND v(dout0_145) AT=655.025n

.meas tran vdout0_146ck1300 FIND v(dout0_146) AT=655.025n

.meas tran vdout0_147ck1300 FIND v(dout0_147) AT=655.025n

.meas tran vdout0_148ck1300 FIND v(dout0_148) AT=655.025n

.meas tran vdout0_149ck1300 FIND v(dout0_149) AT=655.025n

.meas tran vdout0_0ck1310 FIND v(dout0_0) AT=660.025n

.meas tran vdout0_1ck1310 FIND v(dout0_1) AT=660.025n

.meas tran vdout0_2ck1310 FIND v(dout0_2) AT=660.025n

.meas tran vdout0_3ck1310 FIND v(dout0_3) AT=660.025n

.meas tran vdout0_4ck1310 FIND v(dout0_4) AT=660.025n

.meas tran vdout0_5ck1310 FIND v(dout0_5) AT=660.025n

.meas tran vdout0_6ck1310 FIND v(dout0_6) AT=660.025n

.meas tran vdout0_7ck1310 FIND v(dout0_7) AT=660.025n

.meas tran vdout0_8ck1310 FIND v(dout0_8) AT=660.025n

.meas tran vdout0_9ck1310 FIND v(dout0_9) AT=660.025n

.meas tran vdout0_10ck1310 FIND v(dout0_10) AT=660.025n

.meas tran vdout0_11ck1310 FIND v(dout0_11) AT=660.025n

.meas tran vdout0_12ck1310 FIND v(dout0_12) AT=660.025n

.meas tran vdout0_13ck1310 FIND v(dout0_13) AT=660.025n

.meas tran vdout0_14ck1310 FIND v(dout0_14) AT=660.025n

.meas tran vdout0_15ck1310 FIND v(dout0_15) AT=660.025n

.meas tran vdout0_16ck1310 FIND v(dout0_16) AT=660.025n

.meas tran vdout0_17ck1310 FIND v(dout0_17) AT=660.025n

.meas tran vdout0_18ck1310 FIND v(dout0_18) AT=660.025n

.meas tran vdout0_19ck1310 FIND v(dout0_19) AT=660.025n

.meas tran vdout0_20ck1310 FIND v(dout0_20) AT=660.025n

.meas tran vdout0_21ck1310 FIND v(dout0_21) AT=660.025n

.meas tran vdout0_22ck1310 FIND v(dout0_22) AT=660.025n

.meas tran vdout0_23ck1310 FIND v(dout0_23) AT=660.025n

.meas tran vdout0_24ck1310 FIND v(dout0_24) AT=660.025n

.meas tran vdout0_25ck1310 FIND v(dout0_25) AT=660.025n

.meas tran vdout0_26ck1310 FIND v(dout0_26) AT=660.025n

.meas tran vdout0_27ck1310 FIND v(dout0_27) AT=660.025n

.meas tran vdout0_28ck1310 FIND v(dout0_28) AT=660.025n

.meas tran vdout0_29ck1310 FIND v(dout0_29) AT=660.025n

.meas tran vdout0_30ck1310 FIND v(dout0_30) AT=660.025n

.meas tran vdout0_31ck1310 FIND v(dout0_31) AT=660.025n

.meas tran vdout0_32ck1310 FIND v(dout0_32) AT=660.025n

.meas tran vdout0_33ck1310 FIND v(dout0_33) AT=660.025n

.meas tran vdout0_34ck1310 FIND v(dout0_34) AT=660.025n

.meas tran vdout0_35ck1310 FIND v(dout0_35) AT=660.025n

.meas tran vdout0_36ck1310 FIND v(dout0_36) AT=660.025n

.meas tran vdout0_37ck1310 FIND v(dout0_37) AT=660.025n

.meas tran vdout0_38ck1310 FIND v(dout0_38) AT=660.025n

.meas tran vdout0_39ck1310 FIND v(dout0_39) AT=660.025n

.meas tran vdout0_40ck1310 FIND v(dout0_40) AT=660.025n

.meas tran vdout0_41ck1310 FIND v(dout0_41) AT=660.025n

.meas tran vdout0_42ck1310 FIND v(dout0_42) AT=660.025n

.meas tran vdout0_43ck1310 FIND v(dout0_43) AT=660.025n

.meas tran vdout0_44ck1310 FIND v(dout0_44) AT=660.025n

.meas tran vdout0_45ck1310 FIND v(dout0_45) AT=660.025n

.meas tran vdout0_46ck1310 FIND v(dout0_46) AT=660.025n

.meas tran vdout0_47ck1310 FIND v(dout0_47) AT=660.025n

.meas tran vdout0_48ck1310 FIND v(dout0_48) AT=660.025n

.meas tran vdout0_49ck1310 FIND v(dout0_49) AT=660.025n

.meas tran vdout0_50ck1310 FIND v(dout0_50) AT=660.025n

.meas tran vdout0_51ck1310 FIND v(dout0_51) AT=660.025n

.meas tran vdout0_52ck1310 FIND v(dout0_52) AT=660.025n

.meas tran vdout0_53ck1310 FIND v(dout0_53) AT=660.025n

.meas tran vdout0_54ck1310 FIND v(dout0_54) AT=660.025n

.meas tran vdout0_55ck1310 FIND v(dout0_55) AT=660.025n

.meas tran vdout0_56ck1310 FIND v(dout0_56) AT=660.025n

.meas tran vdout0_57ck1310 FIND v(dout0_57) AT=660.025n

.meas tran vdout0_58ck1310 FIND v(dout0_58) AT=660.025n

.meas tran vdout0_59ck1310 FIND v(dout0_59) AT=660.025n

.meas tran vdout0_60ck1310 FIND v(dout0_60) AT=660.025n

.meas tran vdout0_61ck1310 FIND v(dout0_61) AT=660.025n

.meas tran vdout0_62ck1310 FIND v(dout0_62) AT=660.025n

.meas tran vdout0_63ck1310 FIND v(dout0_63) AT=660.025n

.meas tran vdout0_64ck1310 FIND v(dout0_64) AT=660.025n

.meas tran vdout0_65ck1310 FIND v(dout0_65) AT=660.025n

.meas tran vdout0_66ck1310 FIND v(dout0_66) AT=660.025n

.meas tran vdout0_67ck1310 FIND v(dout0_67) AT=660.025n

.meas tran vdout0_68ck1310 FIND v(dout0_68) AT=660.025n

.meas tran vdout0_69ck1310 FIND v(dout0_69) AT=660.025n

.meas tran vdout0_70ck1310 FIND v(dout0_70) AT=660.025n

.meas tran vdout0_71ck1310 FIND v(dout0_71) AT=660.025n

.meas tran vdout0_72ck1310 FIND v(dout0_72) AT=660.025n

.meas tran vdout0_73ck1310 FIND v(dout0_73) AT=660.025n

.meas tran vdout0_74ck1310 FIND v(dout0_74) AT=660.025n

.meas tran vdout0_75ck1310 FIND v(dout0_75) AT=660.025n

.meas tran vdout0_76ck1310 FIND v(dout0_76) AT=660.025n

.meas tran vdout0_77ck1310 FIND v(dout0_77) AT=660.025n

.meas tran vdout0_78ck1310 FIND v(dout0_78) AT=660.025n

.meas tran vdout0_79ck1310 FIND v(dout0_79) AT=660.025n

.meas tran vdout0_80ck1310 FIND v(dout0_80) AT=660.025n

.meas tran vdout0_81ck1310 FIND v(dout0_81) AT=660.025n

.meas tran vdout0_82ck1310 FIND v(dout0_82) AT=660.025n

.meas tran vdout0_83ck1310 FIND v(dout0_83) AT=660.025n

.meas tran vdout0_84ck1310 FIND v(dout0_84) AT=660.025n

.meas tran vdout0_85ck1310 FIND v(dout0_85) AT=660.025n

.meas tran vdout0_86ck1310 FIND v(dout0_86) AT=660.025n

.meas tran vdout0_87ck1310 FIND v(dout0_87) AT=660.025n

.meas tran vdout0_88ck1310 FIND v(dout0_88) AT=660.025n

.meas tran vdout0_89ck1310 FIND v(dout0_89) AT=660.025n

.meas tran vdout0_90ck1310 FIND v(dout0_90) AT=660.025n

.meas tran vdout0_91ck1310 FIND v(dout0_91) AT=660.025n

.meas tran vdout0_92ck1310 FIND v(dout0_92) AT=660.025n

.meas tran vdout0_93ck1310 FIND v(dout0_93) AT=660.025n

.meas tran vdout0_94ck1310 FIND v(dout0_94) AT=660.025n

.meas tran vdout0_95ck1310 FIND v(dout0_95) AT=660.025n

.meas tran vdout0_96ck1310 FIND v(dout0_96) AT=660.025n

.meas tran vdout0_97ck1310 FIND v(dout0_97) AT=660.025n

.meas tran vdout0_98ck1310 FIND v(dout0_98) AT=660.025n

.meas tran vdout0_99ck1310 FIND v(dout0_99) AT=660.025n

.meas tran vdout0_100ck1310 FIND v(dout0_100) AT=660.025n

.meas tran vdout0_101ck1310 FIND v(dout0_101) AT=660.025n

.meas tran vdout0_102ck1310 FIND v(dout0_102) AT=660.025n

.meas tran vdout0_103ck1310 FIND v(dout0_103) AT=660.025n

.meas tran vdout0_104ck1310 FIND v(dout0_104) AT=660.025n

.meas tran vdout0_105ck1310 FIND v(dout0_105) AT=660.025n

.meas tran vdout0_106ck1310 FIND v(dout0_106) AT=660.025n

.meas tran vdout0_107ck1310 FIND v(dout0_107) AT=660.025n

.meas tran vdout0_108ck1310 FIND v(dout0_108) AT=660.025n

.meas tran vdout0_109ck1310 FIND v(dout0_109) AT=660.025n

.meas tran vdout0_110ck1310 FIND v(dout0_110) AT=660.025n

.meas tran vdout0_111ck1310 FIND v(dout0_111) AT=660.025n

.meas tran vdout0_112ck1310 FIND v(dout0_112) AT=660.025n

.meas tran vdout0_113ck1310 FIND v(dout0_113) AT=660.025n

.meas tran vdout0_114ck1310 FIND v(dout0_114) AT=660.025n

.meas tran vdout0_115ck1310 FIND v(dout0_115) AT=660.025n

.meas tran vdout0_116ck1310 FIND v(dout0_116) AT=660.025n

.meas tran vdout0_117ck1310 FIND v(dout0_117) AT=660.025n

.meas tran vdout0_118ck1310 FIND v(dout0_118) AT=660.025n

.meas tran vdout0_119ck1310 FIND v(dout0_119) AT=660.025n

.meas tran vdout0_120ck1310 FIND v(dout0_120) AT=660.025n

.meas tran vdout0_121ck1310 FIND v(dout0_121) AT=660.025n

.meas tran vdout0_122ck1310 FIND v(dout0_122) AT=660.025n

.meas tran vdout0_123ck1310 FIND v(dout0_123) AT=660.025n

.meas tran vdout0_124ck1310 FIND v(dout0_124) AT=660.025n

.meas tran vdout0_125ck1310 FIND v(dout0_125) AT=660.025n

.meas tran vdout0_126ck1310 FIND v(dout0_126) AT=660.025n

.meas tran vdout0_127ck1310 FIND v(dout0_127) AT=660.025n

.meas tran vdout0_128ck1310 FIND v(dout0_128) AT=660.025n

.meas tran vdout0_129ck1310 FIND v(dout0_129) AT=660.025n

.meas tran vdout0_130ck1310 FIND v(dout0_130) AT=660.025n

.meas tran vdout0_131ck1310 FIND v(dout0_131) AT=660.025n

.meas tran vdout0_132ck1310 FIND v(dout0_132) AT=660.025n

.meas tran vdout0_133ck1310 FIND v(dout0_133) AT=660.025n

.meas tran vdout0_134ck1310 FIND v(dout0_134) AT=660.025n

.meas tran vdout0_135ck1310 FIND v(dout0_135) AT=660.025n

.meas tran vdout0_136ck1310 FIND v(dout0_136) AT=660.025n

.meas tran vdout0_137ck1310 FIND v(dout0_137) AT=660.025n

.meas tran vdout0_138ck1310 FIND v(dout0_138) AT=660.025n

.meas tran vdout0_139ck1310 FIND v(dout0_139) AT=660.025n

.meas tran vdout0_140ck1310 FIND v(dout0_140) AT=660.025n

.meas tran vdout0_141ck1310 FIND v(dout0_141) AT=660.025n

.meas tran vdout0_142ck1310 FIND v(dout0_142) AT=660.025n

.meas tran vdout0_143ck1310 FIND v(dout0_143) AT=660.025n

.meas tran vdout0_144ck1310 FIND v(dout0_144) AT=660.025n

.meas tran vdout0_145ck1310 FIND v(dout0_145) AT=660.025n

.meas tran vdout0_146ck1310 FIND v(dout0_146) AT=660.025n

.meas tran vdout0_147ck1310 FIND v(dout0_147) AT=660.025n

.meas tran vdout0_148ck1310 FIND v(dout0_148) AT=660.025n

.meas tran vdout0_149ck1310 FIND v(dout0_149) AT=660.025n

.meas tran vdout0_0ck1320 FIND v(dout0_0) AT=665.025n

.meas tran vdout0_1ck1320 FIND v(dout0_1) AT=665.025n

.meas tran vdout0_2ck1320 FIND v(dout0_2) AT=665.025n

.meas tran vdout0_3ck1320 FIND v(dout0_3) AT=665.025n

.meas tran vdout0_4ck1320 FIND v(dout0_4) AT=665.025n

.meas tran vdout0_5ck1320 FIND v(dout0_5) AT=665.025n

.meas tran vdout0_6ck1320 FIND v(dout0_6) AT=665.025n

.meas tran vdout0_7ck1320 FIND v(dout0_7) AT=665.025n

.meas tran vdout0_8ck1320 FIND v(dout0_8) AT=665.025n

.meas tran vdout0_9ck1320 FIND v(dout0_9) AT=665.025n

.meas tran vdout0_10ck1320 FIND v(dout0_10) AT=665.025n

.meas tran vdout0_11ck1320 FIND v(dout0_11) AT=665.025n

.meas tran vdout0_12ck1320 FIND v(dout0_12) AT=665.025n

.meas tran vdout0_13ck1320 FIND v(dout0_13) AT=665.025n

.meas tran vdout0_14ck1320 FIND v(dout0_14) AT=665.025n

.meas tran vdout0_15ck1320 FIND v(dout0_15) AT=665.025n

.meas tran vdout0_16ck1320 FIND v(dout0_16) AT=665.025n

.meas tran vdout0_17ck1320 FIND v(dout0_17) AT=665.025n

.meas tran vdout0_18ck1320 FIND v(dout0_18) AT=665.025n

.meas tran vdout0_19ck1320 FIND v(dout0_19) AT=665.025n

.meas tran vdout0_20ck1320 FIND v(dout0_20) AT=665.025n

.meas tran vdout0_21ck1320 FIND v(dout0_21) AT=665.025n

.meas tran vdout0_22ck1320 FIND v(dout0_22) AT=665.025n

.meas tran vdout0_23ck1320 FIND v(dout0_23) AT=665.025n

.meas tran vdout0_24ck1320 FIND v(dout0_24) AT=665.025n

.meas tran vdout0_25ck1320 FIND v(dout0_25) AT=665.025n

.meas tran vdout0_26ck1320 FIND v(dout0_26) AT=665.025n

.meas tran vdout0_27ck1320 FIND v(dout0_27) AT=665.025n

.meas tran vdout0_28ck1320 FIND v(dout0_28) AT=665.025n

.meas tran vdout0_29ck1320 FIND v(dout0_29) AT=665.025n

.meas tran vdout0_30ck1320 FIND v(dout0_30) AT=665.025n

.meas tran vdout0_31ck1320 FIND v(dout0_31) AT=665.025n

.meas tran vdout0_32ck1320 FIND v(dout0_32) AT=665.025n

.meas tran vdout0_33ck1320 FIND v(dout0_33) AT=665.025n

.meas tran vdout0_34ck1320 FIND v(dout0_34) AT=665.025n

.meas tran vdout0_35ck1320 FIND v(dout0_35) AT=665.025n

.meas tran vdout0_36ck1320 FIND v(dout0_36) AT=665.025n

.meas tran vdout0_37ck1320 FIND v(dout0_37) AT=665.025n

.meas tran vdout0_38ck1320 FIND v(dout0_38) AT=665.025n

.meas tran vdout0_39ck1320 FIND v(dout0_39) AT=665.025n

.meas tran vdout0_40ck1320 FIND v(dout0_40) AT=665.025n

.meas tran vdout0_41ck1320 FIND v(dout0_41) AT=665.025n

.meas tran vdout0_42ck1320 FIND v(dout0_42) AT=665.025n

.meas tran vdout0_43ck1320 FIND v(dout0_43) AT=665.025n

.meas tran vdout0_44ck1320 FIND v(dout0_44) AT=665.025n

.meas tran vdout0_45ck1320 FIND v(dout0_45) AT=665.025n

.meas tran vdout0_46ck1320 FIND v(dout0_46) AT=665.025n

.meas tran vdout0_47ck1320 FIND v(dout0_47) AT=665.025n

.meas tran vdout0_48ck1320 FIND v(dout0_48) AT=665.025n

.meas tran vdout0_49ck1320 FIND v(dout0_49) AT=665.025n

.meas tran vdout0_50ck1320 FIND v(dout0_50) AT=665.025n

.meas tran vdout0_51ck1320 FIND v(dout0_51) AT=665.025n

.meas tran vdout0_52ck1320 FIND v(dout0_52) AT=665.025n

.meas tran vdout0_53ck1320 FIND v(dout0_53) AT=665.025n

.meas tran vdout0_54ck1320 FIND v(dout0_54) AT=665.025n

.meas tran vdout0_55ck1320 FIND v(dout0_55) AT=665.025n

.meas tran vdout0_56ck1320 FIND v(dout0_56) AT=665.025n

.meas tran vdout0_57ck1320 FIND v(dout0_57) AT=665.025n

.meas tran vdout0_58ck1320 FIND v(dout0_58) AT=665.025n

.meas tran vdout0_59ck1320 FIND v(dout0_59) AT=665.025n

.meas tran vdout0_60ck1320 FIND v(dout0_60) AT=665.025n

.meas tran vdout0_61ck1320 FIND v(dout0_61) AT=665.025n

.meas tran vdout0_62ck1320 FIND v(dout0_62) AT=665.025n

.meas tran vdout0_63ck1320 FIND v(dout0_63) AT=665.025n

.meas tran vdout0_64ck1320 FIND v(dout0_64) AT=665.025n

.meas tran vdout0_65ck1320 FIND v(dout0_65) AT=665.025n

.meas tran vdout0_66ck1320 FIND v(dout0_66) AT=665.025n

.meas tran vdout0_67ck1320 FIND v(dout0_67) AT=665.025n

.meas tran vdout0_68ck1320 FIND v(dout0_68) AT=665.025n

.meas tran vdout0_69ck1320 FIND v(dout0_69) AT=665.025n

.meas tran vdout0_70ck1320 FIND v(dout0_70) AT=665.025n

.meas tran vdout0_71ck1320 FIND v(dout0_71) AT=665.025n

.meas tran vdout0_72ck1320 FIND v(dout0_72) AT=665.025n

.meas tran vdout0_73ck1320 FIND v(dout0_73) AT=665.025n

.meas tran vdout0_74ck1320 FIND v(dout0_74) AT=665.025n

.meas tran vdout0_75ck1320 FIND v(dout0_75) AT=665.025n

.meas tran vdout0_76ck1320 FIND v(dout0_76) AT=665.025n

.meas tran vdout0_77ck1320 FIND v(dout0_77) AT=665.025n

.meas tran vdout0_78ck1320 FIND v(dout0_78) AT=665.025n

.meas tran vdout0_79ck1320 FIND v(dout0_79) AT=665.025n

.meas tran vdout0_80ck1320 FIND v(dout0_80) AT=665.025n

.meas tran vdout0_81ck1320 FIND v(dout0_81) AT=665.025n

.meas tran vdout0_82ck1320 FIND v(dout0_82) AT=665.025n

.meas tran vdout0_83ck1320 FIND v(dout0_83) AT=665.025n

.meas tran vdout0_84ck1320 FIND v(dout0_84) AT=665.025n

.meas tran vdout0_85ck1320 FIND v(dout0_85) AT=665.025n

.meas tran vdout0_86ck1320 FIND v(dout0_86) AT=665.025n

.meas tran vdout0_87ck1320 FIND v(dout0_87) AT=665.025n

.meas tran vdout0_88ck1320 FIND v(dout0_88) AT=665.025n

.meas tran vdout0_89ck1320 FIND v(dout0_89) AT=665.025n

.meas tran vdout0_90ck1320 FIND v(dout0_90) AT=665.025n

.meas tran vdout0_91ck1320 FIND v(dout0_91) AT=665.025n

.meas tran vdout0_92ck1320 FIND v(dout0_92) AT=665.025n

.meas tran vdout0_93ck1320 FIND v(dout0_93) AT=665.025n

.meas tran vdout0_94ck1320 FIND v(dout0_94) AT=665.025n

.meas tran vdout0_95ck1320 FIND v(dout0_95) AT=665.025n

.meas tran vdout0_96ck1320 FIND v(dout0_96) AT=665.025n

.meas tran vdout0_97ck1320 FIND v(dout0_97) AT=665.025n

.meas tran vdout0_98ck1320 FIND v(dout0_98) AT=665.025n

.meas tran vdout0_99ck1320 FIND v(dout0_99) AT=665.025n

.meas tran vdout0_100ck1320 FIND v(dout0_100) AT=665.025n

.meas tran vdout0_101ck1320 FIND v(dout0_101) AT=665.025n

.meas tran vdout0_102ck1320 FIND v(dout0_102) AT=665.025n

.meas tran vdout0_103ck1320 FIND v(dout0_103) AT=665.025n

.meas tran vdout0_104ck1320 FIND v(dout0_104) AT=665.025n

.meas tran vdout0_105ck1320 FIND v(dout0_105) AT=665.025n

.meas tran vdout0_106ck1320 FIND v(dout0_106) AT=665.025n

.meas tran vdout0_107ck1320 FIND v(dout0_107) AT=665.025n

.meas tran vdout0_108ck1320 FIND v(dout0_108) AT=665.025n

.meas tran vdout0_109ck1320 FIND v(dout0_109) AT=665.025n

.meas tran vdout0_110ck1320 FIND v(dout0_110) AT=665.025n

.meas tran vdout0_111ck1320 FIND v(dout0_111) AT=665.025n

.meas tran vdout0_112ck1320 FIND v(dout0_112) AT=665.025n

.meas tran vdout0_113ck1320 FIND v(dout0_113) AT=665.025n

.meas tran vdout0_114ck1320 FIND v(dout0_114) AT=665.025n

.meas tran vdout0_115ck1320 FIND v(dout0_115) AT=665.025n

.meas tran vdout0_116ck1320 FIND v(dout0_116) AT=665.025n

.meas tran vdout0_117ck1320 FIND v(dout0_117) AT=665.025n

.meas tran vdout0_118ck1320 FIND v(dout0_118) AT=665.025n

.meas tran vdout0_119ck1320 FIND v(dout0_119) AT=665.025n

.meas tran vdout0_120ck1320 FIND v(dout0_120) AT=665.025n

.meas tran vdout0_121ck1320 FIND v(dout0_121) AT=665.025n

.meas tran vdout0_122ck1320 FIND v(dout0_122) AT=665.025n

.meas tran vdout0_123ck1320 FIND v(dout0_123) AT=665.025n

.meas tran vdout0_124ck1320 FIND v(dout0_124) AT=665.025n

.meas tran vdout0_125ck1320 FIND v(dout0_125) AT=665.025n

.meas tran vdout0_126ck1320 FIND v(dout0_126) AT=665.025n

.meas tran vdout0_127ck1320 FIND v(dout0_127) AT=665.025n

.meas tran vdout0_128ck1320 FIND v(dout0_128) AT=665.025n

.meas tran vdout0_129ck1320 FIND v(dout0_129) AT=665.025n

.meas tran vdout0_130ck1320 FIND v(dout0_130) AT=665.025n

.meas tran vdout0_131ck1320 FIND v(dout0_131) AT=665.025n

.meas tran vdout0_132ck1320 FIND v(dout0_132) AT=665.025n

.meas tran vdout0_133ck1320 FIND v(dout0_133) AT=665.025n

.meas tran vdout0_134ck1320 FIND v(dout0_134) AT=665.025n

.meas tran vdout0_135ck1320 FIND v(dout0_135) AT=665.025n

.meas tran vdout0_136ck1320 FIND v(dout0_136) AT=665.025n

.meas tran vdout0_137ck1320 FIND v(dout0_137) AT=665.025n

.meas tran vdout0_138ck1320 FIND v(dout0_138) AT=665.025n

.meas tran vdout0_139ck1320 FIND v(dout0_139) AT=665.025n

.meas tran vdout0_140ck1320 FIND v(dout0_140) AT=665.025n

.meas tran vdout0_141ck1320 FIND v(dout0_141) AT=665.025n

.meas tran vdout0_142ck1320 FIND v(dout0_142) AT=665.025n

.meas tran vdout0_143ck1320 FIND v(dout0_143) AT=665.025n

.meas tran vdout0_144ck1320 FIND v(dout0_144) AT=665.025n

.meas tran vdout0_145ck1320 FIND v(dout0_145) AT=665.025n

.meas tran vdout0_146ck1320 FIND v(dout0_146) AT=665.025n

.meas tran vdout0_147ck1320 FIND v(dout0_147) AT=665.025n

.meas tran vdout0_148ck1320 FIND v(dout0_148) AT=665.025n

.meas tran vdout0_149ck1320 FIND v(dout0_149) AT=665.025n

.meas tran vdout0_0ck1340 FIND v(dout0_0) AT=675.025n

.meas tran vdout0_1ck1340 FIND v(dout0_1) AT=675.025n

.meas tran vdout0_2ck1340 FIND v(dout0_2) AT=675.025n

.meas tran vdout0_3ck1340 FIND v(dout0_3) AT=675.025n

.meas tran vdout0_4ck1340 FIND v(dout0_4) AT=675.025n

.meas tran vdout0_5ck1340 FIND v(dout0_5) AT=675.025n

.meas tran vdout0_6ck1340 FIND v(dout0_6) AT=675.025n

.meas tran vdout0_7ck1340 FIND v(dout0_7) AT=675.025n

.meas tran vdout0_8ck1340 FIND v(dout0_8) AT=675.025n

.meas tran vdout0_9ck1340 FIND v(dout0_9) AT=675.025n

.meas tran vdout0_10ck1340 FIND v(dout0_10) AT=675.025n

.meas tran vdout0_11ck1340 FIND v(dout0_11) AT=675.025n

.meas tran vdout0_12ck1340 FIND v(dout0_12) AT=675.025n

.meas tran vdout0_13ck1340 FIND v(dout0_13) AT=675.025n

.meas tran vdout0_14ck1340 FIND v(dout0_14) AT=675.025n

.meas tran vdout0_15ck1340 FIND v(dout0_15) AT=675.025n

.meas tran vdout0_16ck1340 FIND v(dout0_16) AT=675.025n

.meas tran vdout0_17ck1340 FIND v(dout0_17) AT=675.025n

.meas tran vdout0_18ck1340 FIND v(dout0_18) AT=675.025n

.meas tran vdout0_19ck1340 FIND v(dout0_19) AT=675.025n

.meas tran vdout0_20ck1340 FIND v(dout0_20) AT=675.025n

.meas tran vdout0_21ck1340 FIND v(dout0_21) AT=675.025n

.meas tran vdout0_22ck1340 FIND v(dout0_22) AT=675.025n

.meas tran vdout0_23ck1340 FIND v(dout0_23) AT=675.025n

.meas tran vdout0_24ck1340 FIND v(dout0_24) AT=675.025n

.meas tran vdout0_25ck1340 FIND v(dout0_25) AT=675.025n

.meas tran vdout0_26ck1340 FIND v(dout0_26) AT=675.025n

.meas tran vdout0_27ck1340 FIND v(dout0_27) AT=675.025n

.meas tran vdout0_28ck1340 FIND v(dout0_28) AT=675.025n

.meas tran vdout0_29ck1340 FIND v(dout0_29) AT=675.025n

.meas tran vdout0_30ck1340 FIND v(dout0_30) AT=675.025n

.meas tran vdout0_31ck1340 FIND v(dout0_31) AT=675.025n

.meas tran vdout0_32ck1340 FIND v(dout0_32) AT=675.025n

.meas tran vdout0_33ck1340 FIND v(dout0_33) AT=675.025n

.meas tran vdout0_34ck1340 FIND v(dout0_34) AT=675.025n

.meas tran vdout0_35ck1340 FIND v(dout0_35) AT=675.025n

.meas tran vdout0_36ck1340 FIND v(dout0_36) AT=675.025n

.meas tran vdout0_37ck1340 FIND v(dout0_37) AT=675.025n

.meas tran vdout0_38ck1340 FIND v(dout0_38) AT=675.025n

.meas tran vdout0_39ck1340 FIND v(dout0_39) AT=675.025n

.meas tran vdout0_40ck1340 FIND v(dout0_40) AT=675.025n

.meas tran vdout0_41ck1340 FIND v(dout0_41) AT=675.025n

.meas tran vdout0_42ck1340 FIND v(dout0_42) AT=675.025n

.meas tran vdout0_43ck1340 FIND v(dout0_43) AT=675.025n

.meas tran vdout0_44ck1340 FIND v(dout0_44) AT=675.025n

.meas tran vdout0_45ck1340 FIND v(dout0_45) AT=675.025n

.meas tran vdout0_46ck1340 FIND v(dout0_46) AT=675.025n

.meas tran vdout0_47ck1340 FIND v(dout0_47) AT=675.025n

.meas tran vdout0_48ck1340 FIND v(dout0_48) AT=675.025n

.meas tran vdout0_49ck1340 FIND v(dout0_49) AT=675.025n

.meas tran vdout0_50ck1340 FIND v(dout0_50) AT=675.025n

.meas tran vdout0_51ck1340 FIND v(dout0_51) AT=675.025n

.meas tran vdout0_52ck1340 FIND v(dout0_52) AT=675.025n

.meas tran vdout0_53ck1340 FIND v(dout0_53) AT=675.025n

.meas tran vdout0_54ck1340 FIND v(dout0_54) AT=675.025n

.meas tran vdout0_55ck1340 FIND v(dout0_55) AT=675.025n

.meas tran vdout0_56ck1340 FIND v(dout0_56) AT=675.025n

.meas tran vdout0_57ck1340 FIND v(dout0_57) AT=675.025n

.meas tran vdout0_58ck1340 FIND v(dout0_58) AT=675.025n

.meas tran vdout0_59ck1340 FIND v(dout0_59) AT=675.025n

.meas tran vdout0_60ck1340 FIND v(dout0_60) AT=675.025n

.meas tran vdout0_61ck1340 FIND v(dout0_61) AT=675.025n

.meas tran vdout0_62ck1340 FIND v(dout0_62) AT=675.025n

.meas tran vdout0_63ck1340 FIND v(dout0_63) AT=675.025n

.meas tran vdout0_64ck1340 FIND v(dout0_64) AT=675.025n

.meas tran vdout0_65ck1340 FIND v(dout0_65) AT=675.025n

.meas tran vdout0_66ck1340 FIND v(dout0_66) AT=675.025n

.meas tran vdout0_67ck1340 FIND v(dout0_67) AT=675.025n

.meas tran vdout0_68ck1340 FIND v(dout0_68) AT=675.025n

.meas tran vdout0_69ck1340 FIND v(dout0_69) AT=675.025n

.meas tran vdout0_70ck1340 FIND v(dout0_70) AT=675.025n

.meas tran vdout0_71ck1340 FIND v(dout0_71) AT=675.025n

.meas tran vdout0_72ck1340 FIND v(dout0_72) AT=675.025n

.meas tran vdout0_73ck1340 FIND v(dout0_73) AT=675.025n

.meas tran vdout0_74ck1340 FIND v(dout0_74) AT=675.025n

.meas tran vdout0_75ck1340 FIND v(dout0_75) AT=675.025n

.meas tran vdout0_76ck1340 FIND v(dout0_76) AT=675.025n

.meas tran vdout0_77ck1340 FIND v(dout0_77) AT=675.025n

.meas tran vdout0_78ck1340 FIND v(dout0_78) AT=675.025n

.meas tran vdout0_79ck1340 FIND v(dout0_79) AT=675.025n

.meas tran vdout0_80ck1340 FIND v(dout0_80) AT=675.025n

.meas tran vdout0_81ck1340 FIND v(dout0_81) AT=675.025n

.meas tran vdout0_82ck1340 FIND v(dout0_82) AT=675.025n

.meas tran vdout0_83ck1340 FIND v(dout0_83) AT=675.025n

.meas tran vdout0_84ck1340 FIND v(dout0_84) AT=675.025n

.meas tran vdout0_85ck1340 FIND v(dout0_85) AT=675.025n

.meas tran vdout0_86ck1340 FIND v(dout0_86) AT=675.025n

.meas tran vdout0_87ck1340 FIND v(dout0_87) AT=675.025n

.meas tran vdout0_88ck1340 FIND v(dout0_88) AT=675.025n

.meas tran vdout0_89ck1340 FIND v(dout0_89) AT=675.025n

.meas tran vdout0_90ck1340 FIND v(dout0_90) AT=675.025n

.meas tran vdout0_91ck1340 FIND v(dout0_91) AT=675.025n

.meas tran vdout0_92ck1340 FIND v(dout0_92) AT=675.025n

.meas tran vdout0_93ck1340 FIND v(dout0_93) AT=675.025n

.meas tran vdout0_94ck1340 FIND v(dout0_94) AT=675.025n

.meas tran vdout0_95ck1340 FIND v(dout0_95) AT=675.025n

.meas tran vdout0_96ck1340 FIND v(dout0_96) AT=675.025n

.meas tran vdout0_97ck1340 FIND v(dout0_97) AT=675.025n

.meas tran vdout0_98ck1340 FIND v(dout0_98) AT=675.025n

.meas tran vdout0_99ck1340 FIND v(dout0_99) AT=675.025n

.meas tran vdout0_100ck1340 FIND v(dout0_100) AT=675.025n

.meas tran vdout0_101ck1340 FIND v(dout0_101) AT=675.025n

.meas tran vdout0_102ck1340 FIND v(dout0_102) AT=675.025n

.meas tran vdout0_103ck1340 FIND v(dout0_103) AT=675.025n

.meas tran vdout0_104ck1340 FIND v(dout0_104) AT=675.025n

.meas tran vdout0_105ck1340 FIND v(dout0_105) AT=675.025n

.meas tran vdout0_106ck1340 FIND v(dout0_106) AT=675.025n

.meas tran vdout0_107ck1340 FIND v(dout0_107) AT=675.025n

.meas tran vdout0_108ck1340 FIND v(dout0_108) AT=675.025n

.meas tran vdout0_109ck1340 FIND v(dout0_109) AT=675.025n

.meas tran vdout0_110ck1340 FIND v(dout0_110) AT=675.025n

.meas tran vdout0_111ck1340 FIND v(dout0_111) AT=675.025n

.meas tran vdout0_112ck1340 FIND v(dout0_112) AT=675.025n

.meas tran vdout0_113ck1340 FIND v(dout0_113) AT=675.025n

.meas tran vdout0_114ck1340 FIND v(dout0_114) AT=675.025n

.meas tran vdout0_115ck1340 FIND v(dout0_115) AT=675.025n

.meas tran vdout0_116ck1340 FIND v(dout0_116) AT=675.025n

.meas tran vdout0_117ck1340 FIND v(dout0_117) AT=675.025n

.meas tran vdout0_118ck1340 FIND v(dout0_118) AT=675.025n

.meas tran vdout0_119ck1340 FIND v(dout0_119) AT=675.025n

.meas tran vdout0_120ck1340 FIND v(dout0_120) AT=675.025n

.meas tran vdout0_121ck1340 FIND v(dout0_121) AT=675.025n

.meas tran vdout0_122ck1340 FIND v(dout0_122) AT=675.025n

.meas tran vdout0_123ck1340 FIND v(dout0_123) AT=675.025n

.meas tran vdout0_124ck1340 FIND v(dout0_124) AT=675.025n

.meas tran vdout0_125ck1340 FIND v(dout0_125) AT=675.025n

.meas tran vdout0_126ck1340 FIND v(dout0_126) AT=675.025n

.meas tran vdout0_127ck1340 FIND v(dout0_127) AT=675.025n

.meas tran vdout0_128ck1340 FIND v(dout0_128) AT=675.025n

.meas tran vdout0_129ck1340 FIND v(dout0_129) AT=675.025n

.meas tran vdout0_130ck1340 FIND v(dout0_130) AT=675.025n

.meas tran vdout0_131ck1340 FIND v(dout0_131) AT=675.025n

.meas tran vdout0_132ck1340 FIND v(dout0_132) AT=675.025n

.meas tran vdout0_133ck1340 FIND v(dout0_133) AT=675.025n

.meas tran vdout0_134ck1340 FIND v(dout0_134) AT=675.025n

.meas tran vdout0_135ck1340 FIND v(dout0_135) AT=675.025n

.meas tran vdout0_136ck1340 FIND v(dout0_136) AT=675.025n

.meas tran vdout0_137ck1340 FIND v(dout0_137) AT=675.025n

.meas tran vdout0_138ck1340 FIND v(dout0_138) AT=675.025n

.meas tran vdout0_139ck1340 FIND v(dout0_139) AT=675.025n

.meas tran vdout0_140ck1340 FIND v(dout0_140) AT=675.025n

.meas tran vdout0_141ck1340 FIND v(dout0_141) AT=675.025n

.meas tran vdout0_142ck1340 FIND v(dout0_142) AT=675.025n

.meas tran vdout0_143ck1340 FIND v(dout0_143) AT=675.025n

.meas tran vdout0_144ck1340 FIND v(dout0_144) AT=675.025n

.meas tran vdout0_145ck1340 FIND v(dout0_145) AT=675.025n

.meas tran vdout0_146ck1340 FIND v(dout0_146) AT=675.025n

.meas tran vdout0_147ck1340 FIND v(dout0_147) AT=675.025n

.meas tran vdout0_148ck1340 FIND v(dout0_148) AT=675.025n

.meas tran vdout0_149ck1340 FIND v(dout0_149) AT=675.025n

.meas tran vdout0_0ck1350 FIND v(dout0_0) AT=680.025n

.meas tran vdout0_1ck1350 FIND v(dout0_1) AT=680.025n

.meas tran vdout0_2ck1350 FIND v(dout0_2) AT=680.025n

.meas tran vdout0_3ck1350 FIND v(dout0_3) AT=680.025n

.meas tran vdout0_4ck1350 FIND v(dout0_4) AT=680.025n

.meas tran vdout0_5ck1350 FIND v(dout0_5) AT=680.025n

.meas tran vdout0_6ck1350 FIND v(dout0_6) AT=680.025n

.meas tran vdout0_7ck1350 FIND v(dout0_7) AT=680.025n

.meas tran vdout0_8ck1350 FIND v(dout0_8) AT=680.025n

.meas tran vdout0_9ck1350 FIND v(dout0_9) AT=680.025n

.meas tran vdout0_10ck1350 FIND v(dout0_10) AT=680.025n

.meas tran vdout0_11ck1350 FIND v(dout0_11) AT=680.025n

.meas tran vdout0_12ck1350 FIND v(dout0_12) AT=680.025n

.meas tran vdout0_13ck1350 FIND v(dout0_13) AT=680.025n

.meas tran vdout0_14ck1350 FIND v(dout0_14) AT=680.025n

.meas tran vdout0_15ck1350 FIND v(dout0_15) AT=680.025n

.meas tran vdout0_16ck1350 FIND v(dout0_16) AT=680.025n

.meas tran vdout0_17ck1350 FIND v(dout0_17) AT=680.025n

.meas tran vdout0_18ck1350 FIND v(dout0_18) AT=680.025n

.meas tran vdout0_19ck1350 FIND v(dout0_19) AT=680.025n

.meas tran vdout0_20ck1350 FIND v(dout0_20) AT=680.025n

.meas tran vdout0_21ck1350 FIND v(dout0_21) AT=680.025n

.meas tran vdout0_22ck1350 FIND v(dout0_22) AT=680.025n

.meas tran vdout0_23ck1350 FIND v(dout0_23) AT=680.025n

.meas tran vdout0_24ck1350 FIND v(dout0_24) AT=680.025n

.meas tran vdout0_25ck1350 FIND v(dout0_25) AT=680.025n

.meas tran vdout0_26ck1350 FIND v(dout0_26) AT=680.025n

.meas tran vdout0_27ck1350 FIND v(dout0_27) AT=680.025n

.meas tran vdout0_28ck1350 FIND v(dout0_28) AT=680.025n

.meas tran vdout0_29ck1350 FIND v(dout0_29) AT=680.025n

.meas tran vdout0_30ck1350 FIND v(dout0_30) AT=680.025n

.meas tran vdout0_31ck1350 FIND v(dout0_31) AT=680.025n

.meas tran vdout0_32ck1350 FIND v(dout0_32) AT=680.025n

.meas tran vdout0_33ck1350 FIND v(dout0_33) AT=680.025n

.meas tran vdout0_34ck1350 FIND v(dout0_34) AT=680.025n

.meas tran vdout0_35ck1350 FIND v(dout0_35) AT=680.025n

.meas tran vdout0_36ck1350 FIND v(dout0_36) AT=680.025n

.meas tran vdout0_37ck1350 FIND v(dout0_37) AT=680.025n

.meas tran vdout0_38ck1350 FIND v(dout0_38) AT=680.025n

.meas tran vdout0_39ck1350 FIND v(dout0_39) AT=680.025n

.meas tran vdout0_40ck1350 FIND v(dout0_40) AT=680.025n

.meas tran vdout0_41ck1350 FIND v(dout0_41) AT=680.025n

.meas tran vdout0_42ck1350 FIND v(dout0_42) AT=680.025n

.meas tran vdout0_43ck1350 FIND v(dout0_43) AT=680.025n

.meas tran vdout0_44ck1350 FIND v(dout0_44) AT=680.025n

.meas tran vdout0_45ck1350 FIND v(dout0_45) AT=680.025n

.meas tran vdout0_46ck1350 FIND v(dout0_46) AT=680.025n

.meas tran vdout0_47ck1350 FIND v(dout0_47) AT=680.025n

.meas tran vdout0_48ck1350 FIND v(dout0_48) AT=680.025n

.meas tran vdout0_49ck1350 FIND v(dout0_49) AT=680.025n

.meas tran vdout0_50ck1350 FIND v(dout0_50) AT=680.025n

.meas tran vdout0_51ck1350 FIND v(dout0_51) AT=680.025n

.meas tran vdout0_52ck1350 FIND v(dout0_52) AT=680.025n

.meas tran vdout0_53ck1350 FIND v(dout0_53) AT=680.025n

.meas tran vdout0_54ck1350 FIND v(dout0_54) AT=680.025n

.meas tran vdout0_55ck1350 FIND v(dout0_55) AT=680.025n

.meas tran vdout0_56ck1350 FIND v(dout0_56) AT=680.025n

.meas tran vdout0_57ck1350 FIND v(dout0_57) AT=680.025n

.meas tran vdout0_58ck1350 FIND v(dout0_58) AT=680.025n

.meas tran vdout0_59ck1350 FIND v(dout0_59) AT=680.025n

.meas tran vdout0_60ck1350 FIND v(dout0_60) AT=680.025n

.meas tran vdout0_61ck1350 FIND v(dout0_61) AT=680.025n

.meas tran vdout0_62ck1350 FIND v(dout0_62) AT=680.025n

.meas tran vdout0_63ck1350 FIND v(dout0_63) AT=680.025n

.meas tran vdout0_64ck1350 FIND v(dout0_64) AT=680.025n

.meas tran vdout0_65ck1350 FIND v(dout0_65) AT=680.025n

.meas tran vdout0_66ck1350 FIND v(dout0_66) AT=680.025n

.meas tran vdout0_67ck1350 FIND v(dout0_67) AT=680.025n

.meas tran vdout0_68ck1350 FIND v(dout0_68) AT=680.025n

.meas tran vdout0_69ck1350 FIND v(dout0_69) AT=680.025n

.meas tran vdout0_70ck1350 FIND v(dout0_70) AT=680.025n

.meas tran vdout0_71ck1350 FIND v(dout0_71) AT=680.025n

.meas tran vdout0_72ck1350 FIND v(dout0_72) AT=680.025n

.meas tran vdout0_73ck1350 FIND v(dout0_73) AT=680.025n

.meas tran vdout0_74ck1350 FIND v(dout0_74) AT=680.025n

.meas tran vdout0_75ck1350 FIND v(dout0_75) AT=680.025n

.meas tran vdout0_76ck1350 FIND v(dout0_76) AT=680.025n

.meas tran vdout0_77ck1350 FIND v(dout0_77) AT=680.025n

.meas tran vdout0_78ck1350 FIND v(dout0_78) AT=680.025n

.meas tran vdout0_79ck1350 FIND v(dout0_79) AT=680.025n

.meas tran vdout0_80ck1350 FIND v(dout0_80) AT=680.025n

.meas tran vdout0_81ck1350 FIND v(dout0_81) AT=680.025n

.meas tran vdout0_82ck1350 FIND v(dout0_82) AT=680.025n

.meas tran vdout0_83ck1350 FIND v(dout0_83) AT=680.025n

.meas tran vdout0_84ck1350 FIND v(dout0_84) AT=680.025n

.meas tran vdout0_85ck1350 FIND v(dout0_85) AT=680.025n

.meas tran vdout0_86ck1350 FIND v(dout0_86) AT=680.025n

.meas tran vdout0_87ck1350 FIND v(dout0_87) AT=680.025n

.meas tran vdout0_88ck1350 FIND v(dout0_88) AT=680.025n

.meas tran vdout0_89ck1350 FIND v(dout0_89) AT=680.025n

.meas tran vdout0_90ck1350 FIND v(dout0_90) AT=680.025n

.meas tran vdout0_91ck1350 FIND v(dout0_91) AT=680.025n

.meas tran vdout0_92ck1350 FIND v(dout0_92) AT=680.025n

.meas tran vdout0_93ck1350 FIND v(dout0_93) AT=680.025n

.meas tran vdout0_94ck1350 FIND v(dout0_94) AT=680.025n

.meas tran vdout0_95ck1350 FIND v(dout0_95) AT=680.025n

.meas tran vdout0_96ck1350 FIND v(dout0_96) AT=680.025n

.meas tran vdout0_97ck1350 FIND v(dout0_97) AT=680.025n

.meas tran vdout0_98ck1350 FIND v(dout0_98) AT=680.025n

.meas tran vdout0_99ck1350 FIND v(dout0_99) AT=680.025n

.meas tran vdout0_100ck1350 FIND v(dout0_100) AT=680.025n

.meas tran vdout0_101ck1350 FIND v(dout0_101) AT=680.025n

.meas tran vdout0_102ck1350 FIND v(dout0_102) AT=680.025n

.meas tran vdout0_103ck1350 FIND v(dout0_103) AT=680.025n

.meas tran vdout0_104ck1350 FIND v(dout0_104) AT=680.025n

.meas tran vdout0_105ck1350 FIND v(dout0_105) AT=680.025n

.meas tran vdout0_106ck1350 FIND v(dout0_106) AT=680.025n

.meas tran vdout0_107ck1350 FIND v(dout0_107) AT=680.025n

.meas tran vdout0_108ck1350 FIND v(dout0_108) AT=680.025n

.meas tran vdout0_109ck1350 FIND v(dout0_109) AT=680.025n

.meas tran vdout0_110ck1350 FIND v(dout0_110) AT=680.025n

.meas tran vdout0_111ck1350 FIND v(dout0_111) AT=680.025n

.meas tran vdout0_112ck1350 FIND v(dout0_112) AT=680.025n

.meas tran vdout0_113ck1350 FIND v(dout0_113) AT=680.025n

.meas tran vdout0_114ck1350 FIND v(dout0_114) AT=680.025n

.meas tran vdout0_115ck1350 FIND v(dout0_115) AT=680.025n

.meas tran vdout0_116ck1350 FIND v(dout0_116) AT=680.025n

.meas tran vdout0_117ck1350 FIND v(dout0_117) AT=680.025n

.meas tran vdout0_118ck1350 FIND v(dout0_118) AT=680.025n

.meas tran vdout0_119ck1350 FIND v(dout0_119) AT=680.025n

.meas tran vdout0_120ck1350 FIND v(dout0_120) AT=680.025n

.meas tran vdout0_121ck1350 FIND v(dout0_121) AT=680.025n

.meas tran vdout0_122ck1350 FIND v(dout0_122) AT=680.025n

.meas tran vdout0_123ck1350 FIND v(dout0_123) AT=680.025n

.meas tran vdout0_124ck1350 FIND v(dout0_124) AT=680.025n

.meas tran vdout0_125ck1350 FIND v(dout0_125) AT=680.025n

.meas tran vdout0_126ck1350 FIND v(dout0_126) AT=680.025n

.meas tran vdout0_127ck1350 FIND v(dout0_127) AT=680.025n

.meas tran vdout0_128ck1350 FIND v(dout0_128) AT=680.025n

.meas tran vdout0_129ck1350 FIND v(dout0_129) AT=680.025n

.meas tran vdout0_130ck1350 FIND v(dout0_130) AT=680.025n

.meas tran vdout0_131ck1350 FIND v(dout0_131) AT=680.025n

.meas tran vdout0_132ck1350 FIND v(dout0_132) AT=680.025n

.meas tran vdout0_133ck1350 FIND v(dout0_133) AT=680.025n

.meas tran vdout0_134ck1350 FIND v(dout0_134) AT=680.025n

.meas tran vdout0_135ck1350 FIND v(dout0_135) AT=680.025n

.meas tran vdout0_136ck1350 FIND v(dout0_136) AT=680.025n

.meas tran vdout0_137ck1350 FIND v(dout0_137) AT=680.025n

.meas tran vdout0_138ck1350 FIND v(dout0_138) AT=680.025n

.meas tran vdout0_139ck1350 FIND v(dout0_139) AT=680.025n

.meas tran vdout0_140ck1350 FIND v(dout0_140) AT=680.025n

.meas tran vdout0_141ck1350 FIND v(dout0_141) AT=680.025n

.meas tran vdout0_142ck1350 FIND v(dout0_142) AT=680.025n

.meas tran vdout0_143ck1350 FIND v(dout0_143) AT=680.025n

.meas tran vdout0_144ck1350 FIND v(dout0_144) AT=680.025n

.meas tran vdout0_145ck1350 FIND v(dout0_145) AT=680.025n

.meas tran vdout0_146ck1350 FIND v(dout0_146) AT=680.025n

.meas tran vdout0_147ck1350 FIND v(dout0_147) AT=680.025n

.meas tran vdout0_148ck1350 FIND v(dout0_148) AT=680.025n

.meas tran vdout0_149ck1350 FIND v(dout0_149) AT=680.025n

.meas tran vdout0_0ck1370 FIND v(dout0_0) AT=690.025n

.meas tran vdout0_1ck1370 FIND v(dout0_1) AT=690.025n

.meas tran vdout0_2ck1370 FIND v(dout0_2) AT=690.025n

.meas tran vdout0_3ck1370 FIND v(dout0_3) AT=690.025n

.meas tran vdout0_4ck1370 FIND v(dout0_4) AT=690.025n

.meas tran vdout0_5ck1370 FIND v(dout0_5) AT=690.025n

.meas tran vdout0_6ck1370 FIND v(dout0_6) AT=690.025n

.meas tran vdout0_7ck1370 FIND v(dout0_7) AT=690.025n

.meas tran vdout0_8ck1370 FIND v(dout0_8) AT=690.025n

.meas tran vdout0_9ck1370 FIND v(dout0_9) AT=690.025n

.meas tran vdout0_10ck1370 FIND v(dout0_10) AT=690.025n

.meas tran vdout0_11ck1370 FIND v(dout0_11) AT=690.025n

.meas tran vdout0_12ck1370 FIND v(dout0_12) AT=690.025n

.meas tran vdout0_13ck1370 FIND v(dout0_13) AT=690.025n

.meas tran vdout0_14ck1370 FIND v(dout0_14) AT=690.025n

.meas tran vdout0_15ck1370 FIND v(dout0_15) AT=690.025n

.meas tran vdout0_16ck1370 FIND v(dout0_16) AT=690.025n

.meas tran vdout0_17ck1370 FIND v(dout0_17) AT=690.025n

.meas tran vdout0_18ck1370 FIND v(dout0_18) AT=690.025n

.meas tran vdout0_19ck1370 FIND v(dout0_19) AT=690.025n

.meas tran vdout0_20ck1370 FIND v(dout0_20) AT=690.025n

.meas tran vdout0_21ck1370 FIND v(dout0_21) AT=690.025n

.meas tran vdout0_22ck1370 FIND v(dout0_22) AT=690.025n

.meas tran vdout0_23ck1370 FIND v(dout0_23) AT=690.025n

.meas tran vdout0_24ck1370 FIND v(dout0_24) AT=690.025n

.meas tran vdout0_25ck1370 FIND v(dout0_25) AT=690.025n

.meas tran vdout0_26ck1370 FIND v(dout0_26) AT=690.025n

.meas tran vdout0_27ck1370 FIND v(dout0_27) AT=690.025n

.meas tran vdout0_28ck1370 FIND v(dout0_28) AT=690.025n

.meas tran vdout0_29ck1370 FIND v(dout0_29) AT=690.025n

.meas tran vdout0_30ck1370 FIND v(dout0_30) AT=690.025n

.meas tran vdout0_31ck1370 FIND v(dout0_31) AT=690.025n

.meas tran vdout0_32ck1370 FIND v(dout0_32) AT=690.025n

.meas tran vdout0_33ck1370 FIND v(dout0_33) AT=690.025n

.meas tran vdout0_34ck1370 FIND v(dout0_34) AT=690.025n

.meas tran vdout0_35ck1370 FIND v(dout0_35) AT=690.025n

.meas tran vdout0_36ck1370 FIND v(dout0_36) AT=690.025n

.meas tran vdout0_37ck1370 FIND v(dout0_37) AT=690.025n

.meas tran vdout0_38ck1370 FIND v(dout0_38) AT=690.025n

.meas tran vdout0_39ck1370 FIND v(dout0_39) AT=690.025n

.meas tran vdout0_40ck1370 FIND v(dout0_40) AT=690.025n

.meas tran vdout0_41ck1370 FIND v(dout0_41) AT=690.025n

.meas tran vdout0_42ck1370 FIND v(dout0_42) AT=690.025n

.meas tran vdout0_43ck1370 FIND v(dout0_43) AT=690.025n

.meas tran vdout0_44ck1370 FIND v(dout0_44) AT=690.025n

.meas tran vdout0_45ck1370 FIND v(dout0_45) AT=690.025n

.meas tran vdout0_46ck1370 FIND v(dout0_46) AT=690.025n

.meas tran vdout0_47ck1370 FIND v(dout0_47) AT=690.025n

.meas tran vdout0_48ck1370 FIND v(dout0_48) AT=690.025n

.meas tran vdout0_49ck1370 FIND v(dout0_49) AT=690.025n

.meas tran vdout0_50ck1370 FIND v(dout0_50) AT=690.025n

.meas tran vdout0_51ck1370 FIND v(dout0_51) AT=690.025n

.meas tran vdout0_52ck1370 FIND v(dout0_52) AT=690.025n

.meas tran vdout0_53ck1370 FIND v(dout0_53) AT=690.025n

.meas tran vdout0_54ck1370 FIND v(dout0_54) AT=690.025n

.meas tran vdout0_55ck1370 FIND v(dout0_55) AT=690.025n

.meas tran vdout0_56ck1370 FIND v(dout0_56) AT=690.025n

.meas tran vdout0_57ck1370 FIND v(dout0_57) AT=690.025n

.meas tran vdout0_58ck1370 FIND v(dout0_58) AT=690.025n

.meas tran vdout0_59ck1370 FIND v(dout0_59) AT=690.025n

.meas tran vdout0_60ck1370 FIND v(dout0_60) AT=690.025n

.meas tran vdout0_61ck1370 FIND v(dout0_61) AT=690.025n

.meas tran vdout0_62ck1370 FIND v(dout0_62) AT=690.025n

.meas tran vdout0_63ck1370 FIND v(dout0_63) AT=690.025n

.meas tran vdout0_64ck1370 FIND v(dout0_64) AT=690.025n

.meas tran vdout0_65ck1370 FIND v(dout0_65) AT=690.025n

.meas tran vdout0_66ck1370 FIND v(dout0_66) AT=690.025n

.meas tran vdout0_67ck1370 FIND v(dout0_67) AT=690.025n

.meas tran vdout0_68ck1370 FIND v(dout0_68) AT=690.025n

.meas tran vdout0_69ck1370 FIND v(dout0_69) AT=690.025n

.meas tran vdout0_70ck1370 FIND v(dout0_70) AT=690.025n

.meas tran vdout0_71ck1370 FIND v(dout0_71) AT=690.025n

.meas tran vdout0_72ck1370 FIND v(dout0_72) AT=690.025n

.meas tran vdout0_73ck1370 FIND v(dout0_73) AT=690.025n

.meas tran vdout0_74ck1370 FIND v(dout0_74) AT=690.025n

.meas tran vdout0_75ck1370 FIND v(dout0_75) AT=690.025n

.meas tran vdout0_76ck1370 FIND v(dout0_76) AT=690.025n

.meas tran vdout0_77ck1370 FIND v(dout0_77) AT=690.025n

.meas tran vdout0_78ck1370 FIND v(dout0_78) AT=690.025n

.meas tran vdout0_79ck1370 FIND v(dout0_79) AT=690.025n

.meas tran vdout0_80ck1370 FIND v(dout0_80) AT=690.025n

.meas tran vdout0_81ck1370 FIND v(dout0_81) AT=690.025n

.meas tran vdout0_82ck1370 FIND v(dout0_82) AT=690.025n

.meas tran vdout0_83ck1370 FIND v(dout0_83) AT=690.025n

.meas tran vdout0_84ck1370 FIND v(dout0_84) AT=690.025n

.meas tran vdout0_85ck1370 FIND v(dout0_85) AT=690.025n

.meas tran vdout0_86ck1370 FIND v(dout0_86) AT=690.025n

.meas tran vdout0_87ck1370 FIND v(dout0_87) AT=690.025n

.meas tran vdout0_88ck1370 FIND v(dout0_88) AT=690.025n

.meas tran vdout0_89ck1370 FIND v(dout0_89) AT=690.025n

.meas tran vdout0_90ck1370 FIND v(dout0_90) AT=690.025n

.meas tran vdout0_91ck1370 FIND v(dout0_91) AT=690.025n

.meas tran vdout0_92ck1370 FIND v(dout0_92) AT=690.025n

.meas tran vdout0_93ck1370 FIND v(dout0_93) AT=690.025n

.meas tran vdout0_94ck1370 FIND v(dout0_94) AT=690.025n

.meas tran vdout0_95ck1370 FIND v(dout0_95) AT=690.025n

.meas tran vdout0_96ck1370 FIND v(dout0_96) AT=690.025n

.meas tran vdout0_97ck1370 FIND v(dout0_97) AT=690.025n

.meas tran vdout0_98ck1370 FIND v(dout0_98) AT=690.025n

.meas tran vdout0_99ck1370 FIND v(dout0_99) AT=690.025n

.meas tran vdout0_100ck1370 FIND v(dout0_100) AT=690.025n

.meas tran vdout0_101ck1370 FIND v(dout0_101) AT=690.025n

.meas tran vdout0_102ck1370 FIND v(dout0_102) AT=690.025n

.meas tran vdout0_103ck1370 FIND v(dout0_103) AT=690.025n

.meas tran vdout0_104ck1370 FIND v(dout0_104) AT=690.025n

.meas tran vdout0_105ck1370 FIND v(dout0_105) AT=690.025n

.meas tran vdout0_106ck1370 FIND v(dout0_106) AT=690.025n

.meas tran vdout0_107ck1370 FIND v(dout0_107) AT=690.025n

.meas tran vdout0_108ck1370 FIND v(dout0_108) AT=690.025n

.meas tran vdout0_109ck1370 FIND v(dout0_109) AT=690.025n

.meas tran vdout0_110ck1370 FIND v(dout0_110) AT=690.025n

.meas tran vdout0_111ck1370 FIND v(dout0_111) AT=690.025n

.meas tran vdout0_112ck1370 FIND v(dout0_112) AT=690.025n

.meas tran vdout0_113ck1370 FIND v(dout0_113) AT=690.025n

.meas tran vdout0_114ck1370 FIND v(dout0_114) AT=690.025n

.meas tran vdout0_115ck1370 FIND v(dout0_115) AT=690.025n

.meas tran vdout0_116ck1370 FIND v(dout0_116) AT=690.025n

.meas tran vdout0_117ck1370 FIND v(dout0_117) AT=690.025n

.meas tran vdout0_118ck1370 FIND v(dout0_118) AT=690.025n

.meas tran vdout0_119ck1370 FIND v(dout0_119) AT=690.025n

.meas tran vdout0_120ck1370 FIND v(dout0_120) AT=690.025n

.meas tran vdout0_121ck1370 FIND v(dout0_121) AT=690.025n

.meas tran vdout0_122ck1370 FIND v(dout0_122) AT=690.025n

.meas tran vdout0_123ck1370 FIND v(dout0_123) AT=690.025n

.meas tran vdout0_124ck1370 FIND v(dout0_124) AT=690.025n

.meas tran vdout0_125ck1370 FIND v(dout0_125) AT=690.025n

.meas tran vdout0_126ck1370 FIND v(dout0_126) AT=690.025n

.meas tran vdout0_127ck1370 FIND v(dout0_127) AT=690.025n

.meas tran vdout0_128ck1370 FIND v(dout0_128) AT=690.025n

.meas tran vdout0_129ck1370 FIND v(dout0_129) AT=690.025n

.meas tran vdout0_130ck1370 FIND v(dout0_130) AT=690.025n

.meas tran vdout0_131ck1370 FIND v(dout0_131) AT=690.025n

.meas tran vdout0_132ck1370 FIND v(dout0_132) AT=690.025n

.meas tran vdout0_133ck1370 FIND v(dout0_133) AT=690.025n

.meas tran vdout0_134ck1370 FIND v(dout0_134) AT=690.025n

.meas tran vdout0_135ck1370 FIND v(dout0_135) AT=690.025n

.meas tran vdout0_136ck1370 FIND v(dout0_136) AT=690.025n

.meas tran vdout0_137ck1370 FIND v(dout0_137) AT=690.025n

.meas tran vdout0_138ck1370 FIND v(dout0_138) AT=690.025n

.meas tran vdout0_139ck1370 FIND v(dout0_139) AT=690.025n

.meas tran vdout0_140ck1370 FIND v(dout0_140) AT=690.025n

.meas tran vdout0_141ck1370 FIND v(dout0_141) AT=690.025n

.meas tran vdout0_142ck1370 FIND v(dout0_142) AT=690.025n

.meas tran vdout0_143ck1370 FIND v(dout0_143) AT=690.025n

.meas tran vdout0_144ck1370 FIND v(dout0_144) AT=690.025n

.meas tran vdout0_145ck1370 FIND v(dout0_145) AT=690.025n

.meas tran vdout0_146ck1370 FIND v(dout0_146) AT=690.025n

.meas tran vdout0_147ck1370 FIND v(dout0_147) AT=690.025n

.meas tran vdout0_148ck1370 FIND v(dout0_148) AT=690.025n

.meas tran vdout0_149ck1370 FIND v(dout0_149) AT=690.025n

.meas tran vdout0_0ck1380 FIND v(dout0_0) AT=695.025n

.meas tran vdout0_1ck1380 FIND v(dout0_1) AT=695.025n

.meas tran vdout0_2ck1380 FIND v(dout0_2) AT=695.025n

.meas tran vdout0_3ck1380 FIND v(dout0_3) AT=695.025n

.meas tran vdout0_4ck1380 FIND v(dout0_4) AT=695.025n

.meas tran vdout0_5ck1380 FIND v(dout0_5) AT=695.025n

.meas tran vdout0_6ck1380 FIND v(dout0_6) AT=695.025n

.meas tran vdout0_7ck1380 FIND v(dout0_7) AT=695.025n

.meas tran vdout0_8ck1380 FIND v(dout0_8) AT=695.025n

.meas tran vdout0_9ck1380 FIND v(dout0_9) AT=695.025n

.meas tran vdout0_10ck1380 FIND v(dout0_10) AT=695.025n

.meas tran vdout0_11ck1380 FIND v(dout0_11) AT=695.025n

.meas tran vdout0_12ck1380 FIND v(dout0_12) AT=695.025n

.meas tran vdout0_13ck1380 FIND v(dout0_13) AT=695.025n

.meas tran vdout0_14ck1380 FIND v(dout0_14) AT=695.025n

.meas tran vdout0_15ck1380 FIND v(dout0_15) AT=695.025n

.meas tran vdout0_16ck1380 FIND v(dout0_16) AT=695.025n

.meas tran vdout0_17ck1380 FIND v(dout0_17) AT=695.025n

.meas tran vdout0_18ck1380 FIND v(dout0_18) AT=695.025n

.meas tran vdout0_19ck1380 FIND v(dout0_19) AT=695.025n

.meas tran vdout0_20ck1380 FIND v(dout0_20) AT=695.025n

.meas tran vdout0_21ck1380 FIND v(dout0_21) AT=695.025n

.meas tran vdout0_22ck1380 FIND v(dout0_22) AT=695.025n

.meas tran vdout0_23ck1380 FIND v(dout0_23) AT=695.025n

.meas tran vdout0_24ck1380 FIND v(dout0_24) AT=695.025n

.meas tran vdout0_25ck1380 FIND v(dout0_25) AT=695.025n

.meas tran vdout0_26ck1380 FIND v(dout0_26) AT=695.025n

.meas tran vdout0_27ck1380 FIND v(dout0_27) AT=695.025n

.meas tran vdout0_28ck1380 FIND v(dout0_28) AT=695.025n

.meas tran vdout0_29ck1380 FIND v(dout0_29) AT=695.025n

.meas tran vdout0_30ck1380 FIND v(dout0_30) AT=695.025n

.meas tran vdout0_31ck1380 FIND v(dout0_31) AT=695.025n

.meas tran vdout0_32ck1380 FIND v(dout0_32) AT=695.025n

.meas tran vdout0_33ck1380 FIND v(dout0_33) AT=695.025n

.meas tran vdout0_34ck1380 FIND v(dout0_34) AT=695.025n

.meas tran vdout0_35ck1380 FIND v(dout0_35) AT=695.025n

.meas tran vdout0_36ck1380 FIND v(dout0_36) AT=695.025n

.meas tran vdout0_37ck1380 FIND v(dout0_37) AT=695.025n

.meas tran vdout0_38ck1380 FIND v(dout0_38) AT=695.025n

.meas tran vdout0_39ck1380 FIND v(dout0_39) AT=695.025n

.meas tran vdout0_40ck1380 FIND v(dout0_40) AT=695.025n

.meas tran vdout0_41ck1380 FIND v(dout0_41) AT=695.025n

.meas tran vdout0_42ck1380 FIND v(dout0_42) AT=695.025n

.meas tran vdout0_43ck1380 FIND v(dout0_43) AT=695.025n

.meas tran vdout0_44ck1380 FIND v(dout0_44) AT=695.025n

.meas tran vdout0_45ck1380 FIND v(dout0_45) AT=695.025n

.meas tran vdout0_46ck1380 FIND v(dout0_46) AT=695.025n

.meas tran vdout0_47ck1380 FIND v(dout0_47) AT=695.025n

.meas tran vdout0_48ck1380 FIND v(dout0_48) AT=695.025n

.meas tran vdout0_49ck1380 FIND v(dout0_49) AT=695.025n

.meas tran vdout0_50ck1380 FIND v(dout0_50) AT=695.025n

.meas tran vdout0_51ck1380 FIND v(dout0_51) AT=695.025n

.meas tran vdout0_52ck1380 FIND v(dout0_52) AT=695.025n

.meas tran vdout0_53ck1380 FIND v(dout0_53) AT=695.025n

.meas tran vdout0_54ck1380 FIND v(dout0_54) AT=695.025n

.meas tran vdout0_55ck1380 FIND v(dout0_55) AT=695.025n

.meas tran vdout0_56ck1380 FIND v(dout0_56) AT=695.025n

.meas tran vdout0_57ck1380 FIND v(dout0_57) AT=695.025n

.meas tran vdout0_58ck1380 FIND v(dout0_58) AT=695.025n

.meas tran vdout0_59ck1380 FIND v(dout0_59) AT=695.025n

.meas tran vdout0_60ck1380 FIND v(dout0_60) AT=695.025n

.meas tran vdout0_61ck1380 FIND v(dout0_61) AT=695.025n

.meas tran vdout0_62ck1380 FIND v(dout0_62) AT=695.025n

.meas tran vdout0_63ck1380 FIND v(dout0_63) AT=695.025n

.meas tran vdout0_64ck1380 FIND v(dout0_64) AT=695.025n

.meas tran vdout0_65ck1380 FIND v(dout0_65) AT=695.025n

.meas tran vdout0_66ck1380 FIND v(dout0_66) AT=695.025n

.meas tran vdout0_67ck1380 FIND v(dout0_67) AT=695.025n

.meas tran vdout0_68ck1380 FIND v(dout0_68) AT=695.025n

.meas tran vdout0_69ck1380 FIND v(dout0_69) AT=695.025n

.meas tran vdout0_70ck1380 FIND v(dout0_70) AT=695.025n

.meas tran vdout0_71ck1380 FIND v(dout0_71) AT=695.025n

.meas tran vdout0_72ck1380 FIND v(dout0_72) AT=695.025n

.meas tran vdout0_73ck1380 FIND v(dout0_73) AT=695.025n

.meas tran vdout0_74ck1380 FIND v(dout0_74) AT=695.025n

.meas tran vdout0_75ck1380 FIND v(dout0_75) AT=695.025n

.meas tran vdout0_76ck1380 FIND v(dout0_76) AT=695.025n

.meas tran vdout0_77ck1380 FIND v(dout0_77) AT=695.025n

.meas tran vdout0_78ck1380 FIND v(dout0_78) AT=695.025n

.meas tran vdout0_79ck1380 FIND v(dout0_79) AT=695.025n

.meas tran vdout0_80ck1380 FIND v(dout0_80) AT=695.025n

.meas tran vdout0_81ck1380 FIND v(dout0_81) AT=695.025n

.meas tran vdout0_82ck1380 FIND v(dout0_82) AT=695.025n

.meas tran vdout0_83ck1380 FIND v(dout0_83) AT=695.025n

.meas tran vdout0_84ck1380 FIND v(dout0_84) AT=695.025n

.meas tran vdout0_85ck1380 FIND v(dout0_85) AT=695.025n

.meas tran vdout0_86ck1380 FIND v(dout0_86) AT=695.025n

.meas tran vdout0_87ck1380 FIND v(dout0_87) AT=695.025n

.meas tran vdout0_88ck1380 FIND v(dout0_88) AT=695.025n

.meas tran vdout0_89ck1380 FIND v(dout0_89) AT=695.025n

.meas tran vdout0_90ck1380 FIND v(dout0_90) AT=695.025n

.meas tran vdout0_91ck1380 FIND v(dout0_91) AT=695.025n

.meas tran vdout0_92ck1380 FIND v(dout0_92) AT=695.025n

.meas tran vdout0_93ck1380 FIND v(dout0_93) AT=695.025n

.meas tran vdout0_94ck1380 FIND v(dout0_94) AT=695.025n

.meas tran vdout0_95ck1380 FIND v(dout0_95) AT=695.025n

.meas tran vdout0_96ck1380 FIND v(dout0_96) AT=695.025n

.meas tran vdout0_97ck1380 FIND v(dout0_97) AT=695.025n

.meas tran vdout0_98ck1380 FIND v(dout0_98) AT=695.025n

.meas tran vdout0_99ck1380 FIND v(dout0_99) AT=695.025n

.meas tran vdout0_100ck1380 FIND v(dout0_100) AT=695.025n

.meas tran vdout0_101ck1380 FIND v(dout0_101) AT=695.025n

.meas tran vdout0_102ck1380 FIND v(dout0_102) AT=695.025n

.meas tran vdout0_103ck1380 FIND v(dout0_103) AT=695.025n

.meas tran vdout0_104ck1380 FIND v(dout0_104) AT=695.025n

.meas tran vdout0_105ck1380 FIND v(dout0_105) AT=695.025n

.meas tran vdout0_106ck1380 FIND v(dout0_106) AT=695.025n

.meas tran vdout0_107ck1380 FIND v(dout0_107) AT=695.025n

.meas tran vdout0_108ck1380 FIND v(dout0_108) AT=695.025n

.meas tran vdout0_109ck1380 FIND v(dout0_109) AT=695.025n

.meas tran vdout0_110ck1380 FIND v(dout0_110) AT=695.025n

.meas tran vdout0_111ck1380 FIND v(dout0_111) AT=695.025n

.meas tran vdout0_112ck1380 FIND v(dout0_112) AT=695.025n

.meas tran vdout0_113ck1380 FIND v(dout0_113) AT=695.025n

.meas tran vdout0_114ck1380 FIND v(dout0_114) AT=695.025n

.meas tran vdout0_115ck1380 FIND v(dout0_115) AT=695.025n

.meas tran vdout0_116ck1380 FIND v(dout0_116) AT=695.025n

.meas tran vdout0_117ck1380 FIND v(dout0_117) AT=695.025n

.meas tran vdout0_118ck1380 FIND v(dout0_118) AT=695.025n

.meas tran vdout0_119ck1380 FIND v(dout0_119) AT=695.025n

.meas tran vdout0_120ck1380 FIND v(dout0_120) AT=695.025n

.meas tran vdout0_121ck1380 FIND v(dout0_121) AT=695.025n

.meas tran vdout0_122ck1380 FIND v(dout0_122) AT=695.025n

.meas tran vdout0_123ck1380 FIND v(dout0_123) AT=695.025n

.meas tran vdout0_124ck1380 FIND v(dout0_124) AT=695.025n

.meas tran vdout0_125ck1380 FIND v(dout0_125) AT=695.025n

.meas tran vdout0_126ck1380 FIND v(dout0_126) AT=695.025n

.meas tran vdout0_127ck1380 FIND v(dout0_127) AT=695.025n

.meas tran vdout0_128ck1380 FIND v(dout0_128) AT=695.025n

.meas tran vdout0_129ck1380 FIND v(dout0_129) AT=695.025n

.meas tran vdout0_130ck1380 FIND v(dout0_130) AT=695.025n

.meas tran vdout0_131ck1380 FIND v(dout0_131) AT=695.025n

.meas tran vdout0_132ck1380 FIND v(dout0_132) AT=695.025n

.meas tran vdout0_133ck1380 FIND v(dout0_133) AT=695.025n

.meas tran vdout0_134ck1380 FIND v(dout0_134) AT=695.025n

.meas tran vdout0_135ck1380 FIND v(dout0_135) AT=695.025n

.meas tran vdout0_136ck1380 FIND v(dout0_136) AT=695.025n

.meas tran vdout0_137ck1380 FIND v(dout0_137) AT=695.025n

.meas tran vdout0_138ck1380 FIND v(dout0_138) AT=695.025n

.meas tran vdout0_139ck1380 FIND v(dout0_139) AT=695.025n

.meas tran vdout0_140ck1380 FIND v(dout0_140) AT=695.025n

.meas tran vdout0_141ck1380 FIND v(dout0_141) AT=695.025n

.meas tran vdout0_142ck1380 FIND v(dout0_142) AT=695.025n

.meas tran vdout0_143ck1380 FIND v(dout0_143) AT=695.025n

.meas tran vdout0_144ck1380 FIND v(dout0_144) AT=695.025n

.meas tran vdout0_145ck1380 FIND v(dout0_145) AT=695.025n

.meas tran vdout0_146ck1380 FIND v(dout0_146) AT=695.025n

.meas tran vdout0_147ck1380 FIND v(dout0_147) AT=695.025n

.meas tran vdout0_148ck1380 FIND v(dout0_148) AT=695.025n

.meas tran vdout0_149ck1380 FIND v(dout0_149) AT=695.025n

.meas tran vdout0_0ck1390 FIND v(dout0_0) AT=700.025n

.meas tran vdout0_1ck1390 FIND v(dout0_1) AT=700.025n

.meas tran vdout0_2ck1390 FIND v(dout0_2) AT=700.025n

.meas tran vdout0_3ck1390 FIND v(dout0_3) AT=700.025n

.meas tran vdout0_4ck1390 FIND v(dout0_4) AT=700.025n

.meas tran vdout0_5ck1390 FIND v(dout0_5) AT=700.025n

.meas tran vdout0_6ck1390 FIND v(dout0_6) AT=700.025n

.meas tran vdout0_7ck1390 FIND v(dout0_7) AT=700.025n

.meas tran vdout0_8ck1390 FIND v(dout0_8) AT=700.025n

.meas tran vdout0_9ck1390 FIND v(dout0_9) AT=700.025n

.meas tran vdout0_10ck1390 FIND v(dout0_10) AT=700.025n

.meas tran vdout0_11ck1390 FIND v(dout0_11) AT=700.025n

.meas tran vdout0_12ck1390 FIND v(dout0_12) AT=700.025n

.meas tran vdout0_13ck1390 FIND v(dout0_13) AT=700.025n

.meas tran vdout0_14ck1390 FIND v(dout0_14) AT=700.025n

.meas tran vdout0_15ck1390 FIND v(dout0_15) AT=700.025n

.meas tran vdout0_16ck1390 FIND v(dout0_16) AT=700.025n

.meas tran vdout0_17ck1390 FIND v(dout0_17) AT=700.025n

.meas tran vdout0_18ck1390 FIND v(dout0_18) AT=700.025n

.meas tran vdout0_19ck1390 FIND v(dout0_19) AT=700.025n

.meas tran vdout0_20ck1390 FIND v(dout0_20) AT=700.025n

.meas tran vdout0_21ck1390 FIND v(dout0_21) AT=700.025n

.meas tran vdout0_22ck1390 FIND v(dout0_22) AT=700.025n

.meas tran vdout0_23ck1390 FIND v(dout0_23) AT=700.025n

.meas tran vdout0_24ck1390 FIND v(dout0_24) AT=700.025n

.meas tran vdout0_25ck1390 FIND v(dout0_25) AT=700.025n

.meas tran vdout0_26ck1390 FIND v(dout0_26) AT=700.025n

.meas tran vdout0_27ck1390 FIND v(dout0_27) AT=700.025n

.meas tran vdout0_28ck1390 FIND v(dout0_28) AT=700.025n

.meas tran vdout0_29ck1390 FIND v(dout0_29) AT=700.025n

.meas tran vdout0_30ck1390 FIND v(dout0_30) AT=700.025n

.meas tran vdout0_31ck1390 FIND v(dout0_31) AT=700.025n

.meas tran vdout0_32ck1390 FIND v(dout0_32) AT=700.025n

.meas tran vdout0_33ck1390 FIND v(dout0_33) AT=700.025n

.meas tran vdout0_34ck1390 FIND v(dout0_34) AT=700.025n

.meas tran vdout0_35ck1390 FIND v(dout0_35) AT=700.025n

.meas tran vdout0_36ck1390 FIND v(dout0_36) AT=700.025n

.meas tran vdout0_37ck1390 FIND v(dout0_37) AT=700.025n

.meas tran vdout0_38ck1390 FIND v(dout0_38) AT=700.025n

.meas tran vdout0_39ck1390 FIND v(dout0_39) AT=700.025n

.meas tran vdout0_40ck1390 FIND v(dout0_40) AT=700.025n

.meas tran vdout0_41ck1390 FIND v(dout0_41) AT=700.025n

.meas tran vdout0_42ck1390 FIND v(dout0_42) AT=700.025n

.meas tran vdout0_43ck1390 FIND v(dout0_43) AT=700.025n

.meas tran vdout0_44ck1390 FIND v(dout0_44) AT=700.025n

.meas tran vdout0_45ck1390 FIND v(dout0_45) AT=700.025n

.meas tran vdout0_46ck1390 FIND v(dout0_46) AT=700.025n

.meas tran vdout0_47ck1390 FIND v(dout0_47) AT=700.025n

.meas tran vdout0_48ck1390 FIND v(dout0_48) AT=700.025n

.meas tran vdout0_49ck1390 FIND v(dout0_49) AT=700.025n

.meas tran vdout0_50ck1390 FIND v(dout0_50) AT=700.025n

.meas tran vdout0_51ck1390 FIND v(dout0_51) AT=700.025n

.meas tran vdout0_52ck1390 FIND v(dout0_52) AT=700.025n

.meas tran vdout0_53ck1390 FIND v(dout0_53) AT=700.025n

.meas tran vdout0_54ck1390 FIND v(dout0_54) AT=700.025n

.meas tran vdout0_55ck1390 FIND v(dout0_55) AT=700.025n

.meas tran vdout0_56ck1390 FIND v(dout0_56) AT=700.025n

.meas tran vdout0_57ck1390 FIND v(dout0_57) AT=700.025n

.meas tran vdout0_58ck1390 FIND v(dout0_58) AT=700.025n

.meas tran vdout0_59ck1390 FIND v(dout0_59) AT=700.025n

.meas tran vdout0_60ck1390 FIND v(dout0_60) AT=700.025n

.meas tran vdout0_61ck1390 FIND v(dout0_61) AT=700.025n

.meas tran vdout0_62ck1390 FIND v(dout0_62) AT=700.025n

.meas tran vdout0_63ck1390 FIND v(dout0_63) AT=700.025n

.meas tran vdout0_64ck1390 FIND v(dout0_64) AT=700.025n

.meas tran vdout0_65ck1390 FIND v(dout0_65) AT=700.025n

.meas tran vdout0_66ck1390 FIND v(dout0_66) AT=700.025n

.meas tran vdout0_67ck1390 FIND v(dout0_67) AT=700.025n

.meas tran vdout0_68ck1390 FIND v(dout0_68) AT=700.025n

.meas tran vdout0_69ck1390 FIND v(dout0_69) AT=700.025n

.meas tran vdout0_70ck1390 FIND v(dout0_70) AT=700.025n

.meas tran vdout0_71ck1390 FIND v(dout0_71) AT=700.025n

.meas tran vdout0_72ck1390 FIND v(dout0_72) AT=700.025n

.meas tran vdout0_73ck1390 FIND v(dout0_73) AT=700.025n

.meas tran vdout0_74ck1390 FIND v(dout0_74) AT=700.025n

.meas tran vdout0_75ck1390 FIND v(dout0_75) AT=700.025n

.meas tran vdout0_76ck1390 FIND v(dout0_76) AT=700.025n

.meas tran vdout0_77ck1390 FIND v(dout0_77) AT=700.025n

.meas tran vdout0_78ck1390 FIND v(dout0_78) AT=700.025n

.meas tran vdout0_79ck1390 FIND v(dout0_79) AT=700.025n

.meas tran vdout0_80ck1390 FIND v(dout0_80) AT=700.025n

.meas tran vdout0_81ck1390 FIND v(dout0_81) AT=700.025n

.meas tran vdout0_82ck1390 FIND v(dout0_82) AT=700.025n

.meas tran vdout0_83ck1390 FIND v(dout0_83) AT=700.025n

.meas tran vdout0_84ck1390 FIND v(dout0_84) AT=700.025n

.meas tran vdout0_85ck1390 FIND v(dout0_85) AT=700.025n

.meas tran vdout0_86ck1390 FIND v(dout0_86) AT=700.025n

.meas tran vdout0_87ck1390 FIND v(dout0_87) AT=700.025n

.meas tran vdout0_88ck1390 FIND v(dout0_88) AT=700.025n

.meas tran vdout0_89ck1390 FIND v(dout0_89) AT=700.025n

.meas tran vdout0_90ck1390 FIND v(dout0_90) AT=700.025n

.meas tran vdout0_91ck1390 FIND v(dout0_91) AT=700.025n

.meas tran vdout0_92ck1390 FIND v(dout0_92) AT=700.025n

.meas tran vdout0_93ck1390 FIND v(dout0_93) AT=700.025n

.meas tran vdout0_94ck1390 FIND v(dout0_94) AT=700.025n

.meas tran vdout0_95ck1390 FIND v(dout0_95) AT=700.025n

.meas tran vdout0_96ck1390 FIND v(dout0_96) AT=700.025n

.meas tran vdout0_97ck1390 FIND v(dout0_97) AT=700.025n

.meas tran vdout0_98ck1390 FIND v(dout0_98) AT=700.025n

.meas tran vdout0_99ck1390 FIND v(dout0_99) AT=700.025n

.meas tran vdout0_100ck1390 FIND v(dout0_100) AT=700.025n

.meas tran vdout0_101ck1390 FIND v(dout0_101) AT=700.025n

.meas tran vdout0_102ck1390 FIND v(dout0_102) AT=700.025n

.meas tran vdout0_103ck1390 FIND v(dout0_103) AT=700.025n

.meas tran vdout0_104ck1390 FIND v(dout0_104) AT=700.025n

.meas tran vdout0_105ck1390 FIND v(dout0_105) AT=700.025n

.meas tran vdout0_106ck1390 FIND v(dout0_106) AT=700.025n

.meas tran vdout0_107ck1390 FIND v(dout0_107) AT=700.025n

.meas tran vdout0_108ck1390 FIND v(dout0_108) AT=700.025n

.meas tran vdout0_109ck1390 FIND v(dout0_109) AT=700.025n

.meas tran vdout0_110ck1390 FIND v(dout0_110) AT=700.025n

.meas tran vdout0_111ck1390 FIND v(dout0_111) AT=700.025n

.meas tran vdout0_112ck1390 FIND v(dout0_112) AT=700.025n

.meas tran vdout0_113ck1390 FIND v(dout0_113) AT=700.025n

.meas tran vdout0_114ck1390 FIND v(dout0_114) AT=700.025n

.meas tran vdout0_115ck1390 FIND v(dout0_115) AT=700.025n

.meas tran vdout0_116ck1390 FIND v(dout0_116) AT=700.025n

.meas tran vdout0_117ck1390 FIND v(dout0_117) AT=700.025n

.meas tran vdout0_118ck1390 FIND v(dout0_118) AT=700.025n

.meas tran vdout0_119ck1390 FIND v(dout0_119) AT=700.025n

.meas tran vdout0_120ck1390 FIND v(dout0_120) AT=700.025n

.meas tran vdout0_121ck1390 FIND v(dout0_121) AT=700.025n

.meas tran vdout0_122ck1390 FIND v(dout0_122) AT=700.025n

.meas tran vdout0_123ck1390 FIND v(dout0_123) AT=700.025n

.meas tran vdout0_124ck1390 FIND v(dout0_124) AT=700.025n

.meas tran vdout0_125ck1390 FIND v(dout0_125) AT=700.025n

.meas tran vdout0_126ck1390 FIND v(dout0_126) AT=700.025n

.meas tran vdout0_127ck1390 FIND v(dout0_127) AT=700.025n

.meas tran vdout0_128ck1390 FIND v(dout0_128) AT=700.025n

.meas tran vdout0_129ck1390 FIND v(dout0_129) AT=700.025n

.meas tran vdout0_130ck1390 FIND v(dout0_130) AT=700.025n

.meas tran vdout0_131ck1390 FIND v(dout0_131) AT=700.025n

.meas tran vdout0_132ck1390 FIND v(dout0_132) AT=700.025n

.meas tran vdout0_133ck1390 FIND v(dout0_133) AT=700.025n

.meas tran vdout0_134ck1390 FIND v(dout0_134) AT=700.025n

.meas tran vdout0_135ck1390 FIND v(dout0_135) AT=700.025n

.meas tran vdout0_136ck1390 FIND v(dout0_136) AT=700.025n

.meas tran vdout0_137ck1390 FIND v(dout0_137) AT=700.025n

.meas tran vdout0_138ck1390 FIND v(dout0_138) AT=700.025n

.meas tran vdout0_139ck1390 FIND v(dout0_139) AT=700.025n

.meas tran vdout0_140ck1390 FIND v(dout0_140) AT=700.025n

.meas tran vdout0_141ck1390 FIND v(dout0_141) AT=700.025n

.meas tran vdout0_142ck1390 FIND v(dout0_142) AT=700.025n

.meas tran vdout0_143ck1390 FIND v(dout0_143) AT=700.025n

.meas tran vdout0_144ck1390 FIND v(dout0_144) AT=700.025n

.meas tran vdout0_145ck1390 FIND v(dout0_145) AT=700.025n

.meas tran vdout0_146ck1390 FIND v(dout0_146) AT=700.025n

.meas tran vdout0_147ck1390 FIND v(dout0_147) AT=700.025n

.meas tran vdout0_148ck1390 FIND v(dout0_148) AT=700.025n

.meas tran vdout0_149ck1390 FIND v(dout0_149) AT=700.025n

.meas tran vdout0_0ck1420 FIND v(dout0_0) AT=715.025n

.meas tran vdout0_1ck1420 FIND v(dout0_1) AT=715.025n

.meas tran vdout0_2ck1420 FIND v(dout0_2) AT=715.025n

.meas tran vdout0_3ck1420 FIND v(dout0_3) AT=715.025n

.meas tran vdout0_4ck1420 FIND v(dout0_4) AT=715.025n

.meas tran vdout0_5ck1420 FIND v(dout0_5) AT=715.025n

.meas tran vdout0_6ck1420 FIND v(dout0_6) AT=715.025n

.meas tran vdout0_7ck1420 FIND v(dout0_7) AT=715.025n

.meas tran vdout0_8ck1420 FIND v(dout0_8) AT=715.025n

.meas tran vdout0_9ck1420 FIND v(dout0_9) AT=715.025n

.meas tran vdout0_10ck1420 FIND v(dout0_10) AT=715.025n

.meas tran vdout0_11ck1420 FIND v(dout0_11) AT=715.025n

.meas tran vdout0_12ck1420 FIND v(dout0_12) AT=715.025n

.meas tran vdout0_13ck1420 FIND v(dout0_13) AT=715.025n

.meas tran vdout0_14ck1420 FIND v(dout0_14) AT=715.025n

.meas tran vdout0_15ck1420 FIND v(dout0_15) AT=715.025n

.meas tran vdout0_16ck1420 FIND v(dout0_16) AT=715.025n

.meas tran vdout0_17ck1420 FIND v(dout0_17) AT=715.025n

.meas tran vdout0_18ck1420 FIND v(dout0_18) AT=715.025n

.meas tran vdout0_19ck1420 FIND v(dout0_19) AT=715.025n

.meas tran vdout0_20ck1420 FIND v(dout0_20) AT=715.025n

.meas tran vdout0_21ck1420 FIND v(dout0_21) AT=715.025n

.meas tran vdout0_22ck1420 FIND v(dout0_22) AT=715.025n

.meas tran vdout0_23ck1420 FIND v(dout0_23) AT=715.025n

.meas tran vdout0_24ck1420 FIND v(dout0_24) AT=715.025n

.meas tran vdout0_25ck1420 FIND v(dout0_25) AT=715.025n

.meas tran vdout0_26ck1420 FIND v(dout0_26) AT=715.025n

.meas tran vdout0_27ck1420 FIND v(dout0_27) AT=715.025n

.meas tran vdout0_28ck1420 FIND v(dout0_28) AT=715.025n

.meas tran vdout0_29ck1420 FIND v(dout0_29) AT=715.025n

.meas tran vdout0_30ck1420 FIND v(dout0_30) AT=715.025n

.meas tran vdout0_31ck1420 FIND v(dout0_31) AT=715.025n

.meas tran vdout0_32ck1420 FIND v(dout0_32) AT=715.025n

.meas tran vdout0_33ck1420 FIND v(dout0_33) AT=715.025n

.meas tran vdout0_34ck1420 FIND v(dout0_34) AT=715.025n

.meas tran vdout0_35ck1420 FIND v(dout0_35) AT=715.025n

.meas tran vdout0_36ck1420 FIND v(dout0_36) AT=715.025n

.meas tran vdout0_37ck1420 FIND v(dout0_37) AT=715.025n

.meas tran vdout0_38ck1420 FIND v(dout0_38) AT=715.025n

.meas tran vdout0_39ck1420 FIND v(dout0_39) AT=715.025n

.meas tran vdout0_40ck1420 FIND v(dout0_40) AT=715.025n

.meas tran vdout0_41ck1420 FIND v(dout0_41) AT=715.025n

.meas tran vdout0_42ck1420 FIND v(dout0_42) AT=715.025n

.meas tran vdout0_43ck1420 FIND v(dout0_43) AT=715.025n

.meas tran vdout0_44ck1420 FIND v(dout0_44) AT=715.025n

.meas tran vdout0_45ck1420 FIND v(dout0_45) AT=715.025n

.meas tran vdout0_46ck1420 FIND v(dout0_46) AT=715.025n

.meas tran vdout0_47ck1420 FIND v(dout0_47) AT=715.025n

.meas tran vdout0_48ck1420 FIND v(dout0_48) AT=715.025n

.meas tran vdout0_49ck1420 FIND v(dout0_49) AT=715.025n

.meas tran vdout0_50ck1420 FIND v(dout0_50) AT=715.025n

.meas tran vdout0_51ck1420 FIND v(dout0_51) AT=715.025n

.meas tran vdout0_52ck1420 FIND v(dout0_52) AT=715.025n

.meas tran vdout0_53ck1420 FIND v(dout0_53) AT=715.025n

.meas tran vdout0_54ck1420 FIND v(dout0_54) AT=715.025n

.meas tran vdout0_55ck1420 FIND v(dout0_55) AT=715.025n

.meas tran vdout0_56ck1420 FIND v(dout0_56) AT=715.025n

.meas tran vdout0_57ck1420 FIND v(dout0_57) AT=715.025n

.meas tran vdout0_58ck1420 FIND v(dout0_58) AT=715.025n

.meas tran vdout0_59ck1420 FIND v(dout0_59) AT=715.025n

.meas tran vdout0_60ck1420 FIND v(dout0_60) AT=715.025n

.meas tran vdout0_61ck1420 FIND v(dout0_61) AT=715.025n

.meas tran vdout0_62ck1420 FIND v(dout0_62) AT=715.025n

.meas tran vdout0_63ck1420 FIND v(dout0_63) AT=715.025n

.meas tran vdout0_64ck1420 FIND v(dout0_64) AT=715.025n

.meas tran vdout0_65ck1420 FIND v(dout0_65) AT=715.025n

.meas tran vdout0_66ck1420 FIND v(dout0_66) AT=715.025n

.meas tran vdout0_67ck1420 FIND v(dout0_67) AT=715.025n

.meas tran vdout0_68ck1420 FIND v(dout0_68) AT=715.025n

.meas tran vdout0_69ck1420 FIND v(dout0_69) AT=715.025n

.meas tran vdout0_70ck1420 FIND v(dout0_70) AT=715.025n

.meas tran vdout0_71ck1420 FIND v(dout0_71) AT=715.025n

.meas tran vdout0_72ck1420 FIND v(dout0_72) AT=715.025n

.meas tran vdout0_73ck1420 FIND v(dout0_73) AT=715.025n

.meas tran vdout0_74ck1420 FIND v(dout0_74) AT=715.025n

.meas tran vdout0_75ck1420 FIND v(dout0_75) AT=715.025n

.meas tran vdout0_76ck1420 FIND v(dout0_76) AT=715.025n

.meas tran vdout0_77ck1420 FIND v(dout0_77) AT=715.025n

.meas tran vdout0_78ck1420 FIND v(dout0_78) AT=715.025n

.meas tran vdout0_79ck1420 FIND v(dout0_79) AT=715.025n

.meas tran vdout0_80ck1420 FIND v(dout0_80) AT=715.025n

.meas tran vdout0_81ck1420 FIND v(dout0_81) AT=715.025n

.meas tran vdout0_82ck1420 FIND v(dout0_82) AT=715.025n

.meas tran vdout0_83ck1420 FIND v(dout0_83) AT=715.025n

.meas tran vdout0_84ck1420 FIND v(dout0_84) AT=715.025n

.meas tran vdout0_85ck1420 FIND v(dout0_85) AT=715.025n

.meas tran vdout0_86ck1420 FIND v(dout0_86) AT=715.025n

.meas tran vdout0_87ck1420 FIND v(dout0_87) AT=715.025n

.meas tran vdout0_88ck1420 FIND v(dout0_88) AT=715.025n

.meas tran vdout0_89ck1420 FIND v(dout0_89) AT=715.025n

.meas tran vdout0_90ck1420 FIND v(dout0_90) AT=715.025n

.meas tran vdout0_91ck1420 FIND v(dout0_91) AT=715.025n

.meas tran vdout0_92ck1420 FIND v(dout0_92) AT=715.025n

.meas tran vdout0_93ck1420 FIND v(dout0_93) AT=715.025n

.meas tran vdout0_94ck1420 FIND v(dout0_94) AT=715.025n

.meas tran vdout0_95ck1420 FIND v(dout0_95) AT=715.025n

.meas tran vdout0_96ck1420 FIND v(dout0_96) AT=715.025n

.meas tran vdout0_97ck1420 FIND v(dout0_97) AT=715.025n

.meas tran vdout0_98ck1420 FIND v(dout0_98) AT=715.025n

.meas tran vdout0_99ck1420 FIND v(dout0_99) AT=715.025n

.meas tran vdout0_100ck1420 FIND v(dout0_100) AT=715.025n

.meas tran vdout0_101ck1420 FIND v(dout0_101) AT=715.025n

.meas tran vdout0_102ck1420 FIND v(dout0_102) AT=715.025n

.meas tran vdout0_103ck1420 FIND v(dout0_103) AT=715.025n

.meas tran vdout0_104ck1420 FIND v(dout0_104) AT=715.025n

.meas tran vdout0_105ck1420 FIND v(dout0_105) AT=715.025n

.meas tran vdout0_106ck1420 FIND v(dout0_106) AT=715.025n

.meas tran vdout0_107ck1420 FIND v(dout0_107) AT=715.025n

.meas tran vdout0_108ck1420 FIND v(dout0_108) AT=715.025n

.meas tran vdout0_109ck1420 FIND v(dout0_109) AT=715.025n

.meas tran vdout0_110ck1420 FIND v(dout0_110) AT=715.025n

.meas tran vdout0_111ck1420 FIND v(dout0_111) AT=715.025n

.meas tran vdout0_112ck1420 FIND v(dout0_112) AT=715.025n

.meas tran vdout0_113ck1420 FIND v(dout0_113) AT=715.025n

.meas tran vdout0_114ck1420 FIND v(dout0_114) AT=715.025n

.meas tran vdout0_115ck1420 FIND v(dout0_115) AT=715.025n

.meas tran vdout0_116ck1420 FIND v(dout0_116) AT=715.025n

.meas tran vdout0_117ck1420 FIND v(dout0_117) AT=715.025n

.meas tran vdout0_118ck1420 FIND v(dout0_118) AT=715.025n

.meas tran vdout0_119ck1420 FIND v(dout0_119) AT=715.025n

.meas tran vdout0_120ck1420 FIND v(dout0_120) AT=715.025n

.meas tran vdout0_121ck1420 FIND v(dout0_121) AT=715.025n

.meas tran vdout0_122ck1420 FIND v(dout0_122) AT=715.025n

.meas tran vdout0_123ck1420 FIND v(dout0_123) AT=715.025n

.meas tran vdout0_124ck1420 FIND v(dout0_124) AT=715.025n

.meas tran vdout0_125ck1420 FIND v(dout0_125) AT=715.025n

.meas tran vdout0_126ck1420 FIND v(dout0_126) AT=715.025n

.meas tran vdout0_127ck1420 FIND v(dout0_127) AT=715.025n

.meas tran vdout0_128ck1420 FIND v(dout0_128) AT=715.025n

.meas tran vdout0_129ck1420 FIND v(dout0_129) AT=715.025n

.meas tran vdout0_130ck1420 FIND v(dout0_130) AT=715.025n

.meas tran vdout0_131ck1420 FIND v(dout0_131) AT=715.025n

.meas tran vdout0_132ck1420 FIND v(dout0_132) AT=715.025n

.meas tran vdout0_133ck1420 FIND v(dout0_133) AT=715.025n

.meas tran vdout0_134ck1420 FIND v(dout0_134) AT=715.025n

.meas tran vdout0_135ck1420 FIND v(dout0_135) AT=715.025n

.meas tran vdout0_136ck1420 FIND v(dout0_136) AT=715.025n

.meas tran vdout0_137ck1420 FIND v(dout0_137) AT=715.025n

.meas tran vdout0_138ck1420 FIND v(dout0_138) AT=715.025n

.meas tran vdout0_139ck1420 FIND v(dout0_139) AT=715.025n

.meas tran vdout0_140ck1420 FIND v(dout0_140) AT=715.025n

.meas tran vdout0_141ck1420 FIND v(dout0_141) AT=715.025n

.meas tran vdout0_142ck1420 FIND v(dout0_142) AT=715.025n

.meas tran vdout0_143ck1420 FIND v(dout0_143) AT=715.025n

.meas tran vdout0_144ck1420 FIND v(dout0_144) AT=715.025n

.meas tran vdout0_145ck1420 FIND v(dout0_145) AT=715.025n

.meas tran vdout0_146ck1420 FIND v(dout0_146) AT=715.025n

.meas tran vdout0_147ck1420 FIND v(dout0_147) AT=715.025n

.meas tran vdout0_148ck1420 FIND v(dout0_148) AT=715.025n

.meas tran vdout0_149ck1420 FIND v(dout0_149) AT=715.025n

.meas tran vdout0_0ck1490 FIND v(dout0_0) AT=750.025n

.meas tran vdout0_1ck1490 FIND v(dout0_1) AT=750.025n

.meas tran vdout0_2ck1490 FIND v(dout0_2) AT=750.025n

.meas tran vdout0_3ck1490 FIND v(dout0_3) AT=750.025n

.meas tran vdout0_4ck1490 FIND v(dout0_4) AT=750.025n

.meas tran vdout0_5ck1490 FIND v(dout0_5) AT=750.025n

.meas tran vdout0_6ck1490 FIND v(dout0_6) AT=750.025n

.meas tran vdout0_7ck1490 FIND v(dout0_7) AT=750.025n

.meas tran vdout0_8ck1490 FIND v(dout0_8) AT=750.025n

.meas tran vdout0_9ck1490 FIND v(dout0_9) AT=750.025n

.meas tran vdout0_10ck1490 FIND v(dout0_10) AT=750.025n

.meas tran vdout0_11ck1490 FIND v(dout0_11) AT=750.025n

.meas tran vdout0_12ck1490 FIND v(dout0_12) AT=750.025n

.meas tran vdout0_13ck1490 FIND v(dout0_13) AT=750.025n

.meas tran vdout0_14ck1490 FIND v(dout0_14) AT=750.025n

.meas tran vdout0_15ck1490 FIND v(dout0_15) AT=750.025n

.meas tran vdout0_16ck1490 FIND v(dout0_16) AT=750.025n

.meas tran vdout0_17ck1490 FIND v(dout0_17) AT=750.025n

.meas tran vdout0_18ck1490 FIND v(dout0_18) AT=750.025n

.meas tran vdout0_19ck1490 FIND v(dout0_19) AT=750.025n

.meas tran vdout0_20ck1490 FIND v(dout0_20) AT=750.025n

.meas tran vdout0_21ck1490 FIND v(dout0_21) AT=750.025n

.meas tran vdout0_22ck1490 FIND v(dout0_22) AT=750.025n

.meas tran vdout0_23ck1490 FIND v(dout0_23) AT=750.025n

.meas tran vdout0_24ck1490 FIND v(dout0_24) AT=750.025n

.meas tran vdout0_25ck1490 FIND v(dout0_25) AT=750.025n

.meas tran vdout0_26ck1490 FIND v(dout0_26) AT=750.025n

.meas tran vdout0_27ck1490 FIND v(dout0_27) AT=750.025n

.meas tran vdout0_28ck1490 FIND v(dout0_28) AT=750.025n

.meas tran vdout0_29ck1490 FIND v(dout0_29) AT=750.025n

.meas tran vdout0_30ck1490 FIND v(dout0_30) AT=750.025n

.meas tran vdout0_31ck1490 FIND v(dout0_31) AT=750.025n

.meas tran vdout0_32ck1490 FIND v(dout0_32) AT=750.025n

.meas tran vdout0_33ck1490 FIND v(dout0_33) AT=750.025n

.meas tran vdout0_34ck1490 FIND v(dout0_34) AT=750.025n

.meas tran vdout0_35ck1490 FIND v(dout0_35) AT=750.025n

.meas tran vdout0_36ck1490 FIND v(dout0_36) AT=750.025n

.meas tran vdout0_37ck1490 FIND v(dout0_37) AT=750.025n

.meas tran vdout0_38ck1490 FIND v(dout0_38) AT=750.025n

.meas tran vdout0_39ck1490 FIND v(dout0_39) AT=750.025n

.meas tran vdout0_40ck1490 FIND v(dout0_40) AT=750.025n

.meas tran vdout0_41ck1490 FIND v(dout0_41) AT=750.025n

.meas tran vdout0_42ck1490 FIND v(dout0_42) AT=750.025n

.meas tran vdout0_43ck1490 FIND v(dout0_43) AT=750.025n

.meas tran vdout0_44ck1490 FIND v(dout0_44) AT=750.025n

.meas tran vdout0_45ck1490 FIND v(dout0_45) AT=750.025n

.meas tran vdout0_46ck1490 FIND v(dout0_46) AT=750.025n

.meas tran vdout0_47ck1490 FIND v(dout0_47) AT=750.025n

.meas tran vdout0_48ck1490 FIND v(dout0_48) AT=750.025n

.meas tran vdout0_49ck1490 FIND v(dout0_49) AT=750.025n

.meas tran vdout0_50ck1490 FIND v(dout0_50) AT=750.025n

.meas tran vdout0_51ck1490 FIND v(dout0_51) AT=750.025n

.meas tran vdout0_52ck1490 FIND v(dout0_52) AT=750.025n

.meas tran vdout0_53ck1490 FIND v(dout0_53) AT=750.025n

.meas tran vdout0_54ck1490 FIND v(dout0_54) AT=750.025n

.meas tran vdout0_55ck1490 FIND v(dout0_55) AT=750.025n

.meas tran vdout0_56ck1490 FIND v(dout0_56) AT=750.025n

.meas tran vdout0_57ck1490 FIND v(dout0_57) AT=750.025n

.meas tran vdout0_58ck1490 FIND v(dout0_58) AT=750.025n

.meas tran vdout0_59ck1490 FIND v(dout0_59) AT=750.025n

.meas tran vdout0_60ck1490 FIND v(dout0_60) AT=750.025n

.meas tran vdout0_61ck1490 FIND v(dout0_61) AT=750.025n

.meas tran vdout0_62ck1490 FIND v(dout0_62) AT=750.025n

.meas tran vdout0_63ck1490 FIND v(dout0_63) AT=750.025n

.meas tran vdout0_64ck1490 FIND v(dout0_64) AT=750.025n

.meas tran vdout0_65ck1490 FIND v(dout0_65) AT=750.025n

.meas tran vdout0_66ck1490 FIND v(dout0_66) AT=750.025n

.meas tran vdout0_67ck1490 FIND v(dout0_67) AT=750.025n

.meas tran vdout0_68ck1490 FIND v(dout0_68) AT=750.025n

.meas tran vdout0_69ck1490 FIND v(dout0_69) AT=750.025n

.meas tran vdout0_70ck1490 FIND v(dout0_70) AT=750.025n

.meas tran vdout0_71ck1490 FIND v(dout0_71) AT=750.025n

.meas tran vdout0_72ck1490 FIND v(dout0_72) AT=750.025n

.meas tran vdout0_73ck1490 FIND v(dout0_73) AT=750.025n

.meas tran vdout0_74ck1490 FIND v(dout0_74) AT=750.025n

.meas tran vdout0_75ck1490 FIND v(dout0_75) AT=750.025n

.meas tran vdout0_76ck1490 FIND v(dout0_76) AT=750.025n

.meas tran vdout0_77ck1490 FIND v(dout0_77) AT=750.025n

.meas tran vdout0_78ck1490 FIND v(dout0_78) AT=750.025n

.meas tran vdout0_79ck1490 FIND v(dout0_79) AT=750.025n

.meas tran vdout0_80ck1490 FIND v(dout0_80) AT=750.025n

.meas tran vdout0_81ck1490 FIND v(dout0_81) AT=750.025n

.meas tran vdout0_82ck1490 FIND v(dout0_82) AT=750.025n

.meas tran vdout0_83ck1490 FIND v(dout0_83) AT=750.025n

.meas tran vdout0_84ck1490 FIND v(dout0_84) AT=750.025n

.meas tran vdout0_85ck1490 FIND v(dout0_85) AT=750.025n

.meas tran vdout0_86ck1490 FIND v(dout0_86) AT=750.025n

.meas tran vdout0_87ck1490 FIND v(dout0_87) AT=750.025n

.meas tran vdout0_88ck1490 FIND v(dout0_88) AT=750.025n

.meas tran vdout0_89ck1490 FIND v(dout0_89) AT=750.025n

.meas tran vdout0_90ck1490 FIND v(dout0_90) AT=750.025n

.meas tran vdout0_91ck1490 FIND v(dout0_91) AT=750.025n

.meas tran vdout0_92ck1490 FIND v(dout0_92) AT=750.025n

.meas tran vdout0_93ck1490 FIND v(dout0_93) AT=750.025n

.meas tran vdout0_94ck1490 FIND v(dout0_94) AT=750.025n

.meas tran vdout0_95ck1490 FIND v(dout0_95) AT=750.025n

.meas tran vdout0_96ck1490 FIND v(dout0_96) AT=750.025n

.meas tran vdout0_97ck1490 FIND v(dout0_97) AT=750.025n

.meas tran vdout0_98ck1490 FIND v(dout0_98) AT=750.025n

.meas tran vdout0_99ck1490 FIND v(dout0_99) AT=750.025n

.meas tran vdout0_100ck1490 FIND v(dout0_100) AT=750.025n

.meas tran vdout0_101ck1490 FIND v(dout0_101) AT=750.025n

.meas tran vdout0_102ck1490 FIND v(dout0_102) AT=750.025n

.meas tran vdout0_103ck1490 FIND v(dout0_103) AT=750.025n

.meas tran vdout0_104ck1490 FIND v(dout0_104) AT=750.025n

.meas tran vdout0_105ck1490 FIND v(dout0_105) AT=750.025n

.meas tran vdout0_106ck1490 FIND v(dout0_106) AT=750.025n

.meas tran vdout0_107ck1490 FIND v(dout0_107) AT=750.025n

.meas tran vdout0_108ck1490 FIND v(dout0_108) AT=750.025n

.meas tran vdout0_109ck1490 FIND v(dout0_109) AT=750.025n

.meas tran vdout0_110ck1490 FIND v(dout0_110) AT=750.025n

.meas tran vdout0_111ck1490 FIND v(dout0_111) AT=750.025n

.meas tran vdout0_112ck1490 FIND v(dout0_112) AT=750.025n

.meas tran vdout0_113ck1490 FIND v(dout0_113) AT=750.025n

.meas tran vdout0_114ck1490 FIND v(dout0_114) AT=750.025n

.meas tran vdout0_115ck1490 FIND v(dout0_115) AT=750.025n

.meas tran vdout0_116ck1490 FIND v(dout0_116) AT=750.025n

.meas tran vdout0_117ck1490 FIND v(dout0_117) AT=750.025n

.meas tran vdout0_118ck1490 FIND v(dout0_118) AT=750.025n

.meas tran vdout0_119ck1490 FIND v(dout0_119) AT=750.025n

.meas tran vdout0_120ck1490 FIND v(dout0_120) AT=750.025n

.meas tran vdout0_121ck1490 FIND v(dout0_121) AT=750.025n

.meas tran vdout0_122ck1490 FIND v(dout0_122) AT=750.025n

.meas tran vdout0_123ck1490 FIND v(dout0_123) AT=750.025n

.meas tran vdout0_124ck1490 FIND v(dout0_124) AT=750.025n

.meas tran vdout0_125ck1490 FIND v(dout0_125) AT=750.025n

.meas tran vdout0_126ck1490 FIND v(dout0_126) AT=750.025n

.meas tran vdout0_127ck1490 FIND v(dout0_127) AT=750.025n

.meas tran vdout0_128ck1490 FIND v(dout0_128) AT=750.025n

.meas tran vdout0_129ck1490 FIND v(dout0_129) AT=750.025n

.meas tran vdout0_130ck1490 FIND v(dout0_130) AT=750.025n

.meas tran vdout0_131ck1490 FIND v(dout0_131) AT=750.025n

.meas tran vdout0_132ck1490 FIND v(dout0_132) AT=750.025n

.meas tran vdout0_133ck1490 FIND v(dout0_133) AT=750.025n

.meas tran vdout0_134ck1490 FIND v(dout0_134) AT=750.025n

.meas tran vdout0_135ck1490 FIND v(dout0_135) AT=750.025n

.meas tran vdout0_136ck1490 FIND v(dout0_136) AT=750.025n

.meas tran vdout0_137ck1490 FIND v(dout0_137) AT=750.025n

.meas tran vdout0_138ck1490 FIND v(dout0_138) AT=750.025n

.meas tran vdout0_139ck1490 FIND v(dout0_139) AT=750.025n

.meas tran vdout0_140ck1490 FIND v(dout0_140) AT=750.025n

.meas tran vdout0_141ck1490 FIND v(dout0_141) AT=750.025n

.meas tran vdout0_142ck1490 FIND v(dout0_142) AT=750.025n

.meas tran vdout0_143ck1490 FIND v(dout0_143) AT=750.025n

.meas tran vdout0_144ck1490 FIND v(dout0_144) AT=750.025n

.meas tran vdout0_145ck1490 FIND v(dout0_145) AT=750.025n

.meas tran vdout0_146ck1490 FIND v(dout0_146) AT=750.025n

.meas tran vdout0_147ck1490 FIND v(dout0_147) AT=750.025n

.meas tran vdout0_148ck1490 FIND v(dout0_148) AT=750.025n

.meas tran vdout0_149ck1490 FIND v(dout0_149) AT=750.025n

.meas tran vdout0_0ck1540 FIND v(dout0_0) AT=775.025n

.meas tran vdout0_1ck1540 FIND v(dout0_1) AT=775.025n

.meas tran vdout0_2ck1540 FIND v(dout0_2) AT=775.025n

.meas tran vdout0_3ck1540 FIND v(dout0_3) AT=775.025n

.meas tran vdout0_4ck1540 FIND v(dout0_4) AT=775.025n

.meas tran vdout0_5ck1540 FIND v(dout0_5) AT=775.025n

.meas tran vdout0_6ck1540 FIND v(dout0_6) AT=775.025n

.meas tran vdout0_7ck1540 FIND v(dout0_7) AT=775.025n

.meas tran vdout0_8ck1540 FIND v(dout0_8) AT=775.025n

.meas tran vdout0_9ck1540 FIND v(dout0_9) AT=775.025n

.meas tran vdout0_10ck1540 FIND v(dout0_10) AT=775.025n

.meas tran vdout0_11ck1540 FIND v(dout0_11) AT=775.025n

.meas tran vdout0_12ck1540 FIND v(dout0_12) AT=775.025n

.meas tran vdout0_13ck1540 FIND v(dout0_13) AT=775.025n

.meas tran vdout0_14ck1540 FIND v(dout0_14) AT=775.025n

.meas tran vdout0_15ck1540 FIND v(dout0_15) AT=775.025n

.meas tran vdout0_16ck1540 FIND v(dout0_16) AT=775.025n

.meas tran vdout0_17ck1540 FIND v(dout0_17) AT=775.025n

.meas tran vdout0_18ck1540 FIND v(dout0_18) AT=775.025n

.meas tran vdout0_19ck1540 FIND v(dout0_19) AT=775.025n

.meas tran vdout0_20ck1540 FIND v(dout0_20) AT=775.025n

.meas tran vdout0_21ck1540 FIND v(dout0_21) AT=775.025n

.meas tran vdout0_22ck1540 FIND v(dout0_22) AT=775.025n

.meas tran vdout0_23ck1540 FIND v(dout0_23) AT=775.025n

.meas tran vdout0_24ck1540 FIND v(dout0_24) AT=775.025n

.meas tran vdout0_25ck1540 FIND v(dout0_25) AT=775.025n

.meas tran vdout0_26ck1540 FIND v(dout0_26) AT=775.025n

.meas tran vdout0_27ck1540 FIND v(dout0_27) AT=775.025n

.meas tran vdout0_28ck1540 FIND v(dout0_28) AT=775.025n

.meas tran vdout0_29ck1540 FIND v(dout0_29) AT=775.025n

.meas tran vdout0_30ck1540 FIND v(dout0_30) AT=775.025n

.meas tran vdout0_31ck1540 FIND v(dout0_31) AT=775.025n

.meas tran vdout0_32ck1540 FIND v(dout0_32) AT=775.025n

.meas tran vdout0_33ck1540 FIND v(dout0_33) AT=775.025n

.meas tran vdout0_34ck1540 FIND v(dout0_34) AT=775.025n

.meas tran vdout0_35ck1540 FIND v(dout0_35) AT=775.025n

.meas tran vdout0_36ck1540 FIND v(dout0_36) AT=775.025n

.meas tran vdout0_37ck1540 FIND v(dout0_37) AT=775.025n

.meas tran vdout0_38ck1540 FIND v(dout0_38) AT=775.025n

.meas tran vdout0_39ck1540 FIND v(dout0_39) AT=775.025n

.meas tran vdout0_40ck1540 FIND v(dout0_40) AT=775.025n

.meas tran vdout0_41ck1540 FIND v(dout0_41) AT=775.025n

.meas tran vdout0_42ck1540 FIND v(dout0_42) AT=775.025n

.meas tran vdout0_43ck1540 FIND v(dout0_43) AT=775.025n

.meas tran vdout0_44ck1540 FIND v(dout0_44) AT=775.025n

.meas tran vdout0_45ck1540 FIND v(dout0_45) AT=775.025n

.meas tran vdout0_46ck1540 FIND v(dout0_46) AT=775.025n

.meas tran vdout0_47ck1540 FIND v(dout0_47) AT=775.025n

.meas tran vdout0_48ck1540 FIND v(dout0_48) AT=775.025n

.meas tran vdout0_49ck1540 FIND v(dout0_49) AT=775.025n

.meas tran vdout0_50ck1540 FIND v(dout0_50) AT=775.025n

.meas tran vdout0_51ck1540 FIND v(dout0_51) AT=775.025n

.meas tran vdout0_52ck1540 FIND v(dout0_52) AT=775.025n

.meas tran vdout0_53ck1540 FIND v(dout0_53) AT=775.025n

.meas tran vdout0_54ck1540 FIND v(dout0_54) AT=775.025n

.meas tran vdout0_55ck1540 FIND v(dout0_55) AT=775.025n

.meas tran vdout0_56ck1540 FIND v(dout0_56) AT=775.025n

.meas tran vdout0_57ck1540 FIND v(dout0_57) AT=775.025n

.meas tran vdout0_58ck1540 FIND v(dout0_58) AT=775.025n

.meas tran vdout0_59ck1540 FIND v(dout0_59) AT=775.025n

.meas tran vdout0_60ck1540 FIND v(dout0_60) AT=775.025n

.meas tran vdout0_61ck1540 FIND v(dout0_61) AT=775.025n

.meas tran vdout0_62ck1540 FIND v(dout0_62) AT=775.025n

.meas tran vdout0_63ck1540 FIND v(dout0_63) AT=775.025n

.meas tran vdout0_64ck1540 FIND v(dout0_64) AT=775.025n

.meas tran vdout0_65ck1540 FIND v(dout0_65) AT=775.025n

.meas tran vdout0_66ck1540 FIND v(dout0_66) AT=775.025n

.meas tran vdout0_67ck1540 FIND v(dout0_67) AT=775.025n

.meas tran vdout0_68ck1540 FIND v(dout0_68) AT=775.025n

.meas tran vdout0_69ck1540 FIND v(dout0_69) AT=775.025n

.meas tran vdout0_70ck1540 FIND v(dout0_70) AT=775.025n

.meas tran vdout0_71ck1540 FIND v(dout0_71) AT=775.025n

.meas tran vdout0_72ck1540 FIND v(dout0_72) AT=775.025n

.meas tran vdout0_73ck1540 FIND v(dout0_73) AT=775.025n

.meas tran vdout0_74ck1540 FIND v(dout0_74) AT=775.025n

.meas tran vdout0_75ck1540 FIND v(dout0_75) AT=775.025n

.meas tran vdout0_76ck1540 FIND v(dout0_76) AT=775.025n

.meas tran vdout0_77ck1540 FIND v(dout0_77) AT=775.025n

.meas tran vdout0_78ck1540 FIND v(dout0_78) AT=775.025n

.meas tran vdout0_79ck1540 FIND v(dout0_79) AT=775.025n

.meas tran vdout0_80ck1540 FIND v(dout0_80) AT=775.025n

.meas tran vdout0_81ck1540 FIND v(dout0_81) AT=775.025n

.meas tran vdout0_82ck1540 FIND v(dout0_82) AT=775.025n

.meas tran vdout0_83ck1540 FIND v(dout0_83) AT=775.025n

.meas tran vdout0_84ck1540 FIND v(dout0_84) AT=775.025n

.meas tran vdout0_85ck1540 FIND v(dout0_85) AT=775.025n

.meas tran vdout0_86ck1540 FIND v(dout0_86) AT=775.025n

.meas tran vdout0_87ck1540 FIND v(dout0_87) AT=775.025n

.meas tran vdout0_88ck1540 FIND v(dout0_88) AT=775.025n

.meas tran vdout0_89ck1540 FIND v(dout0_89) AT=775.025n

.meas tran vdout0_90ck1540 FIND v(dout0_90) AT=775.025n

.meas tran vdout0_91ck1540 FIND v(dout0_91) AT=775.025n

.meas tran vdout0_92ck1540 FIND v(dout0_92) AT=775.025n

.meas tran vdout0_93ck1540 FIND v(dout0_93) AT=775.025n

.meas tran vdout0_94ck1540 FIND v(dout0_94) AT=775.025n

.meas tran vdout0_95ck1540 FIND v(dout0_95) AT=775.025n

.meas tran vdout0_96ck1540 FIND v(dout0_96) AT=775.025n

.meas tran vdout0_97ck1540 FIND v(dout0_97) AT=775.025n

.meas tran vdout0_98ck1540 FIND v(dout0_98) AT=775.025n

.meas tran vdout0_99ck1540 FIND v(dout0_99) AT=775.025n

.meas tran vdout0_100ck1540 FIND v(dout0_100) AT=775.025n

.meas tran vdout0_101ck1540 FIND v(dout0_101) AT=775.025n

.meas tran vdout0_102ck1540 FIND v(dout0_102) AT=775.025n

.meas tran vdout0_103ck1540 FIND v(dout0_103) AT=775.025n

.meas tran vdout0_104ck1540 FIND v(dout0_104) AT=775.025n

.meas tran vdout0_105ck1540 FIND v(dout0_105) AT=775.025n

.meas tran vdout0_106ck1540 FIND v(dout0_106) AT=775.025n

.meas tran vdout0_107ck1540 FIND v(dout0_107) AT=775.025n

.meas tran vdout0_108ck1540 FIND v(dout0_108) AT=775.025n

.meas tran vdout0_109ck1540 FIND v(dout0_109) AT=775.025n

.meas tran vdout0_110ck1540 FIND v(dout0_110) AT=775.025n

.meas tran vdout0_111ck1540 FIND v(dout0_111) AT=775.025n

.meas tran vdout0_112ck1540 FIND v(dout0_112) AT=775.025n

.meas tran vdout0_113ck1540 FIND v(dout0_113) AT=775.025n

.meas tran vdout0_114ck1540 FIND v(dout0_114) AT=775.025n

.meas tran vdout0_115ck1540 FIND v(dout0_115) AT=775.025n

.meas tran vdout0_116ck1540 FIND v(dout0_116) AT=775.025n

.meas tran vdout0_117ck1540 FIND v(dout0_117) AT=775.025n

.meas tran vdout0_118ck1540 FIND v(dout0_118) AT=775.025n

.meas tran vdout0_119ck1540 FIND v(dout0_119) AT=775.025n

.meas tran vdout0_120ck1540 FIND v(dout0_120) AT=775.025n

.meas tran vdout0_121ck1540 FIND v(dout0_121) AT=775.025n

.meas tran vdout0_122ck1540 FIND v(dout0_122) AT=775.025n

.meas tran vdout0_123ck1540 FIND v(dout0_123) AT=775.025n

.meas tran vdout0_124ck1540 FIND v(dout0_124) AT=775.025n

.meas tran vdout0_125ck1540 FIND v(dout0_125) AT=775.025n

.meas tran vdout0_126ck1540 FIND v(dout0_126) AT=775.025n

.meas tran vdout0_127ck1540 FIND v(dout0_127) AT=775.025n

.meas tran vdout0_128ck1540 FIND v(dout0_128) AT=775.025n

.meas tran vdout0_129ck1540 FIND v(dout0_129) AT=775.025n

.meas tran vdout0_130ck1540 FIND v(dout0_130) AT=775.025n

.meas tran vdout0_131ck1540 FIND v(dout0_131) AT=775.025n

.meas tran vdout0_132ck1540 FIND v(dout0_132) AT=775.025n

.meas tran vdout0_133ck1540 FIND v(dout0_133) AT=775.025n

.meas tran vdout0_134ck1540 FIND v(dout0_134) AT=775.025n

.meas tran vdout0_135ck1540 FIND v(dout0_135) AT=775.025n

.meas tran vdout0_136ck1540 FIND v(dout0_136) AT=775.025n

.meas tran vdout0_137ck1540 FIND v(dout0_137) AT=775.025n

.meas tran vdout0_138ck1540 FIND v(dout0_138) AT=775.025n

.meas tran vdout0_139ck1540 FIND v(dout0_139) AT=775.025n

.meas tran vdout0_140ck1540 FIND v(dout0_140) AT=775.025n

.meas tran vdout0_141ck1540 FIND v(dout0_141) AT=775.025n

.meas tran vdout0_142ck1540 FIND v(dout0_142) AT=775.025n

.meas tran vdout0_143ck1540 FIND v(dout0_143) AT=775.025n

.meas tran vdout0_144ck1540 FIND v(dout0_144) AT=775.025n

.meas tran vdout0_145ck1540 FIND v(dout0_145) AT=775.025n

.meas tran vdout0_146ck1540 FIND v(dout0_146) AT=775.025n

.meas tran vdout0_147ck1540 FIND v(dout0_147) AT=775.025n

.meas tran vdout0_148ck1540 FIND v(dout0_148) AT=775.025n

.meas tran vdout0_149ck1540 FIND v(dout0_149) AT=775.025n

.meas tran vdout0_0ck1570 FIND v(dout0_0) AT=790.025n

.meas tran vdout0_1ck1570 FIND v(dout0_1) AT=790.025n

.meas tran vdout0_2ck1570 FIND v(dout0_2) AT=790.025n

.meas tran vdout0_3ck1570 FIND v(dout0_3) AT=790.025n

.meas tran vdout0_4ck1570 FIND v(dout0_4) AT=790.025n

.meas tran vdout0_5ck1570 FIND v(dout0_5) AT=790.025n

.meas tran vdout0_6ck1570 FIND v(dout0_6) AT=790.025n

.meas tran vdout0_7ck1570 FIND v(dout0_7) AT=790.025n

.meas tran vdout0_8ck1570 FIND v(dout0_8) AT=790.025n

.meas tran vdout0_9ck1570 FIND v(dout0_9) AT=790.025n

.meas tran vdout0_10ck1570 FIND v(dout0_10) AT=790.025n

.meas tran vdout0_11ck1570 FIND v(dout0_11) AT=790.025n

.meas tran vdout0_12ck1570 FIND v(dout0_12) AT=790.025n

.meas tran vdout0_13ck1570 FIND v(dout0_13) AT=790.025n

.meas tran vdout0_14ck1570 FIND v(dout0_14) AT=790.025n

.meas tran vdout0_15ck1570 FIND v(dout0_15) AT=790.025n

.meas tran vdout0_16ck1570 FIND v(dout0_16) AT=790.025n

.meas tran vdout0_17ck1570 FIND v(dout0_17) AT=790.025n

.meas tran vdout0_18ck1570 FIND v(dout0_18) AT=790.025n

.meas tran vdout0_19ck1570 FIND v(dout0_19) AT=790.025n

.meas tran vdout0_20ck1570 FIND v(dout0_20) AT=790.025n

.meas tran vdout0_21ck1570 FIND v(dout0_21) AT=790.025n

.meas tran vdout0_22ck1570 FIND v(dout0_22) AT=790.025n

.meas tran vdout0_23ck1570 FIND v(dout0_23) AT=790.025n

.meas tran vdout0_24ck1570 FIND v(dout0_24) AT=790.025n

.meas tran vdout0_25ck1570 FIND v(dout0_25) AT=790.025n

.meas tran vdout0_26ck1570 FIND v(dout0_26) AT=790.025n

.meas tran vdout0_27ck1570 FIND v(dout0_27) AT=790.025n

.meas tran vdout0_28ck1570 FIND v(dout0_28) AT=790.025n

.meas tran vdout0_29ck1570 FIND v(dout0_29) AT=790.025n

.meas tran vdout0_30ck1570 FIND v(dout0_30) AT=790.025n

.meas tran vdout0_31ck1570 FIND v(dout0_31) AT=790.025n

.meas tran vdout0_32ck1570 FIND v(dout0_32) AT=790.025n

.meas tran vdout0_33ck1570 FIND v(dout0_33) AT=790.025n

.meas tran vdout0_34ck1570 FIND v(dout0_34) AT=790.025n

.meas tran vdout0_35ck1570 FIND v(dout0_35) AT=790.025n

.meas tran vdout0_36ck1570 FIND v(dout0_36) AT=790.025n

.meas tran vdout0_37ck1570 FIND v(dout0_37) AT=790.025n

.meas tran vdout0_38ck1570 FIND v(dout0_38) AT=790.025n

.meas tran vdout0_39ck1570 FIND v(dout0_39) AT=790.025n

.meas tran vdout0_40ck1570 FIND v(dout0_40) AT=790.025n

.meas tran vdout0_41ck1570 FIND v(dout0_41) AT=790.025n

.meas tran vdout0_42ck1570 FIND v(dout0_42) AT=790.025n

.meas tran vdout0_43ck1570 FIND v(dout0_43) AT=790.025n

.meas tran vdout0_44ck1570 FIND v(dout0_44) AT=790.025n

.meas tran vdout0_45ck1570 FIND v(dout0_45) AT=790.025n

.meas tran vdout0_46ck1570 FIND v(dout0_46) AT=790.025n

.meas tran vdout0_47ck1570 FIND v(dout0_47) AT=790.025n

.meas tran vdout0_48ck1570 FIND v(dout0_48) AT=790.025n

.meas tran vdout0_49ck1570 FIND v(dout0_49) AT=790.025n

.meas tran vdout0_50ck1570 FIND v(dout0_50) AT=790.025n

.meas tran vdout0_51ck1570 FIND v(dout0_51) AT=790.025n

.meas tran vdout0_52ck1570 FIND v(dout0_52) AT=790.025n

.meas tran vdout0_53ck1570 FIND v(dout0_53) AT=790.025n

.meas tran vdout0_54ck1570 FIND v(dout0_54) AT=790.025n

.meas tran vdout0_55ck1570 FIND v(dout0_55) AT=790.025n

.meas tran vdout0_56ck1570 FIND v(dout0_56) AT=790.025n

.meas tran vdout0_57ck1570 FIND v(dout0_57) AT=790.025n

.meas tran vdout0_58ck1570 FIND v(dout0_58) AT=790.025n

.meas tran vdout0_59ck1570 FIND v(dout0_59) AT=790.025n

.meas tran vdout0_60ck1570 FIND v(dout0_60) AT=790.025n

.meas tran vdout0_61ck1570 FIND v(dout0_61) AT=790.025n

.meas tran vdout0_62ck1570 FIND v(dout0_62) AT=790.025n

.meas tran vdout0_63ck1570 FIND v(dout0_63) AT=790.025n

.meas tran vdout0_64ck1570 FIND v(dout0_64) AT=790.025n

.meas tran vdout0_65ck1570 FIND v(dout0_65) AT=790.025n

.meas tran vdout0_66ck1570 FIND v(dout0_66) AT=790.025n

.meas tran vdout0_67ck1570 FIND v(dout0_67) AT=790.025n

.meas tran vdout0_68ck1570 FIND v(dout0_68) AT=790.025n

.meas tran vdout0_69ck1570 FIND v(dout0_69) AT=790.025n

.meas tran vdout0_70ck1570 FIND v(dout0_70) AT=790.025n

.meas tran vdout0_71ck1570 FIND v(dout0_71) AT=790.025n

.meas tran vdout0_72ck1570 FIND v(dout0_72) AT=790.025n

.meas tran vdout0_73ck1570 FIND v(dout0_73) AT=790.025n

.meas tran vdout0_74ck1570 FIND v(dout0_74) AT=790.025n

.meas tran vdout0_75ck1570 FIND v(dout0_75) AT=790.025n

.meas tran vdout0_76ck1570 FIND v(dout0_76) AT=790.025n

.meas tran vdout0_77ck1570 FIND v(dout0_77) AT=790.025n

.meas tran vdout0_78ck1570 FIND v(dout0_78) AT=790.025n

.meas tran vdout0_79ck1570 FIND v(dout0_79) AT=790.025n

.meas tran vdout0_80ck1570 FIND v(dout0_80) AT=790.025n

.meas tran vdout0_81ck1570 FIND v(dout0_81) AT=790.025n

.meas tran vdout0_82ck1570 FIND v(dout0_82) AT=790.025n

.meas tran vdout0_83ck1570 FIND v(dout0_83) AT=790.025n

.meas tran vdout0_84ck1570 FIND v(dout0_84) AT=790.025n

.meas tran vdout0_85ck1570 FIND v(dout0_85) AT=790.025n

.meas tran vdout0_86ck1570 FIND v(dout0_86) AT=790.025n

.meas tran vdout0_87ck1570 FIND v(dout0_87) AT=790.025n

.meas tran vdout0_88ck1570 FIND v(dout0_88) AT=790.025n

.meas tran vdout0_89ck1570 FIND v(dout0_89) AT=790.025n

.meas tran vdout0_90ck1570 FIND v(dout0_90) AT=790.025n

.meas tran vdout0_91ck1570 FIND v(dout0_91) AT=790.025n

.meas tran vdout0_92ck1570 FIND v(dout0_92) AT=790.025n

.meas tran vdout0_93ck1570 FIND v(dout0_93) AT=790.025n

.meas tran vdout0_94ck1570 FIND v(dout0_94) AT=790.025n

.meas tran vdout0_95ck1570 FIND v(dout0_95) AT=790.025n

.meas tran vdout0_96ck1570 FIND v(dout0_96) AT=790.025n

.meas tran vdout0_97ck1570 FIND v(dout0_97) AT=790.025n

.meas tran vdout0_98ck1570 FIND v(dout0_98) AT=790.025n

.meas tran vdout0_99ck1570 FIND v(dout0_99) AT=790.025n

.meas tran vdout0_100ck1570 FIND v(dout0_100) AT=790.025n

.meas tran vdout0_101ck1570 FIND v(dout0_101) AT=790.025n

.meas tran vdout0_102ck1570 FIND v(dout0_102) AT=790.025n

.meas tran vdout0_103ck1570 FIND v(dout0_103) AT=790.025n

.meas tran vdout0_104ck1570 FIND v(dout0_104) AT=790.025n

.meas tran vdout0_105ck1570 FIND v(dout0_105) AT=790.025n

.meas tran vdout0_106ck1570 FIND v(dout0_106) AT=790.025n

.meas tran vdout0_107ck1570 FIND v(dout0_107) AT=790.025n

.meas tran vdout0_108ck1570 FIND v(dout0_108) AT=790.025n

.meas tran vdout0_109ck1570 FIND v(dout0_109) AT=790.025n

.meas tran vdout0_110ck1570 FIND v(dout0_110) AT=790.025n

.meas tran vdout0_111ck1570 FIND v(dout0_111) AT=790.025n

.meas tran vdout0_112ck1570 FIND v(dout0_112) AT=790.025n

.meas tran vdout0_113ck1570 FIND v(dout0_113) AT=790.025n

.meas tran vdout0_114ck1570 FIND v(dout0_114) AT=790.025n

.meas tran vdout0_115ck1570 FIND v(dout0_115) AT=790.025n

.meas tran vdout0_116ck1570 FIND v(dout0_116) AT=790.025n

.meas tran vdout0_117ck1570 FIND v(dout0_117) AT=790.025n

.meas tran vdout0_118ck1570 FIND v(dout0_118) AT=790.025n

.meas tran vdout0_119ck1570 FIND v(dout0_119) AT=790.025n

.meas tran vdout0_120ck1570 FIND v(dout0_120) AT=790.025n

.meas tran vdout0_121ck1570 FIND v(dout0_121) AT=790.025n

.meas tran vdout0_122ck1570 FIND v(dout0_122) AT=790.025n

.meas tran vdout0_123ck1570 FIND v(dout0_123) AT=790.025n

.meas tran vdout0_124ck1570 FIND v(dout0_124) AT=790.025n

.meas tran vdout0_125ck1570 FIND v(dout0_125) AT=790.025n

.meas tran vdout0_126ck1570 FIND v(dout0_126) AT=790.025n

.meas tran vdout0_127ck1570 FIND v(dout0_127) AT=790.025n

.meas tran vdout0_128ck1570 FIND v(dout0_128) AT=790.025n

.meas tran vdout0_129ck1570 FIND v(dout0_129) AT=790.025n

.meas tran vdout0_130ck1570 FIND v(dout0_130) AT=790.025n

.meas tran vdout0_131ck1570 FIND v(dout0_131) AT=790.025n

.meas tran vdout0_132ck1570 FIND v(dout0_132) AT=790.025n

.meas tran vdout0_133ck1570 FIND v(dout0_133) AT=790.025n

.meas tran vdout0_134ck1570 FIND v(dout0_134) AT=790.025n

.meas tran vdout0_135ck1570 FIND v(dout0_135) AT=790.025n

.meas tran vdout0_136ck1570 FIND v(dout0_136) AT=790.025n

.meas tran vdout0_137ck1570 FIND v(dout0_137) AT=790.025n

.meas tran vdout0_138ck1570 FIND v(dout0_138) AT=790.025n

.meas tran vdout0_139ck1570 FIND v(dout0_139) AT=790.025n

.meas tran vdout0_140ck1570 FIND v(dout0_140) AT=790.025n

.meas tran vdout0_141ck1570 FIND v(dout0_141) AT=790.025n

.meas tran vdout0_142ck1570 FIND v(dout0_142) AT=790.025n

.meas tran vdout0_143ck1570 FIND v(dout0_143) AT=790.025n

.meas tran vdout0_144ck1570 FIND v(dout0_144) AT=790.025n

.meas tran vdout0_145ck1570 FIND v(dout0_145) AT=790.025n

.meas tran vdout0_146ck1570 FIND v(dout0_146) AT=790.025n

.meas tran vdout0_147ck1570 FIND v(dout0_147) AT=790.025n

.meas tran vdout0_148ck1570 FIND v(dout0_148) AT=790.025n

.meas tran vdout0_149ck1570 FIND v(dout0_149) AT=790.025n

.meas tran vdout0_0ck1580 FIND v(dout0_0) AT=795.025n

.meas tran vdout0_1ck1580 FIND v(dout0_1) AT=795.025n

.meas tran vdout0_2ck1580 FIND v(dout0_2) AT=795.025n

.meas tran vdout0_3ck1580 FIND v(dout0_3) AT=795.025n

.meas tran vdout0_4ck1580 FIND v(dout0_4) AT=795.025n

.meas tran vdout0_5ck1580 FIND v(dout0_5) AT=795.025n

.meas tran vdout0_6ck1580 FIND v(dout0_6) AT=795.025n

.meas tran vdout0_7ck1580 FIND v(dout0_7) AT=795.025n

.meas tran vdout0_8ck1580 FIND v(dout0_8) AT=795.025n

.meas tran vdout0_9ck1580 FIND v(dout0_9) AT=795.025n

.meas tran vdout0_10ck1580 FIND v(dout0_10) AT=795.025n

.meas tran vdout0_11ck1580 FIND v(dout0_11) AT=795.025n

.meas tran vdout0_12ck1580 FIND v(dout0_12) AT=795.025n

.meas tran vdout0_13ck1580 FIND v(dout0_13) AT=795.025n

.meas tran vdout0_14ck1580 FIND v(dout0_14) AT=795.025n

.meas tran vdout0_15ck1580 FIND v(dout0_15) AT=795.025n

.meas tran vdout0_16ck1580 FIND v(dout0_16) AT=795.025n

.meas tran vdout0_17ck1580 FIND v(dout0_17) AT=795.025n

.meas tran vdout0_18ck1580 FIND v(dout0_18) AT=795.025n

.meas tran vdout0_19ck1580 FIND v(dout0_19) AT=795.025n

.meas tran vdout0_20ck1580 FIND v(dout0_20) AT=795.025n

.meas tran vdout0_21ck1580 FIND v(dout0_21) AT=795.025n

.meas tran vdout0_22ck1580 FIND v(dout0_22) AT=795.025n

.meas tran vdout0_23ck1580 FIND v(dout0_23) AT=795.025n

.meas tran vdout0_24ck1580 FIND v(dout0_24) AT=795.025n

.meas tran vdout0_25ck1580 FIND v(dout0_25) AT=795.025n

.meas tran vdout0_26ck1580 FIND v(dout0_26) AT=795.025n

.meas tran vdout0_27ck1580 FIND v(dout0_27) AT=795.025n

.meas tran vdout0_28ck1580 FIND v(dout0_28) AT=795.025n

.meas tran vdout0_29ck1580 FIND v(dout0_29) AT=795.025n

.meas tran vdout0_30ck1580 FIND v(dout0_30) AT=795.025n

.meas tran vdout0_31ck1580 FIND v(dout0_31) AT=795.025n

.meas tran vdout0_32ck1580 FIND v(dout0_32) AT=795.025n

.meas tran vdout0_33ck1580 FIND v(dout0_33) AT=795.025n

.meas tran vdout0_34ck1580 FIND v(dout0_34) AT=795.025n

.meas tran vdout0_35ck1580 FIND v(dout0_35) AT=795.025n

.meas tran vdout0_36ck1580 FIND v(dout0_36) AT=795.025n

.meas tran vdout0_37ck1580 FIND v(dout0_37) AT=795.025n

.meas tran vdout0_38ck1580 FIND v(dout0_38) AT=795.025n

.meas tran vdout0_39ck1580 FIND v(dout0_39) AT=795.025n

.meas tran vdout0_40ck1580 FIND v(dout0_40) AT=795.025n

.meas tran vdout0_41ck1580 FIND v(dout0_41) AT=795.025n

.meas tran vdout0_42ck1580 FIND v(dout0_42) AT=795.025n

.meas tran vdout0_43ck1580 FIND v(dout0_43) AT=795.025n

.meas tran vdout0_44ck1580 FIND v(dout0_44) AT=795.025n

.meas tran vdout0_45ck1580 FIND v(dout0_45) AT=795.025n

.meas tran vdout0_46ck1580 FIND v(dout0_46) AT=795.025n

.meas tran vdout0_47ck1580 FIND v(dout0_47) AT=795.025n

.meas tran vdout0_48ck1580 FIND v(dout0_48) AT=795.025n

.meas tran vdout0_49ck1580 FIND v(dout0_49) AT=795.025n

.meas tran vdout0_50ck1580 FIND v(dout0_50) AT=795.025n

.meas tran vdout0_51ck1580 FIND v(dout0_51) AT=795.025n

.meas tran vdout0_52ck1580 FIND v(dout0_52) AT=795.025n

.meas tran vdout0_53ck1580 FIND v(dout0_53) AT=795.025n

.meas tran vdout0_54ck1580 FIND v(dout0_54) AT=795.025n

.meas tran vdout0_55ck1580 FIND v(dout0_55) AT=795.025n

.meas tran vdout0_56ck1580 FIND v(dout0_56) AT=795.025n

.meas tran vdout0_57ck1580 FIND v(dout0_57) AT=795.025n

.meas tran vdout0_58ck1580 FIND v(dout0_58) AT=795.025n

.meas tran vdout0_59ck1580 FIND v(dout0_59) AT=795.025n

.meas tran vdout0_60ck1580 FIND v(dout0_60) AT=795.025n

.meas tran vdout0_61ck1580 FIND v(dout0_61) AT=795.025n

.meas tran vdout0_62ck1580 FIND v(dout0_62) AT=795.025n

.meas tran vdout0_63ck1580 FIND v(dout0_63) AT=795.025n

.meas tran vdout0_64ck1580 FIND v(dout0_64) AT=795.025n

.meas tran vdout0_65ck1580 FIND v(dout0_65) AT=795.025n

.meas tran vdout0_66ck1580 FIND v(dout0_66) AT=795.025n

.meas tran vdout0_67ck1580 FIND v(dout0_67) AT=795.025n

.meas tran vdout0_68ck1580 FIND v(dout0_68) AT=795.025n

.meas tran vdout0_69ck1580 FIND v(dout0_69) AT=795.025n

.meas tran vdout0_70ck1580 FIND v(dout0_70) AT=795.025n

.meas tran vdout0_71ck1580 FIND v(dout0_71) AT=795.025n

.meas tran vdout0_72ck1580 FIND v(dout0_72) AT=795.025n

.meas tran vdout0_73ck1580 FIND v(dout0_73) AT=795.025n

.meas tran vdout0_74ck1580 FIND v(dout0_74) AT=795.025n

.meas tran vdout0_75ck1580 FIND v(dout0_75) AT=795.025n

.meas tran vdout0_76ck1580 FIND v(dout0_76) AT=795.025n

.meas tran vdout0_77ck1580 FIND v(dout0_77) AT=795.025n

.meas tran vdout0_78ck1580 FIND v(dout0_78) AT=795.025n

.meas tran vdout0_79ck1580 FIND v(dout0_79) AT=795.025n

.meas tran vdout0_80ck1580 FIND v(dout0_80) AT=795.025n

.meas tran vdout0_81ck1580 FIND v(dout0_81) AT=795.025n

.meas tran vdout0_82ck1580 FIND v(dout0_82) AT=795.025n

.meas tran vdout0_83ck1580 FIND v(dout0_83) AT=795.025n

.meas tran vdout0_84ck1580 FIND v(dout0_84) AT=795.025n

.meas tran vdout0_85ck1580 FIND v(dout0_85) AT=795.025n

.meas tran vdout0_86ck1580 FIND v(dout0_86) AT=795.025n

.meas tran vdout0_87ck1580 FIND v(dout0_87) AT=795.025n

.meas tran vdout0_88ck1580 FIND v(dout0_88) AT=795.025n

.meas tran vdout0_89ck1580 FIND v(dout0_89) AT=795.025n

.meas tran vdout0_90ck1580 FIND v(dout0_90) AT=795.025n

.meas tran vdout0_91ck1580 FIND v(dout0_91) AT=795.025n

.meas tran vdout0_92ck1580 FIND v(dout0_92) AT=795.025n

.meas tran vdout0_93ck1580 FIND v(dout0_93) AT=795.025n

.meas tran vdout0_94ck1580 FIND v(dout0_94) AT=795.025n

.meas tran vdout0_95ck1580 FIND v(dout0_95) AT=795.025n

.meas tran vdout0_96ck1580 FIND v(dout0_96) AT=795.025n

.meas tran vdout0_97ck1580 FIND v(dout0_97) AT=795.025n

.meas tran vdout0_98ck1580 FIND v(dout0_98) AT=795.025n

.meas tran vdout0_99ck1580 FIND v(dout0_99) AT=795.025n

.meas tran vdout0_100ck1580 FIND v(dout0_100) AT=795.025n

.meas tran vdout0_101ck1580 FIND v(dout0_101) AT=795.025n

.meas tran vdout0_102ck1580 FIND v(dout0_102) AT=795.025n

.meas tran vdout0_103ck1580 FIND v(dout0_103) AT=795.025n

.meas tran vdout0_104ck1580 FIND v(dout0_104) AT=795.025n

.meas tran vdout0_105ck1580 FIND v(dout0_105) AT=795.025n

.meas tran vdout0_106ck1580 FIND v(dout0_106) AT=795.025n

.meas tran vdout0_107ck1580 FIND v(dout0_107) AT=795.025n

.meas tran vdout0_108ck1580 FIND v(dout0_108) AT=795.025n

.meas tran vdout0_109ck1580 FIND v(dout0_109) AT=795.025n

.meas tran vdout0_110ck1580 FIND v(dout0_110) AT=795.025n

.meas tran vdout0_111ck1580 FIND v(dout0_111) AT=795.025n

.meas tran vdout0_112ck1580 FIND v(dout0_112) AT=795.025n

.meas tran vdout0_113ck1580 FIND v(dout0_113) AT=795.025n

.meas tran vdout0_114ck1580 FIND v(dout0_114) AT=795.025n

.meas tran vdout0_115ck1580 FIND v(dout0_115) AT=795.025n

.meas tran vdout0_116ck1580 FIND v(dout0_116) AT=795.025n

.meas tran vdout0_117ck1580 FIND v(dout0_117) AT=795.025n

.meas tran vdout0_118ck1580 FIND v(dout0_118) AT=795.025n

.meas tran vdout0_119ck1580 FIND v(dout0_119) AT=795.025n

.meas tran vdout0_120ck1580 FIND v(dout0_120) AT=795.025n

.meas tran vdout0_121ck1580 FIND v(dout0_121) AT=795.025n

.meas tran vdout0_122ck1580 FIND v(dout0_122) AT=795.025n

.meas tran vdout0_123ck1580 FIND v(dout0_123) AT=795.025n

.meas tran vdout0_124ck1580 FIND v(dout0_124) AT=795.025n

.meas tran vdout0_125ck1580 FIND v(dout0_125) AT=795.025n

.meas tran vdout0_126ck1580 FIND v(dout0_126) AT=795.025n

.meas tran vdout0_127ck1580 FIND v(dout0_127) AT=795.025n

.meas tran vdout0_128ck1580 FIND v(dout0_128) AT=795.025n

.meas tran vdout0_129ck1580 FIND v(dout0_129) AT=795.025n

.meas tran vdout0_130ck1580 FIND v(dout0_130) AT=795.025n

.meas tran vdout0_131ck1580 FIND v(dout0_131) AT=795.025n

.meas tran vdout0_132ck1580 FIND v(dout0_132) AT=795.025n

.meas tran vdout0_133ck1580 FIND v(dout0_133) AT=795.025n

.meas tran vdout0_134ck1580 FIND v(dout0_134) AT=795.025n

.meas tran vdout0_135ck1580 FIND v(dout0_135) AT=795.025n

.meas tran vdout0_136ck1580 FIND v(dout0_136) AT=795.025n

.meas tran vdout0_137ck1580 FIND v(dout0_137) AT=795.025n

.meas tran vdout0_138ck1580 FIND v(dout0_138) AT=795.025n

.meas tran vdout0_139ck1580 FIND v(dout0_139) AT=795.025n

.meas tran vdout0_140ck1580 FIND v(dout0_140) AT=795.025n

.meas tran vdout0_141ck1580 FIND v(dout0_141) AT=795.025n

.meas tran vdout0_142ck1580 FIND v(dout0_142) AT=795.025n

.meas tran vdout0_143ck1580 FIND v(dout0_143) AT=795.025n

.meas tran vdout0_144ck1580 FIND v(dout0_144) AT=795.025n

.meas tran vdout0_145ck1580 FIND v(dout0_145) AT=795.025n

.meas tran vdout0_146ck1580 FIND v(dout0_146) AT=795.025n

.meas tran vdout0_147ck1580 FIND v(dout0_147) AT=795.025n

.meas tran vdout0_148ck1580 FIND v(dout0_148) AT=795.025n

.meas tran vdout0_149ck1580 FIND v(dout0_149) AT=795.025n

.meas tran vdout0_0ck1590 FIND v(dout0_0) AT=800.025n

.meas tran vdout0_1ck1590 FIND v(dout0_1) AT=800.025n

.meas tran vdout0_2ck1590 FIND v(dout0_2) AT=800.025n

.meas tran vdout0_3ck1590 FIND v(dout0_3) AT=800.025n

.meas tran vdout0_4ck1590 FIND v(dout0_4) AT=800.025n

.meas tran vdout0_5ck1590 FIND v(dout0_5) AT=800.025n

.meas tran vdout0_6ck1590 FIND v(dout0_6) AT=800.025n

.meas tran vdout0_7ck1590 FIND v(dout0_7) AT=800.025n

.meas tran vdout0_8ck1590 FIND v(dout0_8) AT=800.025n

.meas tran vdout0_9ck1590 FIND v(dout0_9) AT=800.025n

.meas tran vdout0_10ck1590 FIND v(dout0_10) AT=800.025n

.meas tran vdout0_11ck1590 FIND v(dout0_11) AT=800.025n

.meas tran vdout0_12ck1590 FIND v(dout0_12) AT=800.025n

.meas tran vdout0_13ck1590 FIND v(dout0_13) AT=800.025n

.meas tran vdout0_14ck1590 FIND v(dout0_14) AT=800.025n

.meas tran vdout0_15ck1590 FIND v(dout0_15) AT=800.025n

.meas tran vdout0_16ck1590 FIND v(dout0_16) AT=800.025n

.meas tran vdout0_17ck1590 FIND v(dout0_17) AT=800.025n

.meas tran vdout0_18ck1590 FIND v(dout0_18) AT=800.025n

.meas tran vdout0_19ck1590 FIND v(dout0_19) AT=800.025n

.meas tran vdout0_20ck1590 FIND v(dout0_20) AT=800.025n

.meas tran vdout0_21ck1590 FIND v(dout0_21) AT=800.025n

.meas tran vdout0_22ck1590 FIND v(dout0_22) AT=800.025n

.meas tran vdout0_23ck1590 FIND v(dout0_23) AT=800.025n

.meas tran vdout0_24ck1590 FIND v(dout0_24) AT=800.025n

.meas tran vdout0_25ck1590 FIND v(dout0_25) AT=800.025n

.meas tran vdout0_26ck1590 FIND v(dout0_26) AT=800.025n

.meas tran vdout0_27ck1590 FIND v(dout0_27) AT=800.025n

.meas tran vdout0_28ck1590 FIND v(dout0_28) AT=800.025n

.meas tran vdout0_29ck1590 FIND v(dout0_29) AT=800.025n

.meas tran vdout0_30ck1590 FIND v(dout0_30) AT=800.025n

.meas tran vdout0_31ck1590 FIND v(dout0_31) AT=800.025n

.meas tran vdout0_32ck1590 FIND v(dout0_32) AT=800.025n

.meas tran vdout0_33ck1590 FIND v(dout0_33) AT=800.025n

.meas tran vdout0_34ck1590 FIND v(dout0_34) AT=800.025n

.meas tran vdout0_35ck1590 FIND v(dout0_35) AT=800.025n

.meas tran vdout0_36ck1590 FIND v(dout0_36) AT=800.025n

.meas tran vdout0_37ck1590 FIND v(dout0_37) AT=800.025n

.meas tran vdout0_38ck1590 FIND v(dout0_38) AT=800.025n

.meas tran vdout0_39ck1590 FIND v(dout0_39) AT=800.025n

.meas tran vdout0_40ck1590 FIND v(dout0_40) AT=800.025n

.meas tran vdout0_41ck1590 FIND v(dout0_41) AT=800.025n

.meas tran vdout0_42ck1590 FIND v(dout0_42) AT=800.025n

.meas tran vdout0_43ck1590 FIND v(dout0_43) AT=800.025n

.meas tran vdout0_44ck1590 FIND v(dout0_44) AT=800.025n

.meas tran vdout0_45ck1590 FIND v(dout0_45) AT=800.025n

.meas tran vdout0_46ck1590 FIND v(dout0_46) AT=800.025n

.meas tran vdout0_47ck1590 FIND v(dout0_47) AT=800.025n

.meas tran vdout0_48ck1590 FIND v(dout0_48) AT=800.025n

.meas tran vdout0_49ck1590 FIND v(dout0_49) AT=800.025n

.meas tran vdout0_50ck1590 FIND v(dout0_50) AT=800.025n

.meas tran vdout0_51ck1590 FIND v(dout0_51) AT=800.025n

.meas tran vdout0_52ck1590 FIND v(dout0_52) AT=800.025n

.meas tran vdout0_53ck1590 FIND v(dout0_53) AT=800.025n

.meas tran vdout0_54ck1590 FIND v(dout0_54) AT=800.025n

.meas tran vdout0_55ck1590 FIND v(dout0_55) AT=800.025n

.meas tran vdout0_56ck1590 FIND v(dout0_56) AT=800.025n

.meas tran vdout0_57ck1590 FIND v(dout0_57) AT=800.025n

.meas tran vdout0_58ck1590 FIND v(dout0_58) AT=800.025n

.meas tran vdout0_59ck1590 FIND v(dout0_59) AT=800.025n

.meas tran vdout0_60ck1590 FIND v(dout0_60) AT=800.025n

.meas tran vdout0_61ck1590 FIND v(dout0_61) AT=800.025n

.meas tran vdout0_62ck1590 FIND v(dout0_62) AT=800.025n

.meas tran vdout0_63ck1590 FIND v(dout0_63) AT=800.025n

.meas tran vdout0_64ck1590 FIND v(dout0_64) AT=800.025n

.meas tran vdout0_65ck1590 FIND v(dout0_65) AT=800.025n

.meas tran vdout0_66ck1590 FIND v(dout0_66) AT=800.025n

.meas tran vdout0_67ck1590 FIND v(dout0_67) AT=800.025n

.meas tran vdout0_68ck1590 FIND v(dout0_68) AT=800.025n

.meas tran vdout0_69ck1590 FIND v(dout0_69) AT=800.025n

.meas tran vdout0_70ck1590 FIND v(dout0_70) AT=800.025n

.meas tran vdout0_71ck1590 FIND v(dout0_71) AT=800.025n

.meas tran vdout0_72ck1590 FIND v(dout0_72) AT=800.025n

.meas tran vdout0_73ck1590 FIND v(dout0_73) AT=800.025n

.meas tran vdout0_74ck1590 FIND v(dout0_74) AT=800.025n

.meas tran vdout0_75ck1590 FIND v(dout0_75) AT=800.025n

.meas tran vdout0_76ck1590 FIND v(dout0_76) AT=800.025n

.meas tran vdout0_77ck1590 FIND v(dout0_77) AT=800.025n

.meas tran vdout0_78ck1590 FIND v(dout0_78) AT=800.025n

.meas tran vdout0_79ck1590 FIND v(dout0_79) AT=800.025n

.meas tran vdout0_80ck1590 FIND v(dout0_80) AT=800.025n

.meas tran vdout0_81ck1590 FIND v(dout0_81) AT=800.025n

.meas tran vdout0_82ck1590 FIND v(dout0_82) AT=800.025n

.meas tran vdout0_83ck1590 FIND v(dout0_83) AT=800.025n

.meas tran vdout0_84ck1590 FIND v(dout0_84) AT=800.025n

.meas tran vdout0_85ck1590 FIND v(dout0_85) AT=800.025n

.meas tran vdout0_86ck1590 FIND v(dout0_86) AT=800.025n

.meas tran vdout0_87ck1590 FIND v(dout0_87) AT=800.025n

.meas tran vdout0_88ck1590 FIND v(dout0_88) AT=800.025n

.meas tran vdout0_89ck1590 FIND v(dout0_89) AT=800.025n

.meas tran vdout0_90ck1590 FIND v(dout0_90) AT=800.025n

.meas tran vdout0_91ck1590 FIND v(dout0_91) AT=800.025n

.meas tran vdout0_92ck1590 FIND v(dout0_92) AT=800.025n

.meas tran vdout0_93ck1590 FIND v(dout0_93) AT=800.025n

.meas tran vdout0_94ck1590 FIND v(dout0_94) AT=800.025n

.meas tran vdout0_95ck1590 FIND v(dout0_95) AT=800.025n

.meas tran vdout0_96ck1590 FIND v(dout0_96) AT=800.025n

.meas tran vdout0_97ck1590 FIND v(dout0_97) AT=800.025n

.meas tran vdout0_98ck1590 FIND v(dout0_98) AT=800.025n

.meas tran vdout0_99ck1590 FIND v(dout0_99) AT=800.025n

.meas tran vdout0_100ck1590 FIND v(dout0_100) AT=800.025n

.meas tran vdout0_101ck1590 FIND v(dout0_101) AT=800.025n

.meas tran vdout0_102ck1590 FIND v(dout0_102) AT=800.025n

.meas tran vdout0_103ck1590 FIND v(dout0_103) AT=800.025n

.meas tran vdout0_104ck1590 FIND v(dout0_104) AT=800.025n

.meas tran vdout0_105ck1590 FIND v(dout0_105) AT=800.025n

.meas tran vdout0_106ck1590 FIND v(dout0_106) AT=800.025n

.meas tran vdout0_107ck1590 FIND v(dout0_107) AT=800.025n

.meas tran vdout0_108ck1590 FIND v(dout0_108) AT=800.025n

.meas tran vdout0_109ck1590 FIND v(dout0_109) AT=800.025n

.meas tran vdout0_110ck1590 FIND v(dout0_110) AT=800.025n

.meas tran vdout0_111ck1590 FIND v(dout0_111) AT=800.025n

.meas tran vdout0_112ck1590 FIND v(dout0_112) AT=800.025n

.meas tran vdout0_113ck1590 FIND v(dout0_113) AT=800.025n

.meas tran vdout0_114ck1590 FIND v(dout0_114) AT=800.025n

.meas tran vdout0_115ck1590 FIND v(dout0_115) AT=800.025n

.meas tran vdout0_116ck1590 FIND v(dout0_116) AT=800.025n

.meas tran vdout0_117ck1590 FIND v(dout0_117) AT=800.025n

.meas tran vdout0_118ck1590 FIND v(dout0_118) AT=800.025n

.meas tran vdout0_119ck1590 FIND v(dout0_119) AT=800.025n

.meas tran vdout0_120ck1590 FIND v(dout0_120) AT=800.025n

.meas tran vdout0_121ck1590 FIND v(dout0_121) AT=800.025n

.meas tran vdout0_122ck1590 FIND v(dout0_122) AT=800.025n

.meas tran vdout0_123ck1590 FIND v(dout0_123) AT=800.025n

.meas tran vdout0_124ck1590 FIND v(dout0_124) AT=800.025n

.meas tran vdout0_125ck1590 FIND v(dout0_125) AT=800.025n

.meas tran vdout0_126ck1590 FIND v(dout0_126) AT=800.025n

.meas tran vdout0_127ck1590 FIND v(dout0_127) AT=800.025n

.meas tran vdout0_128ck1590 FIND v(dout0_128) AT=800.025n

.meas tran vdout0_129ck1590 FIND v(dout0_129) AT=800.025n

.meas tran vdout0_130ck1590 FIND v(dout0_130) AT=800.025n

.meas tran vdout0_131ck1590 FIND v(dout0_131) AT=800.025n

.meas tran vdout0_132ck1590 FIND v(dout0_132) AT=800.025n

.meas tran vdout0_133ck1590 FIND v(dout0_133) AT=800.025n

.meas tran vdout0_134ck1590 FIND v(dout0_134) AT=800.025n

.meas tran vdout0_135ck1590 FIND v(dout0_135) AT=800.025n

.meas tran vdout0_136ck1590 FIND v(dout0_136) AT=800.025n

.meas tran vdout0_137ck1590 FIND v(dout0_137) AT=800.025n

.meas tran vdout0_138ck1590 FIND v(dout0_138) AT=800.025n

.meas tran vdout0_139ck1590 FIND v(dout0_139) AT=800.025n

.meas tran vdout0_140ck1590 FIND v(dout0_140) AT=800.025n

.meas tran vdout0_141ck1590 FIND v(dout0_141) AT=800.025n

.meas tran vdout0_142ck1590 FIND v(dout0_142) AT=800.025n

.meas tran vdout0_143ck1590 FIND v(dout0_143) AT=800.025n

.meas tran vdout0_144ck1590 FIND v(dout0_144) AT=800.025n

.meas tran vdout0_145ck1590 FIND v(dout0_145) AT=800.025n

.meas tran vdout0_146ck1590 FIND v(dout0_146) AT=800.025n

.meas tran vdout0_147ck1590 FIND v(dout0_147) AT=800.025n

.meas tran vdout0_148ck1590 FIND v(dout0_148) AT=800.025n

.meas tran vdout0_149ck1590 FIND v(dout0_149) AT=800.025n

.meas tran vdout0_0ck1600 FIND v(dout0_0) AT=805.025n

.meas tran vdout0_1ck1600 FIND v(dout0_1) AT=805.025n

.meas tran vdout0_2ck1600 FIND v(dout0_2) AT=805.025n

.meas tran vdout0_3ck1600 FIND v(dout0_3) AT=805.025n

.meas tran vdout0_4ck1600 FIND v(dout0_4) AT=805.025n

.meas tran vdout0_5ck1600 FIND v(dout0_5) AT=805.025n

.meas tran vdout0_6ck1600 FIND v(dout0_6) AT=805.025n

.meas tran vdout0_7ck1600 FIND v(dout0_7) AT=805.025n

.meas tran vdout0_8ck1600 FIND v(dout0_8) AT=805.025n

.meas tran vdout0_9ck1600 FIND v(dout0_9) AT=805.025n

.meas tran vdout0_10ck1600 FIND v(dout0_10) AT=805.025n

.meas tran vdout0_11ck1600 FIND v(dout0_11) AT=805.025n

.meas tran vdout0_12ck1600 FIND v(dout0_12) AT=805.025n

.meas tran vdout0_13ck1600 FIND v(dout0_13) AT=805.025n

.meas tran vdout0_14ck1600 FIND v(dout0_14) AT=805.025n

.meas tran vdout0_15ck1600 FIND v(dout0_15) AT=805.025n

.meas tran vdout0_16ck1600 FIND v(dout0_16) AT=805.025n

.meas tran vdout0_17ck1600 FIND v(dout0_17) AT=805.025n

.meas tran vdout0_18ck1600 FIND v(dout0_18) AT=805.025n

.meas tran vdout0_19ck1600 FIND v(dout0_19) AT=805.025n

.meas tran vdout0_20ck1600 FIND v(dout0_20) AT=805.025n

.meas tran vdout0_21ck1600 FIND v(dout0_21) AT=805.025n

.meas tran vdout0_22ck1600 FIND v(dout0_22) AT=805.025n

.meas tran vdout0_23ck1600 FIND v(dout0_23) AT=805.025n

.meas tran vdout0_24ck1600 FIND v(dout0_24) AT=805.025n

.meas tran vdout0_25ck1600 FIND v(dout0_25) AT=805.025n

.meas tran vdout0_26ck1600 FIND v(dout0_26) AT=805.025n

.meas tran vdout0_27ck1600 FIND v(dout0_27) AT=805.025n

.meas tran vdout0_28ck1600 FIND v(dout0_28) AT=805.025n

.meas tran vdout0_29ck1600 FIND v(dout0_29) AT=805.025n

.meas tran vdout0_30ck1600 FIND v(dout0_30) AT=805.025n

.meas tran vdout0_31ck1600 FIND v(dout0_31) AT=805.025n

.meas tran vdout0_32ck1600 FIND v(dout0_32) AT=805.025n

.meas tran vdout0_33ck1600 FIND v(dout0_33) AT=805.025n

.meas tran vdout0_34ck1600 FIND v(dout0_34) AT=805.025n

.meas tran vdout0_35ck1600 FIND v(dout0_35) AT=805.025n

.meas tran vdout0_36ck1600 FIND v(dout0_36) AT=805.025n

.meas tran vdout0_37ck1600 FIND v(dout0_37) AT=805.025n

.meas tran vdout0_38ck1600 FIND v(dout0_38) AT=805.025n

.meas tran vdout0_39ck1600 FIND v(dout0_39) AT=805.025n

.meas tran vdout0_40ck1600 FIND v(dout0_40) AT=805.025n

.meas tran vdout0_41ck1600 FIND v(dout0_41) AT=805.025n

.meas tran vdout0_42ck1600 FIND v(dout0_42) AT=805.025n

.meas tran vdout0_43ck1600 FIND v(dout0_43) AT=805.025n

.meas tran vdout0_44ck1600 FIND v(dout0_44) AT=805.025n

.meas tran vdout0_45ck1600 FIND v(dout0_45) AT=805.025n

.meas tran vdout0_46ck1600 FIND v(dout0_46) AT=805.025n

.meas tran vdout0_47ck1600 FIND v(dout0_47) AT=805.025n

.meas tran vdout0_48ck1600 FIND v(dout0_48) AT=805.025n

.meas tran vdout0_49ck1600 FIND v(dout0_49) AT=805.025n

.meas tran vdout0_50ck1600 FIND v(dout0_50) AT=805.025n

.meas tran vdout0_51ck1600 FIND v(dout0_51) AT=805.025n

.meas tran vdout0_52ck1600 FIND v(dout0_52) AT=805.025n

.meas tran vdout0_53ck1600 FIND v(dout0_53) AT=805.025n

.meas tran vdout0_54ck1600 FIND v(dout0_54) AT=805.025n

.meas tran vdout0_55ck1600 FIND v(dout0_55) AT=805.025n

.meas tran vdout0_56ck1600 FIND v(dout0_56) AT=805.025n

.meas tran vdout0_57ck1600 FIND v(dout0_57) AT=805.025n

.meas tran vdout0_58ck1600 FIND v(dout0_58) AT=805.025n

.meas tran vdout0_59ck1600 FIND v(dout0_59) AT=805.025n

.meas tran vdout0_60ck1600 FIND v(dout0_60) AT=805.025n

.meas tran vdout0_61ck1600 FIND v(dout0_61) AT=805.025n

.meas tran vdout0_62ck1600 FIND v(dout0_62) AT=805.025n

.meas tran vdout0_63ck1600 FIND v(dout0_63) AT=805.025n

.meas tran vdout0_64ck1600 FIND v(dout0_64) AT=805.025n

.meas tran vdout0_65ck1600 FIND v(dout0_65) AT=805.025n

.meas tran vdout0_66ck1600 FIND v(dout0_66) AT=805.025n

.meas tran vdout0_67ck1600 FIND v(dout0_67) AT=805.025n

.meas tran vdout0_68ck1600 FIND v(dout0_68) AT=805.025n

.meas tran vdout0_69ck1600 FIND v(dout0_69) AT=805.025n

.meas tran vdout0_70ck1600 FIND v(dout0_70) AT=805.025n

.meas tran vdout0_71ck1600 FIND v(dout0_71) AT=805.025n

.meas tran vdout0_72ck1600 FIND v(dout0_72) AT=805.025n

.meas tran vdout0_73ck1600 FIND v(dout0_73) AT=805.025n

.meas tran vdout0_74ck1600 FIND v(dout0_74) AT=805.025n

.meas tran vdout0_75ck1600 FIND v(dout0_75) AT=805.025n

.meas tran vdout0_76ck1600 FIND v(dout0_76) AT=805.025n

.meas tran vdout0_77ck1600 FIND v(dout0_77) AT=805.025n

.meas tran vdout0_78ck1600 FIND v(dout0_78) AT=805.025n

.meas tran vdout0_79ck1600 FIND v(dout0_79) AT=805.025n

.meas tran vdout0_80ck1600 FIND v(dout0_80) AT=805.025n

.meas tran vdout0_81ck1600 FIND v(dout0_81) AT=805.025n

.meas tran vdout0_82ck1600 FIND v(dout0_82) AT=805.025n

.meas tran vdout0_83ck1600 FIND v(dout0_83) AT=805.025n

.meas tran vdout0_84ck1600 FIND v(dout0_84) AT=805.025n

.meas tran vdout0_85ck1600 FIND v(dout0_85) AT=805.025n

.meas tran vdout0_86ck1600 FIND v(dout0_86) AT=805.025n

.meas tran vdout0_87ck1600 FIND v(dout0_87) AT=805.025n

.meas tran vdout0_88ck1600 FIND v(dout0_88) AT=805.025n

.meas tran vdout0_89ck1600 FIND v(dout0_89) AT=805.025n

.meas tran vdout0_90ck1600 FIND v(dout0_90) AT=805.025n

.meas tran vdout0_91ck1600 FIND v(dout0_91) AT=805.025n

.meas tran vdout0_92ck1600 FIND v(dout0_92) AT=805.025n

.meas tran vdout0_93ck1600 FIND v(dout0_93) AT=805.025n

.meas tran vdout0_94ck1600 FIND v(dout0_94) AT=805.025n

.meas tran vdout0_95ck1600 FIND v(dout0_95) AT=805.025n

.meas tran vdout0_96ck1600 FIND v(dout0_96) AT=805.025n

.meas tran vdout0_97ck1600 FIND v(dout0_97) AT=805.025n

.meas tran vdout0_98ck1600 FIND v(dout0_98) AT=805.025n

.meas tran vdout0_99ck1600 FIND v(dout0_99) AT=805.025n

.meas tran vdout0_100ck1600 FIND v(dout0_100) AT=805.025n

.meas tran vdout0_101ck1600 FIND v(dout0_101) AT=805.025n

.meas tran vdout0_102ck1600 FIND v(dout0_102) AT=805.025n

.meas tran vdout0_103ck1600 FIND v(dout0_103) AT=805.025n

.meas tran vdout0_104ck1600 FIND v(dout0_104) AT=805.025n

.meas tran vdout0_105ck1600 FIND v(dout0_105) AT=805.025n

.meas tran vdout0_106ck1600 FIND v(dout0_106) AT=805.025n

.meas tran vdout0_107ck1600 FIND v(dout0_107) AT=805.025n

.meas tran vdout0_108ck1600 FIND v(dout0_108) AT=805.025n

.meas tran vdout0_109ck1600 FIND v(dout0_109) AT=805.025n

.meas tran vdout0_110ck1600 FIND v(dout0_110) AT=805.025n

.meas tran vdout0_111ck1600 FIND v(dout0_111) AT=805.025n

.meas tran vdout0_112ck1600 FIND v(dout0_112) AT=805.025n

.meas tran vdout0_113ck1600 FIND v(dout0_113) AT=805.025n

.meas tran vdout0_114ck1600 FIND v(dout0_114) AT=805.025n

.meas tran vdout0_115ck1600 FIND v(dout0_115) AT=805.025n

.meas tran vdout0_116ck1600 FIND v(dout0_116) AT=805.025n

.meas tran vdout0_117ck1600 FIND v(dout0_117) AT=805.025n

.meas tran vdout0_118ck1600 FIND v(dout0_118) AT=805.025n

.meas tran vdout0_119ck1600 FIND v(dout0_119) AT=805.025n

.meas tran vdout0_120ck1600 FIND v(dout0_120) AT=805.025n

.meas tran vdout0_121ck1600 FIND v(dout0_121) AT=805.025n

.meas tran vdout0_122ck1600 FIND v(dout0_122) AT=805.025n

.meas tran vdout0_123ck1600 FIND v(dout0_123) AT=805.025n

.meas tran vdout0_124ck1600 FIND v(dout0_124) AT=805.025n

.meas tran vdout0_125ck1600 FIND v(dout0_125) AT=805.025n

.meas tran vdout0_126ck1600 FIND v(dout0_126) AT=805.025n

.meas tran vdout0_127ck1600 FIND v(dout0_127) AT=805.025n

.meas tran vdout0_128ck1600 FIND v(dout0_128) AT=805.025n

.meas tran vdout0_129ck1600 FIND v(dout0_129) AT=805.025n

.meas tran vdout0_130ck1600 FIND v(dout0_130) AT=805.025n

.meas tran vdout0_131ck1600 FIND v(dout0_131) AT=805.025n

.meas tran vdout0_132ck1600 FIND v(dout0_132) AT=805.025n

.meas tran vdout0_133ck1600 FIND v(dout0_133) AT=805.025n

.meas tran vdout0_134ck1600 FIND v(dout0_134) AT=805.025n

.meas tran vdout0_135ck1600 FIND v(dout0_135) AT=805.025n

.meas tran vdout0_136ck1600 FIND v(dout0_136) AT=805.025n

.meas tran vdout0_137ck1600 FIND v(dout0_137) AT=805.025n

.meas tran vdout0_138ck1600 FIND v(dout0_138) AT=805.025n

.meas tran vdout0_139ck1600 FIND v(dout0_139) AT=805.025n

.meas tran vdout0_140ck1600 FIND v(dout0_140) AT=805.025n

.meas tran vdout0_141ck1600 FIND v(dout0_141) AT=805.025n

.meas tran vdout0_142ck1600 FIND v(dout0_142) AT=805.025n

.meas tran vdout0_143ck1600 FIND v(dout0_143) AT=805.025n

.meas tran vdout0_144ck1600 FIND v(dout0_144) AT=805.025n

.meas tran vdout0_145ck1600 FIND v(dout0_145) AT=805.025n

.meas tran vdout0_146ck1600 FIND v(dout0_146) AT=805.025n

.meas tran vdout0_147ck1600 FIND v(dout0_147) AT=805.025n

.meas tran vdout0_148ck1600 FIND v(dout0_148) AT=805.025n

.meas tran vdout0_149ck1600 FIND v(dout0_149) AT=805.025n

.meas tran vdout0_0ck1610 FIND v(dout0_0) AT=810.025n

.meas tran vdout0_1ck1610 FIND v(dout0_1) AT=810.025n

.meas tran vdout0_2ck1610 FIND v(dout0_2) AT=810.025n

.meas tran vdout0_3ck1610 FIND v(dout0_3) AT=810.025n

.meas tran vdout0_4ck1610 FIND v(dout0_4) AT=810.025n

.meas tran vdout0_5ck1610 FIND v(dout0_5) AT=810.025n

.meas tran vdout0_6ck1610 FIND v(dout0_6) AT=810.025n

.meas tran vdout0_7ck1610 FIND v(dout0_7) AT=810.025n

.meas tran vdout0_8ck1610 FIND v(dout0_8) AT=810.025n

.meas tran vdout0_9ck1610 FIND v(dout0_9) AT=810.025n

.meas tran vdout0_10ck1610 FIND v(dout0_10) AT=810.025n

.meas tran vdout0_11ck1610 FIND v(dout0_11) AT=810.025n

.meas tran vdout0_12ck1610 FIND v(dout0_12) AT=810.025n

.meas tran vdout0_13ck1610 FIND v(dout0_13) AT=810.025n

.meas tran vdout0_14ck1610 FIND v(dout0_14) AT=810.025n

.meas tran vdout0_15ck1610 FIND v(dout0_15) AT=810.025n

.meas tran vdout0_16ck1610 FIND v(dout0_16) AT=810.025n

.meas tran vdout0_17ck1610 FIND v(dout0_17) AT=810.025n

.meas tran vdout0_18ck1610 FIND v(dout0_18) AT=810.025n

.meas tran vdout0_19ck1610 FIND v(dout0_19) AT=810.025n

.meas tran vdout0_20ck1610 FIND v(dout0_20) AT=810.025n

.meas tran vdout0_21ck1610 FIND v(dout0_21) AT=810.025n

.meas tran vdout0_22ck1610 FIND v(dout0_22) AT=810.025n

.meas tran vdout0_23ck1610 FIND v(dout0_23) AT=810.025n

.meas tran vdout0_24ck1610 FIND v(dout0_24) AT=810.025n

.meas tran vdout0_25ck1610 FIND v(dout0_25) AT=810.025n

.meas tran vdout0_26ck1610 FIND v(dout0_26) AT=810.025n

.meas tran vdout0_27ck1610 FIND v(dout0_27) AT=810.025n

.meas tran vdout0_28ck1610 FIND v(dout0_28) AT=810.025n

.meas tran vdout0_29ck1610 FIND v(dout0_29) AT=810.025n

.meas tran vdout0_30ck1610 FIND v(dout0_30) AT=810.025n

.meas tran vdout0_31ck1610 FIND v(dout0_31) AT=810.025n

.meas tran vdout0_32ck1610 FIND v(dout0_32) AT=810.025n

.meas tran vdout0_33ck1610 FIND v(dout0_33) AT=810.025n

.meas tran vdout0_34ck1610 FIND v(dout0_34) AT=810.025n

.meas tran vdout0_35ck1610 FIND v(dout0_35) AT=810.025n

.meas tran vdout0_36ck1610 FIND v(dout0_36) AT=810.025n

.meas tran vdout0_37ck1610 FIND v(dout0_37) AT=810.025n

.meas tran vdout0_38ck1610 FIND v(dout0_38) AT=810.025n

.meas tran vdout0_39ck1610 FIND v(dout0_39) AT=810.025n

.meas tran vdout0_40ck1610 FIND v(dout0_40) AT=810.025n

.meas tran vdout0_41ck1610 FIND v(dout0_41) AT=810.025n

.meas tran vdout0_42ck1610 FIND v(dout0_42) AT=810.025n

.meas tran vdout0_43ck1610 FIND v(dout0_43) AT=810.025n

.meas tran vdout0_44ck1610 FIND v(dout0_44) AT=810.025n

.meas tran vdout0_45ck1610 FIND v(dout0_45) AT=810.025n

.meas tran vdout0_46ck1610 FIND v(dout0_46) AT=810.025n

.meas tran vdout0_47ck1610 FIND v(dout0_47) AT=810.025n

.meas tran vdout0_48ck1610 FIND v(dout0_48) AT=810.025n

.meas tran vdout0_49ck1610 FIND v(dout0_49) AT=810.025n

.meas tran vdout0_50ck1610 FIND v(dout0_50) AT=810.025n

.meas tran vdout0_51ck1610 FIND v(dout0_51) AT=810.025n

.meas tran vdout0_52ck1610 FIND v(dout0_52) AT=810.025n

.meas tran vdout0_53ck1610 FIND v(dout0_53) AT=810.025n

.meas tran vdout0_54ck1610 FIND v(dout0_54) AT=810.025n

.meas tran vdout0_55ck1610 FIND v(dout0_55) AT=810.025n

.meas tran vdout0_56ck1610 FIND v(dout0_56) AT=810.025n

.meas tran vdout0_57ck1610 FIND v(dout0_57) AT=810.025n

.meas tran vdout0_58ck1610 FIND v(dout0_58) AT=810.025n

.meas tran vdout0_59ck1610 FIND v(dout0_59) AT=810.025n

.meas tran vdout0_60ck1610 FIND v(dout0_60) AT=810.025n

.meas tran vdout0_61ck1610 FIND v(dout0_61) AT=810.025n

.meas tran vdout0_62ck1610 FIND v(dout0_62) AT=810.025n

.meas tran vdout0_63ck1610 FIND v(dout0_63) AT=810.025n

.meas tran vdout0_64ck1610 FIND v(dout0_64) AT=810.025n

.meas tran vdout0_65ck1610 FIND v(dout0_65) AT=810.025n

.meas tran vdout0_66ck1610 FIND v(dout0_66) AT=810.025n

.meas tran vdout0_67ck1610 FIND v(dout0_67) AT=810.025n

.meas tran vdout0_68ck1610 FIND v(dout0_68) AT=810.025n

.meas tran vdout0_69ck1610 FIND v(dout0_69) AT=810.025n

.meas tran vdout0_70ck1610 FIND v(dout0_70) AT=810.025n

.meas tran vdout0_71ck1610 FIND v(dout0_71) AT=810.025n

.meas tran vdout0_72ck1610 FIND v(dout0_72) AT=810.025n

.meas tran vdout0_73ck1610 FIND v(dout0_73) AT=810.025n

.meas tran vdout0_74ck1610 FIND v(dout0_74) AT=810.025n

.meas tran vdout0_75ck1610 FIND v(dout0_75) AT=810.025n

.meas tran vdout0_76ck1610 FIND v(dout0_76) AT=810.025n

.meas tran vdout0_77ck1610 FIND v(dout0_77) AT=810.025n

.meas tran vdout0_78ck1610 FIND v(dout0_78) AT=810.025n

.meas tran vdout0_79ck1610 FIND v(dout0_79) AT=810.025n

.meas tran vdout0_80ck1610 FIND v(dout0_80) AT=810.025n

.meas tran vdout0_81ck1610 FIND v(dout0_81) AT=810.025n

.meas tran vdout0_82ck1610 FIND v(dout0_82) AT=810.025n

.meas tran vdout0_83ck1610 FIND v(dout0_83) AT=810.025n

.meas tran vdout0_84ck1610 FIND v(dout0_84) AT=810.025n

.meas tran vdout0_85ck1610 FIND v(dout0_85) AT=810.025n

.meas tran vdout0_86ck1610 FIND v(dout0_86) AT=810.025n

.meas tran vdout0_87ck1610 FIND v(dout0_87) AT=810.025n

.meas tran vdout0_88ck1610 FIND v(dout0_88) AT=810.025n

.meas tran vdout0_89ck1610 FIND v(dout0_89) AT=810.025n

.meas tran vdout0_90ck1610 FIND v(dout0_90) AT=810.025n

.meas tran vdout0_91ck1610 FIND v(dout0_91) AT=810.025n

.meas tran vdout0_92ck1610 FIND v(dout0_92) AT=810.025n

.meas tran vdout0_93ck1610 FIND v(dout0_93) AT=810.025n

.meas tran vdout0_94ck1610 FIND v(dout0_94) AT=810.025n

.meas tran vdout0_95ck1610 FIND v(dout0_95) AT=810.025n

.meas tran vdout0_96ck1610 FIND v(dout0_96) AT=810.025n

.meas tran vdout0_97ck1610 FIND v(dout0_97) AT=810.025n

.meas tran vdout0_98ck1610 FIND v(dout0_98) AT=810.025n

.meas tran vdout0_99ck1610 FIND v(dout0_99) AT=810.025n

.meas tran vdout0_100ck1610 FIND v(dout0_100) AT=810.025n

.meas tran vdout0_101ck1610 FIND v(dout0_101) AT=810.025n

.meas tran vdout0_102ck1610 FIND v(dout0_102) AT=810.025n

.meas tran vdout0_103ck1610 FIND v(dout0_103) AT=810.025n

.meas tran vdout0_104ck1610 FIND v(dout0_104) AT=810.025n

.meas tran vdout0_105ck1610 FIND v(dout0_105) AT=810.025n

.meas tran vdout0_106ck1610 FIND v(dout0_106) AT=810.025n

.meas tran vdout0_107ck1610 FIND v(dout0_107) AT=810.025n

.meas tran vdout0_108ck1610 FIND v(dout0_108) AT=810.025n

.meas tran vdout0_109ck1610 FIND v(dout0_109) AT=810.025n

.meas tran vdout0_110ck1610 FIND v(dout0_110) AT=810.025n

.meas tran vdout0_111ck1610 FIND v(dout0_111) AT=810.025n

.meas tran vdout0_112ck1610 FIND v(dout0_112) AT=810.025n

.meas tran vdout0_113ck1610 FIND v(dout0_113) AT=810.025n

.meas tran vdout0_114ck1610 FIND v(dout0_114) AT=810.025n

.meas tran vdout0_115ck1610 FIND v(dout0_115) AT=810.025n

.meas tran vdout0_116ck1610 FIND v(dout0_116) AT=810.025n

.meas tran vdout0_117ck1610 FIND v(dout0_117) AT=810.025n

.meas tran vdout0_118ck1610 FIND v(dout0_118) AT=810.025n

.meas tran vdout0_119ck1610 FIND v(dout0_119) AT=810.025n

.meas tran vdout0_120ck1610 FIND v(dout0_120) AT=810.025n

.meas tran vdout0_121ck1610 FIND v(dout0_121) AT=810.025n

.meas tran vdout0_122ck1610 FIND v(dout0_122) AT=810.025n

.meas tran vdout0_123ck1610 FIND v(dout0_123) AT=810.025n

.meas tran vdout0_124ck1610 FIND v(dout0_124) AT=810.025n

.meas tran vdout0_125ck1610 FIND v(dout0_125) AT=810.025n

.meas tran vdout0_126ck1610 FIND v(dout0_126) AT=810.025n

.meas tran vdout0_127ck1610 FIND v(dout0_127) AT=810.025n

.meas tran vdout0_128ck1610 FIND v(dout0_128) AT=810.025n

.meas tran vdout0_129ck1610 FIND v(dout0_129) AT=810.025n

.meas tran vdout0_130ck1610 FIND v(dout0_130) AT=810.025n

.meas tran vdout0_131ck1610 FIND v(dout0_131) AT=810.025n

.meas tran vdout0_132ck1610 FIND v(dout0_132) AT=810.025n

.meas tran vdout0_133ck1610 FIND v(dout0_133) AT=810.025n

.meas tran vdout0_134ck1610 FIND v(dout0_134) AT=810.025n

.meas tran vdout0_135ck1610 FIND v(dout0_135) AT=810.025n

.meas tran vdout0_136ck1610 FIND v(dout0_136) AT=810.025n

.meas tran vdout0_137ck1610 FIND v(dout0_137) AT=810.025n

.meas tran vdout0_138ck1610 FIND v(dout0_138) AT=810.025n

.meas tran vdout0_139ck1610 FIND v(dout0_139) AT=810.025n

.meas tran vdout0_140ck1610 FIND v(dout0_140) AT=810.025n

.meas tran vdout0_141ck1610 FIND v(dout0_141) AT=810.025n

.meas tran vdout0_142ck1610 FIND v(dout0_142) AT=810.025n

.meas tran vdout0_143ck1610 FIND v(dout0_143) AT=810.025n

.meas tran vdout0_144ck1610 FIND v(dout0_144) AT=810.025n

.meas tran vdout0_145ck1610 FIND v(dout0_145) AT=810.025n

.meas tran vdout0_146ck1610 FIND v(dout0_146) AT=810.025n

.meas tran vdout0_147ck1610 FIND v(dout0_147) AT=810.025n

.meas tran vdout0_148ck1610 FIND v(dout0_148) AT=810.025n

.meas tran vdout0_149ck1610 FIND v(dout0_149) AT=810.025n

.meas tran vdout0_0ck1620 FIND v(dout0_0) AT=815.025n

.meas tran vdout0_1ck1620 FIND v(dout0_1) AT=815.025n

.meas tran vdout0_2ck1620 FIND v(dout0_2) AT=815.025n

.meas tran vdout0_3ck1620 FIND v(dout0_3) AT=815.025n

.meas tran vdout0_4ck1620 FIND v(dout0_4) AT=815.025n

.meas tran vdout0_5ck1620 FIND v(dout0_5) AT=815.025n

.meas tran vdout0_6ck1620 FIND v(dout0_6) AT=815.025n

.meas tran vdout0_7ck1620 FIND v(dout0_7) AT=815.025n

.meas tran vdout0_8ck1620 FIND v(dout0_8) AT=815.025n

.meas tran vdout0_9ck1620 FIND v(dout0_9) AT=815.025n

.meas tran vdout0_10ck1620 FIND v(dout0_10) AT=815.025n

.meas tran vdout0_11ck1620 FIND v(dout0_11) AT=815.025n

.meas tran vdout0_12ck1620 FIND v(dout0_12) AT=815.025n

.meas tran vdout0_13ck1620 FIND v(dout0_13) AT=815.025n

.meas tran vdout0_14ck1620 FIND v(dout0_14) AT=815.025n

.meas tran vdout0_15ck1620 FIND v(dout0_15) AT=815.025n

.meas tran vdout0_16ck1620 FIND v(dout0_16) AT=815.025n

.meas tran vdout0_17ck1620 FIND v(dout0_17) AT=815.025n

.meas tran vdout0_18ck1620 FIND v(dout0_18) AT=815.025n

.meas tran vdout0_19ck1620 FIND v(dout0_19) AT=815.025n

.meas tran vdout0_20ck1620 FIND v(dout0_20) AT=815.025n

.meas tran vdout0_21ck1620 FIND v(dout0_21) AT=815.025n

.meas tran vdout0_22ck1620 FIND v(dout0_22) AT=815.025n

.meas tran vdout0_23ck1620 FIND v(dout0_23) AT=815.025n

.meas tran vdout0_24ck1620 FIND v(dout0_24) AT=815.025n

.meas tran vdout0_25ck1620 FIND v(dout0_25) AT=815.025n

.meas tran vdout0_26ck1620 FIND v(dout0_26) AT=815.025n

.meas tran vdout0_27ck1620 FIND v(dout0_27) AT=815.025n

.meas tran vdout0_28ck1620 FIND v(dout0_28) AT=815.025n

.meas tran vdout0_29ck1620 FIND v(dout0_29) AT=815.025n

.meas tran vdout0_30ck1620 FIND v(dout0_30) AT=815.025n

.meas tran vdout0_31ck1620 FIND v(dout0_31) AT=815.025n

.meas tran vdout0_32ck1620 FIND v(dout0_32) AT=815.025n

.meas tran vdout0_33ck1620 FIND v(dout0_33) AT=815.025n

.meas tran vdout0_34ck1620 FIND v(dout0_34) AT=815.025n

.meas tran vdout0_35ck1620 FIND v(dout0_35) AT=815.025n

.meas tran vdout0_36ck1620 FIND v(dout0_36) AT=815.025n

.meas tran vdout0_37ck1620 FIND v(dout0_37) AT=815.025n

.meas tran vdout0_38ck1620 FIND v(dout0_38) AT=815.025n

.meas tran vdout0_39ck1620 FIND v(dout0_39) AT=815.025n

.meas tran vdout0_40ck1620 FIND v(dout0_40) AT=815.025n

.meas tran vdout0_41ck1620 FIND v(dout0_41) AT=815.025n

.meas tran vdout0_42ck1620 FIND v(dout0_42) AT=815.025n

.meas tran vdout0_43ck1620 FIND v(dout0_43) AT=815.025n

.meas tran vdout0_44ck1620 FIND v(dout0_44) AT=815.025n

.meas tran vdout0_45ck1620 FIND v(dout0_45) AT=815.025n

.meas tran vdout0_46ck1620 FIND v(dout0_46) AT=815.025n

.meas tran vdout0_47ck1620 FIND v(dout0_47) AT=815.025n

.meas tran vdout0_48ck1620 FIND v(dout0_48) AT=815.025n

.meas tran vdout0_49ck1620 FIND v(dout0_49) AT=815.025n

.meas tran vdout0_50ck1620 FIND v(dout0_50) AT=815.025n

.meas tran vdout0_51ck1620 FIND v(dout0_51) AT=815.025n

.meas tran vdout0_52ck1620 FIND v(dout0_52) AT=815.025n

.meas tran vdout0_53ck1620 FIND v(dout0_53) AT=815.025n

.meas tran vdout0_54ck1620 FIND v(dout0_54) AT=815.025n

.meas tran vdout0_55ck1620 FIND v(dout0_55) AT=815.025n

.meas tran vdout0_56ck1620 FIND v(dout0_56) AT=815.025n

.meas tran vdout0_57ck1620 FIND v(dout0_57) AT=815.025n

.meas tran vdout0_58ck1620 FIND v(dout0_58) AT=815.025n

.meas tran vdout0_59ck1620 FIND v(dout0_59) AT=815.025n

.meas tran vdout0_60ck1620 FIND v(dout0_60) AT=815.025n

.meas tran vdout0_61ck1620 FIND v(dout0_61) AT=815.025n

.meas tran vdout0_62ck1620 FIND v(dout0_62) AT=815.025n

.meas tran vdout0_63ck1620 FIND v(dout0_63) AT=815.025n

.meas tran vdout0_64ck1620 FIND v(dout0_64) AT=815.025n

.meas tran vdout0_65ck1620 FIND v(dout0_65) AT=815.025n

.meas tran vdout0_66ck1620 FIND v(dout0_66) AT=815.025n

.meas tran vdout0_67ck1620 FIND v(dout0_67) AT=815.025n

.meas tran vdout0_68ck1620 FIND v(dout0_68) AT=815.025n

.meas tran vdout0_69ck1620 FIND v(dout0_69) AT=815.025n

.meas tran vdout0_70ck1620 FIND v(dout0_70) AT=815.025n

.meas tran vdout0_71ck1620 FIND v(dout0_71) AT=815.025n

.meas tran vdout0_72ck1620 FIND v(dout0_72) AT=815.025n

.meas tran vdout0_73ck1620 FIND v(dout0_73) AT=815.025n

.meas tran vdout0_74ck1620 FIND v(dout0_74) AT=815.025n

.meas tran vdout0_75ck1620 FIND v(dout0_75) AT=815.025n

.meas tran vdout0_76ck1620 FIND v(dout0_76) AT=815.025n

.meas tran vdout0_77ck1620 FIND v(dout0_77) AT=815.025n

.meas tran vdout0_78ck1620 FIND v(dout0_78) AT=815.025n

.meas tran vdout0_79ck1620 FIND v(dout0_79) AT=815.025n

.meas tran vdout0_80ck1620 FIND v(dout0_80) AT=815.025n

.meas tran vdout0_81ck1620 FIND v(dout0_81) AT=815.025n

.meas tran vdout0_82ck1620 FIND v(dout0_82) AT=815.025n

.meas tran vdout0_83ck1620 FIND v(dout0_83) AT=815.025n

.meas tran vdout0_84ck1620 FIND v(dout0_84) AT=815.025n

.meas tran vdout0_85ck1620 FIND v(dout0_85) AT=815.025n

.meas tran vdout0_86ck1620 FIND v(dout0_86) AT=815.025n

.meas tran vdout0_87ck1620 FIND v(dout0_87) AT=815.025n

.meas tran vdout0_88ck1620 FIND v(dout0_88) AT=815.025n

.meas tran vdout0_89ck1620 FIND v(dout0_89) AT=815.025n

.meas tran vdout0_90ck1620 FIND v(dout0_90) AT=815.025n

.meas tran vdout0_91ck1620 FIND v(dout0_91) AT=815.025n

.meas tran vdout0_92ck1620 FIND v(dout0_92) AT=815.025n

.meas tran vdout0_93ck1620 FIND v(dout0_93) AT=815.025n

.meas tran vdout0_94ck1620 FIND v(dout0_94) AT=815.025n

.meas tran vdout0_95ck1620 FIND v(dout0_95) AT=815.025n

.meas tran vdout0_96ck1620 FIND v(dout0_96) AT=815.025n

.meas tran vdout0_97ck1620 FIND v(dout0_97) AT=815.025n

.meas tran vdout0_98ck1620 FIND v(dout0_98) AT=815.025n

.meas tran vdout0_99ck1620 FIND v(dout0_99) AT=815.025n

.meas tran vdout0_100ck1620 FIND v(dout0_100) AT=815.025n

.meas tran vdout0_101ck1620 FIND v(dout0_101) AT=815.025n

.meas tran vdout0_102ck1620 FIND v(dout0_102) AT=815.025n

.meas tran vdout0_103ck1620 FIND v(dout0_103) AT=815.025n

.meas tran vdout0_104ck1620 FIND v(dout0_104) AT=815.025n

.meas tran vdout0_105ck1620 FIND v(dout0_105) AT=815.025n

.meas tran vdout0_106ck1620 FIND v(dout0_106) AT=815.025n

.meas tran vdout0_107ck1620 FIND v(dout0_107) AT=815.025n

.meas tran vdout0_108ck1620 FIND v(dout0_108) AT=815.025n

.meas tran vdout0_109ck1620 FIND v(dout0_109) AT=815.025n

.meas tran vdout0_110ck1620 FIND v(dout0_110) AT=815.025n

.meas tran vdout0_111ck1620 FIND v(dout0_111) AT=815.025n

.meas tran vdout0_112ck1620 FIND v(dout0_112) AT=815.025n

.meas tran vdout0_113ck1620 FIND v(dout0_113) AT=815.025n

.meas tran vdout0_114ck1620 FIND v(dout0_114) AT=815.025n

.meas tran vdout0_115ck1620 FIND v(dout0_115) AT=815.025n

.meas tran vdout0_116ck1620 FIND v(dout0_116) AT=815.025n

.meas tran vdout0_117ck1620 FIND v(dout0_117) AT=815.025n

.meas tran vdout0_118ck1620 FIND v(dout0_118) AT=815.025n

.meas tran vdout0_119ck1620 FIND v(dout0_119) AT=815.025n

.meas tran vdout0_120ck1620 FIND v(dout0_120) AT=815.025n

.meas tran vdout0_121ck1620 FIND v(dout0_121) AT=815.025n

.meas tran vdout0_122ck1620 FIND v(dout0_122) AT=815.025n

.meas tran vdout0_123ck1620 FIND v(dout0_123) AT=815.025n

.meas tran vdout0_124ck1620 FIND v(dout0_124) AT=815.025n

.meas tran vdout0_125ck1620 FIND v(dout0_125) AT=815.025n

.meas tran vdout0_126ck1620 FIND v(dout0_126) AT=815.025n

.meas tran vdout0_127ck1620 FIND v(dout0_127) AT=815.025n

.meas tran vdout0_128ck1620 FIND v(dout0_128) AT=815.025n

.meas tran vdout0_129ck1620 FIND v(dout0_129) AT=815.025n

.meas tran vdout0_130ck1620 FIND v(dout0_130) AT=815.025n

.meas tran vdout0_131ck1620 FIND v(dout0_131) AT=815.025n

.meas tran vdout0_132ck1620 FIND v(dout0_132) AT=815.025n

.meas tran vdout0_133ck1620 FIND v(dout0_133) AT=815.025n

.meas tran vdout0_134ck1620 FIND v(dout0_134) AT=815.025n

.meas tran vdout0_135ck1620 FIND v(dout0_135) AT=815.025n

.meas tran vdout0_136ck1620 FIND v(dout0_136) AT=815.025n

.meas tran vdout0_137ck1620 FIND v(dout0_137) AT=815.025n

.meas tran vdout0_138ck1620 FIND v(dout0_138) AT=815.025n

.meas tran vdout0_139ck1620 FIND v(dout0_139) AT=815.025n

.meas tran vdout0_140ck1620 FIND v(dout0_140) AT=815.025n

.meas tran vdout0_141ck1620 FIND v(dout0_141) AT=815.025n

.meas tran vdout0_142ck1620 FIND v(dout0_142) AT=815.025n

.meas tran vdout0_143ck1620 FIND v(dout0_143) AT=815.025n

.meas tran vdout0_144ck1620 FIND v(dout0_144) AT=815.025n

.meas tran vdout0_145ck1620 FIND v(dout0_145) AT=815.025n

.meas tran vdout0_146ck1620 FIND v(dout0_146) AT=815.025n

.meas tran vdout0_147ck1620 FIND v(dout0_147) AT=815.025n

.meas tran vdout0_148ck1620 FIND v(dout0_148) AT=815.025n

.meas tran vdout0_149ck1620 FIND v(dout0_149) AT=815.025n

.meas tran vdout0_0ck1640 FIND v(dout0_0) AT=825.025n

.meas tran vdout0_1ck1640 FIND v(dout0_1) AT=825.025n

.meas tran vdout0_2ck1640 FIND v(dout0_2) AT=825.025n

.meas tran vdout0_3ck1640 FIND v(dout0_3) AT=825.025n

.meas tran vdout0_4ck1640 FIND v(dout0_4) AT=825.025n

.meas tran vdout0_5ck1640 FIND v(dout0_5) AT=825.025n

.meas tran vdout0_6ck1640 FIND v(dout0_6) AT=825.025n

.meas tran vdout0_7ck1640 FIND v(dout0_7) AT=825.025n

.meas tran vdout0_8ck1640 FIND v(dout0_8) AT=825.025n

.meas tran vdout0_9ck1640 FIND v(dout0_9) AT=825.025n

.meas tran vdout0_10ck1640 FIND v(dout0_10) AT=825.025n

.meas tran vdout0_11ck1640 FIND v(dout0_11) AT=825.025n

.meas tran vdout0_12ck1640 FIND v(dout0_12) AT=825.025n

.meas tran vdout0_13ck1640 FIND v(dout0_13) AT=825.025n

.meas tran vdout0_14ck1640 FIND v(dout0_14) AT=825.025n

.meas tran vdout0_15ck1640 FIND v(dout0_15) AT=825.025n

.meas tran vdout0_16ck1640 FIND v(dout0_16) AT=825.025n

.meas tran vdout0_17ck1640 FIND v(dout0_17) AT=825.025n

.meas tran vdout0_18ck1640 FIND v(dout0_18) AT=825.025n

.meas tran vdout0_19ck1640 FIND v(dout0_19) AT=825.025n

.meas tran vdout0_20ck1640 FIND v(dout0_20) AT=825.025n

.meas tran vdout0_21ck1640 FIND v(dout0_21) AT=825.025n

.meas tran vdout0_22ck1640 FIND v(dout0_22) AT=825.025n

.meas tran vdout0_23ck1640 FIND v(dout0_23) AT=825.025n

.meas tran vdout0_24ck1640 FIND v(dout0_24) AT=825.025n

.meas tran vdout0_25ck1640 FIND v(dout0_25) AT=825.025n

.meas tran vdout0_26ck1640 FIND v(dout0_26) AT=825.025n

.meas tran vdout0_27ck1640 FIND v(dout0_27) AT=825.025n

.meas tran vdout0_28ck1640 FIND v(dout0_28) AT=825.025n

.meas tran vdout0_29ck1640 FIND v(dout0_29) AT=825.025n

.meas tran vdout0_30ck1640 FIND v(dout0_30) AT=825.025n

.meas tran vdout0_31ck1640 FIND v(dout0_31) AT=825.025n

.meas tran vdout0_32ck1640 FIND v(dout0_32) AT=825.025n

.meas tran vdout0_33ck1640 FIND v(dout0_33) AT=825.025n

.meas tran vdout0_34ck1640 FIND v(dout0_34) AT=825.025n

.meas tran vdout0_35ck1640 FIND v(dout0_35) AT=825.025n

.meas tran vdout0_36ck1640 FIND v(dout0_36) AT=825.025n

.meas tran vdout0_37ck1640 FIND v(dout0_37) AT=825.025n

.meas tran vdout0_38ck1640 FIND v(dout0_38) AT=825.025n

.meas tran vdout0_39ck1640 FIND v(dout0_39) AT=825.025n

.meas tran vdout0_40ck1640 FIND v(dout0_40) AT=825.025n

.meas tran vdout0_41ck1640 FIND v(dout0_41) AT=825.025n

.meas tran vdout0_42ck1640 FIND v(dout0_42) AT=825.025n

.meas tran vdout0_43ck1640 FIND v(dout0_43) AT=825.025n

.meas tran vdout0_44ck1640 FIND v(dout0_44) AT=825.025n

.meas tran vdout0_45ck1640 FIND v(dout0_45) AT=825.025n

.meas tran vdout0_46ck1640 FIND v(dout0_46) AT=825.025n

.meas tran vdout0_47ck1640 FIND v(dout0_47) AT=825.025n

.meas tran vdout0_48ck1640 FIND v(dout0_48) AT=825.025n

.meas tran vdout0_49ck1640 FIND v(dout0_49) AT=825.025n

.meas tran vdout0_50ck1640 FIND v(dout0_50) AT=825.025n

.meas tran vdout0_51ck1640 FIND v(dout0_51) AT=825.025n

.meas tran vdout0_52ck1640 FIND v(dout0_52) AT=825.025n

.meas tran vdout0_53ck1640 FIND v(dout0_53) AT=825.025n

.meas tran vdout0_54ck1640 FIND v(dout0_54) AT=825.025n

.meas tran vdout0_55ck1640 FIND v(dout0_55) AT=825.025n

.meas tran vdout0_56ck1640 FIND v(dout0_56) AT=825.025n

.meas tran vdout0_57ck1640 FIND v(dout0_57) AT=825.025n

.meas tran vdout0_58ck1640 FIND v(dout0_58) AT=825.025n

.meas tran vdout0_59ck1640 FIND v(dout0_59) AT=825.025n

.meas tran vdout0_60ck1640 FIND v(dout0_60) AT=825.025n

.meas tran vdout0_61ck1640 FIND v(dout0_61) AT=825.025n

.meas tran vdout0_62ck1640 FIND v(dout0_62) AT=825.025n

.meas tran vdout0_63ck1640 FIND v(dout0_63) AT=825.025n

.meas tran vdout0_64ck1640 FIND v(dout0_64) AT=825.025n

.meas tran vdout0_65ck1640 FIND v(dout0_65) AT=825.025n

.meas tran vdout0_66ck1640 FIND v(dout0_66) AT=825.025n

.meas tran vdout0_67ck1640 FIND v(dout0_67) AT=825.025n

.meas tran vdout0_68ck1640 FIND v(dout0_68) AT=825.025n

.meas tran vdout0_69ck1640 FIND v(dout0_69) AT=825.025n

.meas tran vdout0_70ck1640 FIND v(dout0_70) AT=825.025n

.meas tran vdout0_71ck1640 FIND v(dout0_71) AT=825.025n

.meas tran vdout0_72ck1640 FIND v(dout0_72) AT=825.025n

.meas tran vdout0_73ck1640 FIND v(dout0_73) AT=825.025n

.meas tran vdout0_74ck1640 FIND v(dout0_74) AT=825.025n

.meas tran vdout0_75ck1640 FIND v(dout0_75) AT=825.025n

.meas tran vdout0_76ck1640 FIND v(dout0_76) AT=825.025n

.meas tran vdout0_77ck1640 FIND v(dout0_77) AT=825.025n

.meas tran vdout0_78ck1640 FIND v(dout0_78) AT=825.025n

.meas tran vdout0_79ck1640 FIND v(dout0_79) AT=825.025n

.meas tran vdout0_80ck1640 FIND v(dout0_80) AT=825.025n

.meas tran vdout0_81ck1640 FIND v(dout0_81) AT=825.025n

.meas tran vdout0_82ck1640 FIND v(dout0_82) AT=825.025n

.meas tran vdout0_83ck1640 FIND v(dout0_83) AT=825.025n

.meas tran vdout0_84ck1640 FIND v(dout0_84) AT=825.025n

.meas tran vdout0_85ck1640 FIND v(dout0_85) AT=825.025n

.meas tran vdout0_86ck1640 FIND v(dout0_86) AT=825.025n

.meas tran vdout0_87ck1640 FIND v(dout0_87) AT=825.025n

.meas tran vdout0_88ck1640 FIND v(dout0_88) AT=825.025n

.meas tran vdout0_89ck1640 FIND v(dout0_89) AT=825.025n

.meas tran vdout0_90ck1640 FIND v(dout0_90) AT=825.025n

.meas tran vdout0_91ck1640 FIND v(dout0_91) AT=825.025n

.meas tran vdout0_92ck1640 FIND v(dout0_92) AT=825.025n

.meas tran vdout0_93ck1640 FIND v(dout0_93) AT=825.025n

.meas tran vdout0_94ck1640 FIND v(dout0_94) AT=825.025n

.meas tran vdout0_95ck1640 FIND v(dout0_95) AT=825.025n

.meas tran vdout0_96ck1640 FIND v(dout0_96) AT=825.025n

.meas tran vdout0_97ck1640 FIND v(dout0_97) AT=825.025n

.meas tran vdout0_98ck1640 FIND v(dout0_98) AT=825.025n

.meas tran vdout0_99ck1640 FIND v(dout0_99) AT=825.025n

.meas tran vdout0_100ck1640 FIND v(dout0_100) AT=825.025n

.meas tran vdout0_101ck1640 FIND v(dout0_101) AT=825.025n

.meas tran vdout0_102ck1640 FIND v(dout0_102) AT=825.025n

.meas tran vdout0_103ck1640 FIND v(dout0_103) AT=825.025n

.meas tran vdout0_104ck1640 FIND v(dout0_104) AT=825.025n

.meas tran vdout0_105ck1640 FIND v(dout0_105) AT=825.025n

.meas tran vdout0_106ck1640 FIND v(dout0_106) AT=825.025n

.meas tran vdout0_107ck1640 FIND v(dout0_107) AT=825.025n

.meas tran vdout0_108ck1640 FIND v(dout0_108) AT=825.025n

.meas tran vdout0_109ck1640 FIND v(dout0_109) AT=825.025n

.meas tran vdout0_110ck1640 FIND v(dout0_110) AT=825.025n

.meas tran vdout0_111ck1640 FIND v(dout0_111) AT=825.025n

.meas tran vdout0_112ck1640 FIND v(dout0_112) AT=825.025n

.meas tran vdout0_113ck1640 FIND v(dout0_113) AT=825.025n

.meas tran vdout0_114ck1640 FIND v(dout0_114) AT=825.025n

.meas tran vdout0_115ck1640 FIND v(dout0_115) AT=825.025n

.meas tran vdout0_116ck1640 FIND v(dout0_116) AT=825.025n

.meas tran vdout0_117ck1640 FIND v(dout0_117) AT=825.025n

.meas tran vdout0_118ck1640 FIND v(dout0_118) AT=825.025n

.meas tran vdout0_119ck1640 FIND v(dout0_119) AT=825.025n

.meas tran vdout0_120ck1640 FIND v(dout0_120) AT=825.025n

.meas tran vdout0_121ck1640 FIND v(dout0_121) AT=825.025n

.meas tran vdout0_122ck1640 FIND v(dout0_122) AT=825.025n

.meas tran vdout0_123ck1640 FIND v(dout0_123) AT=825.025n

.meas tran vdout0_124ck1640 FIND v(dout0_124) AT=825.025n

.meas tran vdout0_125ck1640 FIND v(dout0_125) AT=825.025n

.meas tran vdout0_126ck1640 FIND v(dout0_126) AT=825.025n

.meas tran vdout0_127ck1640 FIND v(dout0_127) AT=825.025n

.meas tran vdout0_128ck1640 FIND v(dout0_128) AT=825.025n

.meas tran vdout0_129ck1640 FIND v(dout0_129) AT=825.025n

.meas tran vdout0_130ck1640 FIND v(dout0_130) AT=825.025n

.meas tran vdout0_131ck1640 FIND v(dout0_131) AT=825.025n

.meas tran vdout0_132ck1640 FIND v(dout0_132) AT=825.025n

.meas tran vdout0_133ck1640 FIND v(dout0_133) AT=825.025n

.meas tran vdout0_134ck1640 FIND v(dout0_134) AT=825.025n

.meas tran vdout0_135ck1640 FIND v(dout0_135) AT=825.025n

.meas tran vdout0_136ck1640 FIND v(dout0_136) AT=825.025n

.meas tran vdout0_137ck1640 FIND v(dout0_137) AT=825.025n

.meas tran vdout0_138ck1640 FIND v(dout0_138) AT=825.025n

.meas tran vdout0_139ck1640 FIND v(dout0_139) AT=825.025n

.meas tran vdout0_140ck1640 FIND v(dout0_140) AT=825.025n

.meas tran vdout0_141ck1640 FIND v(dout0_141) AT=825.025n

.meas tran vdout0_142ck1640 FIND v(dout0_142) AT=825.025n

.meas tran vdout0_143ck1640 FIND v(dout0_143) AT=825.025n

.meas tran vdout0_144ck1640 FIND v(dout0_144) AT=825.025n

.meas tran vdout0_145ck1640 FIND v(dout0_145) AT=825.025n

.meas tran vdout0_146ck1640 FIND v(dout0_146) AT=825.025n

.meas tran vdout0_147ck1640 FIND v(dout0_147) AT=825.025n

.meas tran vdout0_148ck1640 FIND v(dout0_148) AT=825.025n

.meas tran vdout0_149ck1640 FIND v(dout0_149) AT=825.025n

.meas tran vdout0_0ck1660 FIND v(dout0_0) AT=835.025n

.meas tran vdout0_1ck1660 FIND v(dout0_1) AT=835.025n

.meas tran vdout0_2ck1660 FIND v(dout0_2) AT=835.025n

.meas tran vdout0_3ck1660 FIND v(dout0_3) AT=835.025n

.meas tran vdout0_4ck1660 FIND v(dout0_4) AT=835.025n

.meas tran vdout0_5ck1660 FIND v(dout0_5) AT=835.025n

.meas tran vdout0_6ck1660 FIND v(dout0_6) AT=835.025n

.meas tran vdout0_7ck1660 FIND v(dout0_7) AT=835.025n

.meas tran vdout0_8ck1660 FIND v(dout0_8) AT=835.025n

.meas tran vdout0_9ck1660 FIND v(dout0_9) AT=835.025n

.meas tran vdout0_10ck1660 FIND v(dout0_10) AT=835.025n

.meas tran vdout0_11ck1660 FIND v(dout0_11) AT=835.025n

.meas tran vdout0_12ck1660 FIND v(dout0_12) AT=835.025n

.meas tran vdout0_13ck1660 FIND v(dout0_13) AT=835.025n

.meas tran vdout0_14ck1660 FIND v(dout0_14) AT=835.025n

.meas tran vdout0_15ck1660 FIND v(dout0_15) AT=835.025n

.meas tran vdout0_16ck1660 FIND v(dout0_16) AT=835.025n

.meas tran vdout0_17ck1660 FIND v(dout0_17) AT=835.025n

.meas tran vdout0_18ck1660 FIND v(dout0_18) AT=835.025n

.meas tran vdout0_19ck1660 FIND v(dout0_19) AT=835.025n

.meas tran vdout0_20ck1660 FIND v(dout0_20) AT=835.025n

.meas tran vdout0_21ck1660 FIND v(dout0_21) AT=835.025n

.meas tran vdout0_22ck1660 FIND v(dout0_22) AT=835.025n

.meas tran vdout0_23ck1660 FIND v(dout0_23) AT=835.025n

.meas tran vdout0_24ck1660 FIND v(dout0_24) AT=835.025n

.meas tran vdout0_25ck1660 FIND v(dout0_25) AT=835.025n

.meas tran vdout0_26ck1660 FIND v(dout0_26) AT=835.025n

.meas tran vdout0_27ck1660 FIND v(dout0_27) AT=835.025n

.meas tran vdout0_28ck1660 FIND v(dout0_28) AT=835.025n

.meas tran vdout0_29ck1660 FIND v(dout0_29) AT=835.025n

.meas tran vdout0_30ck1660 FIND v(dout0_30) AT=835.025n

.meas tran vdout0_31ck1660 FIND v(dout0_31) AT=835.025n

.meas tran vdout0_32ck1660 FIND v(dout0_32) AT=835.025n

.meas tran vdout0_33ck1660 FIND v(dout0_33) AT=835.025n

.meas tran vdout0_34ck1660 FIND v(dout0_34) AT=835.025n

.meas tran vdout0_35ck1660 FIND v(dout0_35) AT=835.025n

.meas tran vdout0_36ck1660 FIND v(dout0_36) AT=835.025n

.meas tran vdout0_37ck1660 FIND v(dout0_37) AT=835.025n

.meas tran vdout0_38ck1660 FIND v(dout0_38) AT=835.025n

.meas tran vdout0_39ck1660 FIND v(dout0_39) AT=835.025n

.meas tran vdout0_40ck1660 FIND v(dout0_40) AT=835.025n

.meas tran vdout0_41ck1660 FIND v(dout0_41) AT=835.025n

.meas tran vdout0_42ck1660 FIND v(dout0_42) AT=835.025n

.meas tran vdout0_43ck1660 FIND v(dout0_43) AT=835.025n

.meas tran vdout0_44ck1660 FIND v(dout0_44) AT=835.025n

.meas tran vdout0_45ck1660 FIND v(dout0_45) AT=835.025n

.meas tran vdout0_46ck1660 FIND v(dout0_46) AT=835.025n

.meas tran vdout0_47ck1660 FIND v(dout0_47) AT=835.025n

.meas tran vdout0_48ck1660 FIND v(dout0_48) AT=835.025n

.meas tran vdout0_49ck1660 FIND v(dout0_49) AT=835.025n

.meas tran vdout0_50ck1660 FIND v(dout0_50) AT=835.025n

.meas tran vdout0_51ck1660 FIND v(dout0_51) AT=835.025n

.meas tran vdout0_52ck1660 FIND v(dout0_52) AT=835.025n

.meas tran vdout0_53ck1660 FIND v(dout0_53) AT=835.025n

.meas tran vdout0_54ck1660 FIND v(dout0_54) AT=835.025n

.meas tran vdout0_55ck1660 FIND v(dout0_55) AT=835.025n

.meas tran vdout0_56ck1660 FIND v(dout0_56) AT=835.025n

.meas tran vdout0_57ck1660 FIND v(dout0_57) AT=835.025n

.meas tran vdout0_58ck1660 FIND v(dout0_58) AT=835.025n

.meas tran vdout0_59ck1660 FIND v(dout0_59) AT=835.025n

.meas tran vdout0_60ck1660 FIND v(dout0_60) AT=835.025n

.meas tran vdout0_61ck1660 FIND v(dout0_61) AT=835.025n

.meas tran vdout0_62ck1660 FIND v(dout0_62) AT=835.025n

.meas tran vdout0_63ck1660 FIND v(dout0_63) AT=835.025n

.meas tran vdout0_64ck1660 FIND v(dout0_64) AT=835.025n

.meas tran vdout0_65ck1660 FIND v(dout0_65) AT=835.025n

.meas tran vdout0_66ck1660 FIND v(dout0_66) AT=835.025n

.meas tran vdout0_67ck1660 FIND v(dout0_67) AT=835.025n

.meas tran vdout0_68ck1660 FIND v(dout0_68) AT=835.025n

.meas tran vdout0_69ck1660 FIND v(dout0_69) AT=835.025n

.meas tran vdout0_70ck1660 FIND v(dout0_70) AT=835.025n

.meas tran vdout0_71ck1660 FIND v(dout0_71) AT=835.025n

.meas tran vdout0_72ck1660 FIND v(dout0_72) AT=835.025n

.meas tran vdout0_73ck1660 FIND v(dout0_73) AT=835.025n

.meas tran vdout0_74ck1660 FIND v(dout0_74) AT=835.025n

.meas tran vdout0_75ck1660 FIND v(dout0_75) AT=835.025n

.meas tran vdout0_76ck1660 FIND v(dout0_76) AT=835.025n

.meas tran vdout0_77ck1660 FIND v(dout0_77) AT=835.025n

.meas tran vdout0_78ck1660 FIND v(dout0_78) AT=835.025n

.meas tran vdout0_79ck1660 FIND v(dout0_79) AT=835.025n

.meas tran vdout0_80ck1660 FIND v(dout0_80) AT=835.025n

.meas tran vdout0_81ck1660 FIND v(dout0_81) AT=835.025n

.meas tran vdout0_82ck1660 FIND v(dout0_82) AT=835.025n

.meas tran vdout0_83ck1660 FIND v(dout0_83) AT=835.025n

.meas tran vdout0_84ck1660 FIND v(dout0_84) AT=835.025n

.meas tran vdout0_85ck1660 FIND v(dout0_85) AT=835.025n

.meas tran vdout0_86ck1660 FIND v(dout0_86) AT=835.025n

.meas tran vdout0_87ck1660 FIND v(dout0_87) AT=835.025n

.meas tran vdout0_88ck1660 FIND v(dout0_88) AT=835.025n

.meas tran vdout0_89ck1660 FIND v(dout0_89) AT=835.025n

.meas tran vdout0_90ck1660 FIND v(dout0_90) AT=835.025n

.meas tran vdout0_91ck1660 FIND v(dout0_91) AT=835.025n

.meas tran vdout0_92ck1660 FIND v(dout0_92) AT=835.025n

.meas tran vdout0_93ck1660 FIND v(dout0_93) AT=835.025n

.meas tran vdout0_94ck1660 FIND v(dout0_94) AT=835.025n

.meas tran vdout0_95ck1660 FIND v(dout0_95) AT=835.025n

.meas tran vdout0_96ck1660 FIND v(dout0_96) AT=835.025n

.meas tran vdout0_97ck1660 FIND v(dout0_97) AT=835.025n

.meas tran vdout0_98ck1660 FIND v(dout0_98) AT=835.025n

.meas tran vdout0_99ck1660 FIND v(dout0_99) AT=835.025n

.meas tran vdout0_100ck1660 FIND v(dout0_100) AT=835.025n

.meas tran vdout0_101ck1660 FIND v(dout0_101) AT=835.025n

.meas tran vdout0_102ck1660 FIND v(dout0_102) AT=835.025n

.meas tran vdout0_103ck1660 FIND v(dout0_103) AT=835.025n

.meas tran vdout0_104ck1660 FIND v(dout0_104) AT=835.025n

.meas tran vdout0_105ck1660 FIND v(dout0_105) AT=835.025n

.meas tran vdout0_106ck1660 FIND v(dout0_106) AT=835.025n

.meas tran vdout0_107ck1660 FIND v(dout0_107) AT=835.025n

.meas tran vdout0_108ck1660 FIND v(dout0_108) AT=835.025n

.meas tran vdout0_109ck1660 FIND v(dout0_109) AT=835.025n

.meas tran vdout0_110ck1660 FIND v(dout0_110) AT=835.025n

.meas tran vdout0_111ck1660 FIND v(dout0_111) AT=835.025n

.meas tran vdout0_112ck1660 FIND v(dout0_112) AT=835.025n

.meas tran vdout0_113ck1660 FIND v(dout0_113) AT=835.025n

.meas tran vdout0_114ck1660 FIND v(dout0_114) AT=835.025n

.meas tran vdout0_115ck1660 FIND v(dout0_115) AT=835.025n

.meas tran vdout0_116ck1660 FIND v(dout0_116) AT=835.025n

.meas tran vdout0_117ck1660 FIND v(dout0_117) AT=835.025n

.meas tran vdout0_118ck1660 FIND v(dout0_118) AT=835.025n

.meas tran vdout0_119ck1660 FIND v(dout0_119) AT=835.025n

.meas tran vdout0_120ck1660 FIND v(dout0_120) AT=835.025n

.meas tran vdout0_121ck1660 FIND v(dout0_121) AT=835.025n

.meas tran vdout0_122ck1660 FIND v(dout0_122) AT=835.025n

.meas tran vdout0_123ck1660 FIND v(dout0_123) AT=835.025n

.meas tran vdout0_124ck1660 FIND v(dout0_124) AT=835.025n

.meas tran vdout0_125ck1660 FIND v(dout0_125) AT=835.025n

.meas tran vdout0_126ck1660 FIND v(dout0_126) AT=835.025n

.meas tran vdout0_127ck1660 FIND v(dout0_127) AT=835.025n

.meas tran vdout0_128ck1660 FIND v(dout0_128) AT=835.025n

.meas tran vdout0_129ck1660 FIND v(dout0_129) AT=835.025n

.meas tran vdout0_130ck1660 FIND v(dout0_130) AT=835.025n

.meas tran vdout0_131ck1660 FIND v(dout0_131) AT=835.025n

.meas tran vdout0_132ck1660 FIND v(dout0_132) AT=835.025n

.meas tran vdout0_133ck1660 FIND v(dout0_133) AT=835.025n

.meas tran vdout0_134ck1660 FIND v(dout0_134) AT=835.025n

.meas tran vdout0_135ck1660 FIND v(dout0_135) AT=835.025n

.meas tran vdout0_136ck1660 FIND v(dout0_136) AT=835.025n

.meas tran vdout0_137ck1660 FIND v(dout0_137) AT=835.025n

.meas tran vdout0_138ck1660 FIND v(dout0_138) AT=835.025n

.meas tran vdout0_139ck1660 FIND v(dout0_139) AT=835.025n

.meas tran vdout0_140ck1660 FIND v(dout0_140) AT=835.025n

.meas tran vdout0_141ck1660 FIND v(dout0_141) AT=835.025n

.meas tran vdout0_142ck1660 FIND v(dout0_142) AT=835.025n

.meas tran vdout0_143ck1660 FIND v(dout0_143) AT=835.025n

.meas tran vdout0_144ck1660 FIND v(dout0_144) AT=835.025n

.meas tran vdout0_145ck1660 FIND v(dout0_145) AT=835.025n

.meas tran vdout0_146ck1660 FIND v(dout0_146) AT=835.025n

.meas tran vdout0_147ck1660 FIND v(dout0_147) AT=835.025n

.meas tran vdout0_148ck1660 FIND v(dout0_148) AT=835.025n

.meas tran vdout0_149ck1660 FIND v(dout0_149) AT=835.025n

.meas tran vdout0_0ck1670 FIND v(dout0_0) AT=840.025n

.meas tran vdout0_1ck1670 FIND v(dout0_1) AT=840.025n

.meas tran vdout0_2ck1670 FIND v(dout0_2) AT=840.025n

.meas tran vdout0_3ck1670 FIND v(dout0_3) AT=840.025n

.meas tran vdout0_4ck1670 FIND v(dout0_4) AT=840.025n

.meas tran vdout0_5ck1670 FIND v(dout0_5) AT=840.025n

.meas tran vdout0_6ck1670 FIND v(dout0_6) AT=840.025n

.meas tran vdout0_7ck1670 FIND v(dout0_7) AT=840.025n

.meas tran vdout0_8ck1670 FIND v(dout0_8) AT=840.025n

.meas tran vdout0_9ck1670 FIND v(dout0_9) AT=840.025n

.meas tran vdout0_10ck1670 FIND v(dout0_10) AT=840.025n

.meas tran vdout0_11ck1670 FIND v(dout0_11) AT=840.025n

.meas tran vdout0_12ck1670 FIND v(dout0_12) AT=840.025n

.meas tran vdout0_13ck1670 FIND v(dout0_13) AT=840.025n

.meas tran vdout0_14ck1670 FIND v(dout0_14) AT=840.025n

.meas tran vdout0_15ck1670 FIND v(dout0_15) AT=840.025n

.meas tran vdout0_16ck1670 FIND v(dout0_16) AT=840.025n

.meas tran vdout0_17ck1670 FIND v(dout0_17) AT=840.025n

.meas tran vdout0_18ck1670 FIND v(dout0_18) AT=840.025n

.meas tran vdout0_19ck1670 FIND v(dout0_19) AT=840.025n

.meas tran vdout0_20ck1670 FIND v(dout0_20) AT=840.025n

.meas tran vdout0_21ck1670 FIND v(dout0_21) AT=840.025n

.meas tran vdout0_22ck1670 FIND v(dout0_22) AT=840.025n

.meas tran vdout0_23ck1670 FIND v(dout0_23) AT=840.025n

.meas tran vdout0_24ck1670 FIND v(dout0_24) AT=840.025n

.meas tran vdout0_25ck1670 FIND v(dout0_25) AT=840.025n

.meas tran vdout0_26ck1670 FIND v(dout0_26) AT=840.025n

.meas tran vdout0_27ck1670 FIND v(dout0_27) AT=840.025n

.meas tran vdout0_28ck1670 FIND v(dout0_28) AT=840.025n

.meas tran vdout0_29ck1670 FIND v(dout0_29) AT=840.025n

.meas tran vdout0_30ck1670 FIND v(dout0_30) AT=840.025n

.meas tran vdout0_31ck1670 FIND v(dout0_31) AT=840.025n

.meas tran vdout0_32ck1670 FIND v(dout0_32) AT=840.025n

.meas tran vdout0_33ck1670 FIND v(dout0_33) AT=840.025n

.meas tran vdout0_34ck1670 FIND v(dout0_34) AT=840.025n

.meas tran vdout0_35ck1670 FIND v(dout0_35) AT=840.025n

.meas tran vdout0_36ck1670 FIND v(dout0_36) AT=840.025n

.meas tran vdout0_37ck1670 FIND v(dout0_37) AT=840.025n

.meas tran vdout0_38ck1670 FIND v(dout0_38) AT=840.025n

.meas tran vdout0_39ck1670 FIND v(dout0_39) AT=840.025n

.meas tran vdout0_40ck1670 FIND v(dout0_40) AT=840.025n

.meas tran vdout0_41ck1670 FIND v(dout0_41) AT=840.025n

.meas tran vdout0_42ck1670 FIND v(dout0_42) AT=840.025n

.meas tran vdout0_43ck1670 FIND v(dout0_43) AT=840.025n

.meas tran vdout0_44ck1670 FIND v(dout0_44) AT=840.025n

.meas tran vdout0_45ck1670 FIND v(dout0_45) AT=840.025n

.meas tran vdout0_46ck1670 FIND v(dout0_46) AT=840.025n

.meas tran vdout0_47ck1670 FIND v(dout0_47) AT=840.025n

.meas tran vdout0_48ck1670 FIND v(dout0_48) AT=840.025n

.meas tran vdout0_49ck1670 FIND v(dout0_49) AT=840.025n

.meas tran vdout0_50ck1670 FIND v(dout0_50) AT=840.025n

.meas tran vdout0_51ck1670 FIND v(dout0_51) AT=840.025n

.meas tran vdout0_52ck1670 FIND v(dout0_52) AT=840.025n

.meas tran vdout0_53ck1670 FIND v(dout0_53) AT=840.025n

.meas tran vdout0_54ck1670 FIND v(dout0_54) AT=840.025n

.meas tran vdout0_55ck1670 FIND v(dout0_55) AT=840.025n

.meas tran vdout0_56ck1670 FIND v(dout0_56) AT=840.025n

.meas tran vdout0_57ck1670 FIND v(dout0_57) AT=840.025n

.meas tran vdout0_58ck1670 FIND v(dout0_58) AT=840.025n

.meas tran vdout0_59ck1670 FIND v(dout0_59) AT=840.025n

.meas tran vdout0_60ck1670 FIND v(dout0_60) AT=840.025n

.meas tran vdout0_61ck1670 FIND v(dout0_61) AT=840.025n

.meas tran vdout0_62ck1670 FIND v(dout0_62) AT=840.025n

.meas tran vdout0_63ck1670 FIND v(dout0_63) AT=840.025n

.meas tran vdout0_64ck1670 FIND v(dout0_64) AT=840.025n

.meas tran vdout0_65ck1670 FIND v(dout0_65) AT=840.025n

.meas tran vdout0_66ck1670 FIND v(dout0_66) AT=840.025n

.meas tran vdout0_67ck1670 FIND v(dout0_67) AT=840.025n

.meas tran vdout0_68ck1670 FIND v(dout0_68) AT=840.025n

.meas tran vdout0_69ck1670 FIND v(dout0_69) AT=840.025n

.meas tran vdout0_70ck1670 FIND v(dout0_70) AT=840.025n

.meas tran vdout0_71ck1670 FIND v(dout0_71) AT=840.025n

.meas tran vdout0_72ck1670 FIND v(dout0_72) AT=840.025n

.meas tran vdout0_73ck1670 FIND v(dout0_73) AT=840.025n

.meas tran vdout0_74ck1670 FIND v(dout0_74) AT=840.025n

.meas tran vdout0_75ck1670 FIND v(dout0_75) AT=840.025n

.meas tran vdout0_76ck1670 FIND v(dout0_76) AT=840.025n

.meas tran vdout0_77ck1670 FIND v(dout0_77) AT=840.025n

.meas tran vdout0_78ck1670 FIND v(dout0_78) AT=840.025n

.meas tran vdout0_79ck1670 FIND v(dout0_79) AT=840.025n

.meas tran vdout0_80ck1670 FIND v(dout0_80) AT=840.025n

.meas tran vdout0_81ck1670 FIND v(dout0_81) AT=840.025n

.meas tran vdout0_82ck1670 FIND v(dout0_82) AT=840.025n

.meas tran vdout0_83ck1670 FIND v(dout0_83) AT=840.025n

.meas tran vdout0_84ck1670 FIND v(dout0_84) AT=840.025n

.meas tran vdout0_85ck1670 FIND v(dout0_85) AT=840.025n

.meas tran vdout0_86ck1670 FIND v(dout0_86) AT=840.025n

.meas tran vdout0_87ck1670 FIND v(dout0_87) AT=840.025n

.meas tran vdout0_88ck1670 FIND v(dout0_88) AT=840.025n

.meas tran vdout0_89ck1670 FIND v(dout0_89) AT=840.025n

.meas tran vdout0_90ck1670 FIND v(dout0_90) AT=840.025n

.meas tran vdout0_91ck1670 FIND v(dout0_91) AT=840.025n

.meas tran vdout0_92ck1670 FIND v(dout0_92) AT=840.025n

.meas tran vdout0_93ck1670 FIND v(dout0_93) AT=840.025n

.meas tran vdout0_94ck1670 FIND v(dout0_94) AT=840.025n

.meas tran vdout0_95ck1670 FIND v(dout0_95) AT=840.025n

.meas tran vdout0_96ck1670 FIND v(dout0_96) AT=840.025n

.meas tran vdout0_97ck1670 FIND v(dout0_97) AT=840.025n

.meas tran vdout0_98ck1670 FIND v(dout0_98) AT=840.025n

.meas tran vdout0_99ck1670 FIND v(dout0_99) AT=840.025n

.meas tran vdout0_100ck1670 FIND v(dout0_100) AT=840.025n

.meas tran vdout0_101ck1670 FIND v(dout0_101) AT=840.025n

.meas tran vdout0_102ck1670 FIND v(dout0_102) AT=840.025n

.meas tran vdout0_103ck1670 FIND v(dout0_103) AT=840.025n

.meas tran vdout0_104ck1670 FIND v(dout0_104) AT=840.025n

.meas tran vdout0_105ck1670 FIND v(dout0_105) AT=840.025n

.meas tran vdout0_106ck1670 FIND v(dout0_106) AT=840.025n

.meas tran vdout0_107ck1670 FIND v(dout0_107) AT=840.025n

.meas tran vdout0_108ck1670 FIND v(dout0_108) AT=840.025n

.meas tran vdout0_109ck1670 FIND v(dout0_109) AT=840.025n

.meas tran vdout0_110ck1670 FIND v(dout0_110) AT=840.025n

.meas tran vdout0_111ck1670 FIND v(dout0_111) AT=840.025n

.meas tran vdout0_112ck1670 FIND v(dout0_112) AT=840.025n

.meas tran vdout0_113ck1670 FIND v(dout0_113) AT=840.025n

.meas tran vdout0_114ck1670 FIND v(dout0_114) AT=840.025n

.meas tran vdout0_115ck1670 FIND v(dout0_115) AT=840.025n

.meas tran vdout0_116ck1670 FIND v(dout0_116) AT=840.025n

.meas tran vdout0_117ck1670 FIND v(dout0_117) AT=840.025n

.meas tran vdout0_118ck1670 FIND v(dout0_118) AT=840.025n

.meas tran vdout0_119ck1670 FIND v(dout0_119) AT=840.025n

.meas tran vdout0_120ck1670 FIND v(dout0_120) AT=840.025n

.meas tran vdout0_121ck1670 FIND v(dout0_121) AT=840.025n

.meas tran vdout0_122ck1670 FIND v(dout0_122) AT=840.025n

.meas tran vdout0_123ck1670 FIND v(dout0_123) AT=840.025n

.meas tran vdout0_124ck1670 FIND v(dout0_124) AT=840.025n

.meas tran vdout0_125ck1670 FIND v(dout0_125) AT=840.025n

.meas tran vdout0_126ck1670 FIND v(dout0_126) AT=840.025n

.meas tran vdout0_127ck1670 FIND v(dout0_127) AT=840.025n

.meas tran vdout0_128ck1670 FIND v(dout0_128) AT=840.025n

.meas tran vdout0_129ck1670 FIND v(dout0_129) AT=840.025n

.meas tran vdout0_130ck1670 FIND v(dout0_130) AT=840.025n

.meas tran vdout0_131ck1670 FIND v(dout0_131) AT=840.025n

.meas tran vdout0_132ck1670 FIND v(dout0_132) AT=840.025n

.meas tran vdout0_133ck1670 FIND v(dout0_133) AT=840.025n

.meas tran vdout0_134ck1670 FIND v(dout0_134) AT=840.025n

.meas tran vdout0_135ck1670 FIND v(dout0_135) AT=840.025n

.meas tran vdout0_136ck1670 FIND v(dout0_136) AT=840.025n

.meas tran vdout0_137ck1670 FIND v(dout0_137) AT=840.025n

.meas tran vdout0_138ck1670 FIND v(dout0_138) AT=840.025n

.meas tran vdout0_139ck1670 FIND v(dout0_139) AT=840.025n

.meas tran vdout0_140ck1670 FIND v(dout0_140) AT=840.025n

.meas tran vdout0_141ck1670 FIND v(dout0_141) AT=840.025n

.meas tran vdout0_142ck1670 FIND v(dout0_142) AT=840.025n

.meas tran vdout0_143ck1670 FIND v(dout0_143) AT=840.025n

.meas tran vdout0_144ck1670 FIND v(dout0_144) AT=840.025n

.meas tran vdout0_145ck1670 FIND v(dout0_145) AT=840.025n

.meas tran vdout0_146ck1670 FIND v(dout0_146) AT=840.025n

.meas tran vdout0_147ck1670 FIND v(dout0_147) AT=840.025n

.meas tran vdout0_148ck1670 FIND v(dout0_148) AT=840.025n

.meas tran vdout0_149ck1670 FIND v(dout0_149) AT=840.025n

.meas tran vdout0_0ck1700 FIND v(dout0_0) AT=855.025n

.meas tran vdout0_1ck1700 FIND v(dout0_1) AT=855.025n

.meas tran vdout0_2ck1700 FIND v(dout0_2) AT=855.025n

.meas tran vdout0_3ck1700 FIND v(dout0_3) AT=855.025n

.meas tran vdout0_4ck1700 FIND v(dout0_4) AT=855.025n

.meas tran vdout0_5ck1700 FIND v(dout0_5) AT=855.025n

.meas tran vdout0_6ck1700 FIND v(dout0_6) AT=855.025n

.meas tran vdout0_7ck1700 FIND v(dout0_7) AT=855.025n

.meas tran vdout0_8ck1700 FIND v(dout0_8) AT=855.025n

.meas tran vdout0_9ck1700 FIND v(dout0_9) AT=855.025n

.meas tran vdout0_10ck1700 FIND v(dout0_10) AT=855.025n

.meas tran vdout0_11ck1700 FIND v(dout0_11) AT=855.025n

.meas tran vdout0_12ck1700 FIND v(dout0_12) AT=855.025n

.meas tran vdout0_13ck1700 FIND v(dout0_13) AT=855.025n

.meas tran vdout0_14ck1700 FIND v(dout0_14) AT=855.025n

.meas tran vdout0_15ck1700 FIND v(dout0_15) AT=855.025n

.meas tran vdout0_16ck1700 FIND v(dout0_16) AT=855.025n

.meas tran vdout0_17ck1700 FIND v(dout0_17) AT=855.025n

.meas tran vdout0_18ck1700 FIND v(dout0_18) AT=855.025n

.meas tran vdout0_19ck1700 FIND v(dout0_19) AT=855.025n

.meas tran vdout0_20ck1700 FIND v(dout0_20) AT=855.025n

.meas tran vdout0_21ck1700 FIND v(dout0_21) AT=855.025n

.meas tran vdout0_22ck1700 FIND v(dout0_22) AT=855.025n

.meas tran vdout0_23ck1700 FIND v(dout0_23) AT=855.025n

.meas tran vdout0_24ck1700 FIND v(dout0_24) AT=855.025n

.meas tran vdout0_25ck1700 FIND v(dout0_25) AT=855.025n

.meas tran vdout0_26ck1700 FIND v(dout0_26) AT=855.025n

.meas tran vdout0_27ck1700 FIND v(dout0_27) AT=855.025n

.meas tran vdout0_28ck1700 FIND v(dout0_28) AT=855.025n

.meas tran vdout0_29ck1700 FIND v(dout0_29) AT=855.025n

.meas tran vdout0_30ck1700 FIND v(dout0_30) AT=855.025n

.meas tran vdout0_31ck1700 FIND v(dout0_31) AT=855.025n

.meas tran vdout0_32ck1700 FIND v(dout0_32) AT=855.025n

.meas tran vdout0_33ck1700 FIND v(dout0_33) AT=855.025n

.meas tran vdout0_34ck1700 FIND v(dout0_34) AT=855.025n

.meas tran vdout0_35ck1700 FIND v(dout0_35) AT=855.025n

.meas tran vdout0_36ck1700 FIND v(dout0_36) AT=855.025n

.meas tran vdout0_37ck1700 FIND v(dout0_37) AT=855.025n

.meas tran vdout0_38ck1700 FIND v(dout0_38) AT=855.025n

.meas tran vdout0_39ck1700 FIND v(dout0_39) AT=855.025n

.meas tran vdout0_40ck1700 FIND v(dout0_40) AT=855.025n

.meas tran vdout0_41ck1700 FIND v(dout0_41) AT=855.025n

.meas tran vdout0_42ck1700 FIND v(dout0_42) AT=855.025n

.meas tran vdout0_43ck1700 FIND v(dout0_43) AT=855.025n

.meas tran vdout0_44ck1700 FIND v(dout0_44) AT=855.025n

.meas tran vdout0_45ck1700 FIND v(dout0_45) AT=855.025n

.meas tran vdout0_46ck1700 FIND v(dout0_46) AT=855.025n

.meas tran vdout0_47ck1700 FIND v(dout0_47) AT=855.025n

.meas tran vdout0_48ck1700 FIND v(dout0_48) AT=855.025n

.meas tran vdout0_49ck1700 FIND v(dout0_49) AT=855.025n

.meas tran vdout0_50ck1700 FIND v(dout0_50) AT=855.025n

.meas tran vdout0_51ck1700 FIND v(dout0_51) AT=855.025n

.meas tran vdout0_52ck1700 FIND v(dout0_52) AT=855.025n

.meas tran vdout0_53ck1700 FIND v(dout0_53) AT=855.025n

.meas tran vdout0_54ck1700 FIND v(dout0_54) AT=855.025n

.meas tran vdout0_55ck1700 FIND v(dout0_55) AT=855.025n

.meas tran vdout0_56ck1700 FIND v(dout0_56) AT=855.025n

.meas tran vdout0_57ck1700 FIND v(dout0_57) AT=855.025n

.meas tran vdout0_58ck1700 FIND v(dout0_58) AT=855.025n

.meas tran vdout0_59ck1700 FIND v(dout0_59) AT=855.025n

.meas tran vdout0_60ck1700 FIND v(dout0_60) AT=855.025n

.meas tran vdout0_61ck1700 FIND v(dout0_61) AT=855.025n

.meas tran vdout0_62ck1700 FIND v(dout0_62) AT=855.025n

.meas tran vdout0_63ck1700 FIND v(dout0_63) AT=855.025n

.meas tran vdout0_64ck1700 FIND v(dout0_64) AT=855.025n

.meas tran vdout0_65ck1700 FIND v(dout0_65) AT=855.025n

.meas tran vdout0_66ck1700 FIND v(dout0_66) AT=855.025n

.meas tran vdout0_67ck1700 FIND v(dout0_67) AT=855.025n

.meas tran vdout0_68ck1700 FIND v(dout0_68) AT=855.025n

.meas tran vdout0_69ck1700 FIND v(dout0_69) AT=855.025n

.meas tran vdout0_70ck1700 FIND v(dout0_70) AT=855.025n

.meas tran vdout0_71ck1700 FIND v(dout0_71) AT=855.025n

.meas tran vdout0_72ck1700 FIND v(dout0_72) AT=855.025n

.meas tran vdout0_73ck1700 FIND v(dout0_73) AT=855.025n

.meas tran vdout0_74ck1700 FIND v(dout0_74) AT=855.025n

.meas tran vdout0_75ck1700 FIND v(dout0_75) AT=855.025n

.meas tran vdout0_76ck1700 FIND v(dout0_76) AT=855.025n

.meas tran vdout0_77ck1700 FIND v(dout0_77) AT=855.025n

.meas tran vdout0_78ck1700 FIND v(dout0_78) AT=855.025n

.meas tran vdout0_79ck1700 FIND v(dout0_79) AT=855.025n

.meas tran vdout0_80ck1700 FIND v(dout0_80) AT=855.025n

.meas tran vdout0_81ck1700 FIND v(dout0_81) AT=855.025n

.meas tran vdout0_82ck1700 FIND v(dout0_82) AT=855.025n

.meas tran vdout0_83ck1700 FIND v(dout0_83) AT=855.025n

.meas tran vdout0_84ck1700 FIND v(dout0_84) AT=855.025n

.meas tran vdout0_85ck1700 FIND v(dout0_85) AT=855.025n

.meas tran vdout0_86ck1700 FIND v(dout0_86) AT=855.025n

.meas tran vdout0_87ck1700 FIND v(dout0_87) AT=855.025n

.meas tran vdout0_88ck1700 FIND v(dout0_88) AT=855.025n

.meas tran vdout0_89ck1700 FIND v(dout0_89) AT=855.025n

.meas tran vdout0_90ck1700 FIND v(dout0_90) AT=855.025n

.meas tran vdout0_91ck1700 FIND v(dout0_91) AT=855.025n

.meas tran vdout0_92ck1700 FIND v(dout0_92) AT=855.025n

.meas tran vdout0_93ck1700 FIND v(dout0_93) AT=855.025n

.meas tran vdout0_94ck1700 FIND v(dout0_94) AT=855.025n

.meas tran vdout0_95ck1700 FIND v(dout0_95) AT=855.025n

.meas tran vdout0_96ck1700 FIND v(dout0_96) AT=855.025n

.meas tran vdout0_97ck1700 FIND v(dout0_97) AT=855.025n

.meas tran vdout0_98ck1700 FIND v(dout0_98) AT=855.025n

.meas tran vdout0_99ck1700 FIND v(dout0_99) AT=855.025n

.meas tran vdout0_100ck1700 FIND v(dout0_100) AT=855.025n

.meas tran vdout0_101ck1700 FIND v(dout0_101) AT=855.025n

.meas tran vdout0_102ck1700 FIND v(dout0_102) AT=855.025n

.meas tran vdout0_103ck1700 FIND v(dout0_103) AT=855.025n

.meas tran vdout0_104ck1700 FIND v(dout0_104) AT=855.025n

.meas tran vdout0_105ck1700 FIND v(dout0_105) AT=855.025n

.meas tran vdout0_106ck1700 FIND v(dout0_106) AT=855.025n

.meas tran vdout0_107ck1700 FIND v(dout0_107) AT=855.025n

.meas tran vdout0_108ck1700 FIND v(dout0_108) AT=855.025n

.meas tran vdout0_109ck1700 FIND v(dout0_109) AT=855.025n

.meas tran vdout0_110ck1700 FIND v(dout0_110) AT=855.025n

.meas tran vdout0_111ck1700 FIND v(dout0_111) AT=855.025n

.meas tran vdout0_112ck1700 FIND v(dout0_112) AT=855.025n

.meas tran vdout0_113ck1700 FIND v(dout0_113) AT=855.025n

.meas tran vdout0_114ck1700 FIND v(dout0_114) AT=855.025n

.meas tran vdout0_115ck1700 FIND v(dout0_115) AT=855.025n

.meas tran vdout0_116ck1700 FIND v(dout0_116) AT=855.025n

.meas tran vdout0_117ck1700 FIND v(dout0_117) AT=855.025n

.meas tran vdout0_118ck1700 FIND v(dout0_118) AT=855.025n

.meas tran vdout0_119ck1700 FIND v(dout0_119) AT=855.025n

.meas tran vdout0_120ck1700 FIND v(dout0_120) AT=855.025n

.meas tran vdout0_121ck1700 FIND v(dout0_121) AT=855.025n

.meas tran vdout0_122ck1700 FIND v(dout0_122) AT=855.025n

.meas tran vdout0_123ck1700 FIND v(dout0_123) AT=855.025n

.meas tran vdout0_124ck1700 FIND v(dout0_124) AT=855.025n

.meas tran vdout0_125ck1700 FIND v(dout0_125) AT=855.025n

.meas tran vdout0_126ck1700 FIND v(dout0_126) AT=855.025n

.meas tran vdout0_127ck1700 FIND v(dout0_127) AT=855.025n

.meas tran vdout0_128ck1700 FIND v(dout0_128) AT=855.025n

.meas tran vdout0_129ck1700 FIND v(dout0_129) AT=855.025n

.meas tran vdout0_130ck1700 FIND v(dout0_130) AT=855.025n

.meas tran vdout0_131ck1700 FIND v(dout0_131) AT=855.025n

.meas tran vdout0_132ck1700 FIND v(dout0_132) AT=855.025n

.meas tran vdout0_133ck1700 FIND v(dout0_133) AT=855.025n

.meas tran vdout0_134ck1700 FIND v(dout0_134) AT=855.025n

.meas tran vdout0_135ck1700 FIND v(dout0_135) AT=855.025n

.meas tran vdout0_136ck1700 FIND v(dout0_136) AT=855.025n

.meas tran vdout0_137ck1700 FIND v(dout0_137) AT=855.025n

.meas tran vdout0_138ck1700 FIND v(dout0_138) AT=855.025n

.meas tran vdout0_139ck1700 FIND v(dout0_139) AT=855.025n

.meas tran vdout0_140ck1700 FIND v(dout0_140) AT=855.025n

.meas tran vdout0_141ck1700 FIND v(dout0_141) AT=855.025n

.meas tran vdout0_142ck1700 FIND v(dout0_142) AT=855.025n

.meas tran vdout0_143ck1700 FIND v(dout0_143) AT=855.025n

.meas tran vdout0_144ck1700 FIND v(dout0_144) AT=855.025n

.meas tran vdout0_145ck1700 FIND v(dout0_145) AT=855.025n

.meas tran vdout0_146ck1700 FIND v(dout0_146) AT=855.025n

.meas tran vdout0_147ck1700 FIND v(dout0_147) AT=855.025n

.meas tran vdout0_148ck1700 FIND v(dout0_148) AT=855.025n

.meas tran vdout0_149ck1700 FIND v(dout0_149) AT=855.025n

.meas tran vdout0_0ck1720 FIND v(dout0_0) AT=865.025n

.meas tran vdout0_1ck1720 FIND v(dout0_1) AT=865.025n

.meas tran vdout0_2ck1720 FIND v(dout0_2) AT=865.025n

.meas tran vdout0_3ck1720 FIND v(dout0_3) AT=865.025n

.meas tran vdout0_4ck1720 FIND v(dout0_4) AT=865.025n

.meas tran vdout0_5ck1720 FIND v(dout0_5) AT=865.025n

.meas tran vdout0_6ck1720 FIND v(dout0_6) AT=865.025n

.meas tran vdout0_7ck1720 FIND v(dout0_7) AT=865.025n

.meas tran vdout0_8ck1720 FIND v(dout0_8) AT=865.025n

.meas tran vdout0_9ck1720 FIND v(dout0_9) AT=865.025n

.meas tran vdout0_10ck1720 FIND v(dout0_10) AT=865.025n

.meas tran vdout0_11ck1720 FIND v(dout0_11) AT=865.025n

.meas tran vdout0_12ck1720 FIND v(dout0_12) AT=865.025n

.meas tran vdout0_13ck1720 FIND v(dout0_13) AT=865.025n

.meas tran vdout0_14ck1720 FIND v(dout0_14) AT=865.025n

.meas tran vdout0_15ck1720 FIND v(dout0_15) AT=865.025n

.meas tran vdout0_16ck1720 FIND v(dout0_16) AT=865.025n

.meas tran vdout0_17ck1720 FIND v(dout0_17) AT=865.025n

.meas tran vdout0_18ck1720 FIND v(dout0_18) AT=865.025n

.meas tran vdout0_19ck1720 FIND v(dout0_19) AT=865.025n

.meas tran vdout0_20ck1720 FIND v(dout0_20) AT=865.025n

.meas tran vdout0_21ck1720 FIND v(dout0_21) AT=865.025n

.meas tran vdout0_22ck1720 FIND v(dout0_22) AT=865.025n

.meas tran vdout0_23ck1720 FIND v(dout0_23) AT=865.025n

.meas tran vdout0_24ck1720 FIND v(dout0_24) AT=865.025n

.meas tran vdout0_25ck1720 FIND v(dout0_25) AT=865.025n

.meas tran vdout0_26ck1720 FIND v(dout0_26) AT=865.025n

.meas tran vdout0_27ck1720 FIND v(dout0_27) AT=865.025n

.meas tran vdout0_28ck1720 FIND v(dout0_28) AT=865.025n

.meas tran vdout0_29ck1720 FIND v(dout0_29) AT=865.025n

.meas tran vdout0_30ck1720 FIND v(dout0_30) AT=865.025n

.meas tran vdout0_31ck1720 FIND v(dout0_31) AT=865.025n

.meas tran vdout0_32ck1720 FIND v(dout0_32) AT=865.025n

.meas tran vdout0_33ck1720 FIND v(dout0_33) AT=865.025n

.meas tran vdout0_34ck1720 FIND v(dout0_34) AT=865.025n

.meas tran vdout0_35ck1720 FIND v(dout0_35) AT=865.025n

.meas tran vdout0_36ck1720 FIND v(dout0_36) AT=865.025n

.meas tran vdout0_37ck1720 FIND v(dout0_37) AT=865.025n

.meas tran vdout0_38ck1720 FIND v(dout0_38) AT=865.025n

.meas tran vdout0_39ck1720 FIND v(dout0_39) AT=865.025n

.meas tran vdout0_40ck1720 FIND v(dout0_40) AT=865.025n

.meas tran vdout0_41ck1720 FIND v(dout0_41) AT=865.025n

.meas tran vdout0_42ck1720 FIND v(dout0_42) AT=865.025n

.meas tran vdout0_43ck1720 FIND v(dout0_43) AT=865.025n

.meas tran vdout0_44ck1720 FIND v(dout0_44) AT=865.025n

.meas tran vdout0_45ck1720 FIND v(dout0_45) AT=865.025n

.meas tran vdout0_46ck1720 FIND v(dout0_46) AT=865.025n

.meas tran vdout0_47ck1720 FIND v(dout0_47) AT=865.025n

.meas tran vdout0_48ck1720 FIND v(dout0_48) AT=865.025n

.meas tran vdout0_49ck1720 FIND v(dout0_49) AT=865.025n

.meas tran vdout0_50ck1720 FIND v(dout0_50) AT=865.025n

.meas tran vdout0_51ck1720 FIND v(dout0_51) AT=865.025n

.meas tran vdout0_52ck1720 FIND v(dout0_52) AT=865.025n

.meas tran vdout0_53ck1720 FIND v(dout0_53) AT=865.025n

.meas tran vdout0_54ck1720 FIND v(dout0_54) AT=865.025n

.meas tran vdout0_55ck1720 FIND v(dout0_55) AT=865.025n

.meas tran vdout0_56ck1720 FIND v(dout0_56) AT=865.025n

.meas tran vdout0_57ck1720 FIND v(dout0_57) AT=865.025n

.meas tran vdout0_58ck1720 FIND v(dout0_58) AT=865.025n

.meas tran vdout0_59ck1720 FIND v(dout0_59) AT=865.025n

.meas tran vdout0_60ck1720 FIND v(dout0_60) AT=865.025n

.meas tran vdout0_61ck1720 FIND v(dout0_61) AT=865.025n

.meas tran vdout0_62ck1720 FIND v(dout0_62) AT=865.025n

.meas tran vdout0_63ck1720 FIND v(dout0_63) AT=865.025n

.meas tran vdout0_64ck1720 FIND v(dout0_64) AT=865.025n

.meas tran vdout0_65ck1720 FIND v(dout0_65) AT=865.025n

.meas tran vdout0_66ck1720 FIND v(dout0_66) AT=865.025n

.meas tran vdout0_67ck1720 FIND v(dout0_67) AT=865.025n

.meas tran vdout0_68ck1720 FIND v(dout0_68) AT=865.025n

.meas tran vdout0_69ck1720 FIND v(dout0_69) AT=865.025n

.meas tran vdout0_70ck1720 FIND v(dout0_70) AT=865.025n

.meas tran vdout0_71ck1720 FIND v(dout0_71) AT=865.025n

.meas tran vdout0_72ck1720 FIND v(dout0_72) AT=865.025n

.meas tran vdout0_73ck1720 FIND v(dout0_73) AT=865.025n

.meas tran vdout0_74ck1720 FIND v(dout0_74) AT=865.025n

.meas tran vdout0_75ck1720 FIND v(dout0_75) AT=865.025n

.meas tran vdout0_76ck1720 FIND v(dout0_76) AT=865.025n

.meas tran vdout0_77ck1720 FIND v(dout0_77) AT=865.025n

.meas tran vdout0_78ck1720 FIND v(dout0_78) AT=865.025n

.meas tran vdout0_79ck1720 FIND v(dout0_79) AT=865.025n

.meas tran vdout0_80ck1720 FIND v(dout0_80) AT=865.025n

.meas tran vdout0_81ck1720 FIND v(dout0_81) AT=865.025n

.meas tran vdout0_82ck1720 FIND v(dout0_82) AT=865.025n

.meas tran vdout0_83ck1720 FIND v(dout0_83) AT=865.025n

.meas tran vdout0_84ck1720 FIND v(dout0_84) AT=865.025n

.meas tran vdout0_85ck1720 FIND v(dout0_85) AT=865.025n

.meas tran vdout0_86ck1720 FIND v(dout0_86) AT=865.025n

.meas tran vdout0_87ck1720 FIND v(dout0_87) AT=865.025n

.meas tran vdout0_88ck1720 FIND v(dout0_88) AT=865.025n

.meas tran vdout0_89ck1720 FIND v(dout0_89) AT=865.025n

.meas tran vdout0_90ck1720 FIND v(dout0_90) AT=865.025n

.meas tran vdout0_91ck1720 FIND v(dout0_91) AT=865.025n

.meas tran vdout0_92ck1720 FIND v(dout0_92) AT=865.025n

.meas tran vdout0_93ck1720 FIND v(dout0_93) AT=865.025n

.meas tran vdout0_94ck1720 FIND v(dout0_94) AT=865.025n

.meas tran vdout0_95ck1720 FIND v(dout0_95) AT=865.025n

.meas tran vdout0_96ck1720 FIND v(dout0_96) AT=865.025n

.meas tran vdout0_97ck1720 FIND v(dout0_97) AT=865.025n

.meas tran vdout0_98ck1720 FIND v(dout0_98) AT=865.025n

.meas tran vdout0_99ck1720 FIND v(dout0_99) AT=865.025n

.meas tran vdout0_100ck1720 FIND v(dout0_100) AT=865.025n

.meas tran vdout0_101ck1720 FIND v(dout0_101) AT=865.025n

.meas tran vdout0_102ck1720 FIND v(dout0_102) AT=865.025n

.meas tran vdout0_103ck1720 FIND v(dout0_103) AT=865.025n

.meas tran vdout0_104ck1720 FIND v(dout0_104) AT=865.025n

.meas tran vdout0_105ck1720 FIND v(dout0_105) AT=865.025n

.meas tran vdout0_106ck1720 FIND v(dout0_106) AT=865.025n

.meas tran vdout0_107ck1720 FIND v(dout0_107) AT=865.025n

.meas tran vdout0_108ck1720 FIND v(dout0_108) AT=865.025n

.meas tran vdout0_109ck1720 FIND v(dout0_109) AT=865.025n

.meas tran vdout0_110ck1720 FIND v(dout0_110) AT=865.025n

.meas tran vdout0_111ck1720 FIND v(dout0_111) AT=865.025n

.meas tran vdout0_112ck1720 FIND v(dout0_112) AT=865.025n

.meas tran vdout0_113ck1720 FIND v(dout0_113) AT=865.025n

.meas tran vdout0_114ck1720 FIND v(dout0_114) AT=865.025n

.meas tran vdout0_115ck1720 FIND v(dout0_115) AT=865.025n

.meas tran vdout0_116ck1720 FIND v(dout0_116) AT=865.025n

.meas tran vdout0_117ck1720 FIND v(dout0_117) AT=865.025n

.meas tran vdout0_118ck1720 FIND v(dout0_118) AT=865.025n

.meas tran vdout0_119ck1720 FIND v(dout0_119) AT=865.025n

.meas tran vdout0_120ck1720 FIND v(dout0_120) AT=865.025n

.meas tran vdout0_121ck1720 FIND v(dout0_121) AT=865.025n

.meas tran vdout0_122ck1720 FIND v(dout0_122) AT=865.025n

.meas tran vdout0_123ck1720 FIND v(dout0_123) AT=865.025n

.meas tran vdout0_124ck1720 FIND v(dout0_124) AT=865.025n

.meas tran vdout0_125ck1720 FIND v(dout0_125) AT=865.025n

.meas tran vdout0_126ck1720 FIND v(dout0_126) AT=865.025n

.meas tran vdout0_127ck1720 FIND v(dout0_127) AT=865.025n

.meas tran vdout0_128ck1720 FIND v(dout0_128) AT=865.025n

.meas tran vdout0_129ck1720 FIND v(dout0_129) AT=865.025n

.meas tran vdout0_130ck1720 FIND v(dout0_130) AT=865.025n

.meas tran vdout0_131ck1720 FIND v(dout0_131) AT=865.025n

.meas tran vdout0_132ck1720 FIND v(dout0_132) AT=865.025n

.meas tran vdout0_133ck1720 FIND v(dout0_133) AT=865.025n

.meas tran vdout0_134ck1720 FIND v(dout0_134) AT=865.025n

.meas tran vdout0_135ck1720 FIND v(dout0_135) AT=865.025n

.meas tran vdout0_136ck1720 FIND v(dout0_136) AT=865.025n

.meas tran vdout0_137ck1720 FIND v(dout0_137) AT=865.025n

.meas tran vdout0_138ck1720 FIND v(dout0_138) AT=865.025n

.meas tran vdout0_139ck1720 FIND v(dout0_139) AT=865.025n

.meas tran vdout0_140ck1720 FIND v(dout0_140) AT=865.025n

.meas tran vdout0_141ck1720 FIND v(dout0_141) AT=865.025n

.meas tran vdout0_142ck1720 FIND v(dout0_142) AT=865.025n

.meas tran vdout0_143ck1720 FIND v(dout0_143) AT=865.025n

.meas tran vdout0_144ck1720 FIND v(dout0_144) AT=865.025n

.meas tran vdout0_145ck1720 FIND v(dout0_145) AT=865.025n

.meas tran vdout0_146ck1720 FIND v(dout0_146) AT=865.025n

.meas tran vdout0_147ck1720 FIND v(dout0_147) AT=865.025n

.meas tran vdout0_148ck1720 FIND v(dout0_148) AT=865.025n

.meas tran vdout0_149ck1720 FIND v(dout0_149) AT=865.025n

.meas tran vdout0_0ck1740 FIND v(dout0_0) AT=875.025n

.meas tran vdout0_1ck1740 FIND v(dout0_1) AT=875.025n

.meas tran vdout0_2ck1740 FIND v(dout0_2) AT=875.025n

.meas tran vdout0_3ck1740 FIND v(dout0_3) AT=875.025n

.meas tran vdout0_4ck1740 FIND v(dout0_4) AT=875.025n

.meas tran vdout0_5ck1740 FIND v(dout0_5) AT=875.025n

.meas tran vdout0_6ck1740 FIND v(dout0_6) AT=875.025n

.meas tran vdout0_7ck1740 FIND v(dout0_7) AT=875.025n

.meas tran vdout0_8ck1740 FIND v(dout0_8) AT=875.025n

.meas tran vdout0_9ck1740 FIND v(dout0_9) AT=875.025n

.meas tran vdout0_10ck1740 FIND v(dout0_10) AT=875.025n

.meas tran vdout0_11ck1740 FIND v(dout0_11) AT=875.025n

.meas tran vdout0_12ck1740 FIND v(dout0_12) AT=875.025n

.meas tran vdout0_13ck1740 FIND v(dout0_13) AT=875.025n

.meas tran vdout0_14ck1740 FIND v(dout0_14) AT=875.025n

.meas tran vdout0_15ck1740 FIND v(dout0_15) AT=875.025n

.meas tran vdout0_16ck1740 FIND v(dout0_16) AT=875.025n

.meas tran vdout0_17ck1740 FIND v(dout0_17) AT=875.025n

.meas tran vdout0_18ck1740 FIND v(dout0_18) AT=875.025n

.meas tran vdout0_19ck1740 FIND v(dout0_19) AT=875.025n

.meas tran vdout0_20ck1740 FIND v(dout0_20) AT=875.025n

.meas tran vdout0_21ck1740 FIND v(dout0_21) AT=875.025n

.meas tran vdout0_22ck1740 FIND v(dout0_22) AT=875.025n

.meas tran vdout0_23ck1740 FIND v(dout0_23) AT=875.025n

.meas tran vdout0_24ck1740 FIND v(dout0_24) AT=875.025n

.meas tran vdout0_25ck1740 FIND v(dout0_25) AT=875.025n

.meas tran vdout0_26ck1740 FIND v(dout0_26) AT=875.025n

.meas tran vdout0_27ck1740 FIND v(dout0_27) AT=875.025n

.meas tran vdout0_28ck1740 FIND v(dout0_28) AT=875.025n

.meas tran vdout0_29ck1740 FIND v(dout0_29) AT=875.025n

.meas tran vdout0_30ck1740 FIND v(dout0_30) AT=875.025n

.meas tran vdout0_31ck1740 FIND v(dout0_31) AT=875.025n

.meas tran vdout0_32ck1740 FIND v(dout0_32) AT=875.025n

.meas tran vdout0_33ck1740 FIND v(dout0_33) AT=875.025n

.meas tran vdout0_34ck1740 FIND v(dout0_34) AT=875.025n

.meas tran vdout0_35ck1740 FIND v(dout0_35) AT=875.025n

.meas tran vdout0_36ck1740 FIND v(dout0_36) AT=875.025n

.meas tran vdout0_37ck1740 FIND v(dout0_37) AT=875.025n

.meas tran vdout0_38ck1740 FIND v(dout0_38) AT=875.025n

.meas tran vdout0_39ck1740 FIND v(dout0_39) AT=875.025n

.meas tran vdout0_40ck1740 FIND v(dout0_40) AT=875.025n

.meas tran vdout0_41ck1740 FIND v(dout0_41) AT=875.025n

.meas tran vdout0_42ck1740 FIND v(dout0_42) AT=875.025n

.meas tran vdout0_43ck1740 FIND v(dout0_43) AT=875.025n

.meas tran vdout0_44ck1740 FIND v(dout0_44) AT=875.025n

.meas tran vdout0_45ck1740 FIND v(dout0_45) AT=875.025n

.meas tran vdout0_46ck1740 FIND v(dout0_46) AT=875.025n

.meas tran vdout0_47ck1740 FIND v(dout0_47) AT=875.025n

.meas tran vdout0_48ck1740 FIND v(dout0_48) AT=875.025n

.meas tran vdout0_49ck1740 FIND v(dout0_49) AT=875.025n

.meas tran vdout0_50ck1740 FIND v(dout0_50) AT=875.025n

.meas tran vdout0_51ck1740 FIND v(dout0_51) AT=875.025n

.meas tran vdout0_52ck1740 FIND v(dout0_52) AT=875.025n

.meas tran vdout0_53ck1740 FIND v(dout0_53) AT=875.025n

.meas tran vdout0_54ck1740 FIND v(dout0_54) AT=875.025n

.meas tran vdout0_55ck1740 FIND v(dout0_55) AT=875.025n

.meas tran vdout0_56ck1740 FIND v(dout0_56) AT=875.025n

.meas tran vdout0_57ck1740 FIND v(dout0_57) AT=875.025n

.meas tran vdout0_58ck1740 FIND v(dout0_58) AT=875.025n

.meas tran vdout0_59ck1740 FIND v(dout0_59) AT=875.025n

.meas tran vdout0_60ck1740 FIND v(dout0_60) AT=875.025n

.meas tran vdout0_61ck1740 FIND v(dout0_61) AT=875.025n

.meas tran vdout0_62ck1740 FIND v(dout0_62) AT=875.025n

.meas tran vdout0_63ck1740 FIND v(dout0_63) AT=875.025n

.meas tran vdout0_64ck1740 FIND v(dout0_64) AT=875.025n

.meas tran vdout0_65ck1740 FIND v(dout0_65) AT=875.025n

.meas tran vdout0_66ck1740 FIND v(dout0_66) AT=875.025n

.meas tran vdout0_67ck1740 FIND v(dout0_67) AT=875.025n

.meas tran vdout0_68ck1740 FIND v(dout0_68) AT=875.025n

.meas tran vdout0_69ck1740 FIND v(dout0_69) AT=875.025n

.meas tran vdout0_70ck1740 FIND v(dout0_70) AT=875.025n

.meas tran vdout0_71ck1740 FIND v(dout0_71) AT=875.025n

.meas tran vdout0_72ck1740 FIND v(dout0_72) AT=875.025n

.meas tran vdout0_73ck1740 FIND v(dout0_73) AT=875.025n

.meas tran vdout0_74ck1740 FIND v(dout0_74) AT=875.025n

.meas tran vdout0_75ck1740 FIND v(dout0_75) AT=875.025n

.meas tran vdout0_76ck1740 FIND v(dout0_76) AT=875.025n

.meas tran vdout0_77ck1740 FIND v(dout0_77) AT=875.025n

.meas tran vdout0_78ck1740 FIND v(dout0_78) AT=875.025n

.meas tran vdout0_79ck1740 FIND v(dout0_79) AT=875.025n

.meas tran vdout0_80ck1740 FIND v(dout0_80) AT=875.025n

.meas tran vdout0_81ck1740 FIND v(dout0_81) AT=875.025n

.meas tran vdout0_82ck1740 FIND v(dout0_82) AT=875.025n

.meas tran vdout0_83ck1740 FIND v(dout0_83) AT=875.025n

.meas tran vdout0_84ck1740 FIND v(dout0_84) AT=875.025n

.meas tran vdout0_85ck1740 FIND v(dout0_85) AT=875.025n

.meas tran vdout0_86ck1740 FIND v(dout0_86) AT=875.025n

.meas tran vdout0_87ck1740 FIND v(dout0_87) AT=875.025n

.meas tran vdout0_88ck1740 FIND v(dout0_88) AT=875.025n

.meas tran vdout0_89ck1740 FIND v(dout0_89) AT=875.025n

.meas tran vdout0_90ck1740 FIND v(dout0_90) AT=875.025n

.meas tran vdout0_91ck1740 FIND v(dout0_91) AT=875.025n

.meas tran vdout0_92ck1740 FIND v(dout0_92) AT=875.025n

.meas tran vdout0_93ck1740 FIND v(dout0_93) AT=875.025n

.meas tran vdout0_94ck1740 FIND v(dout0_94) AT=875.025n

.meas tran vdout0_95ck1740 FIND v(dout0_95) AT=875.025n

.meas tran vdout0_96ck1740 FIND v(dout0_96) AT=875.025n

.meas tran vdout0_97ck1740 FIND v(dout0_97) AT=875.025n

.meas tran vdout0_98ck1740 FIND v(dout0_98) AT=875.025n

.meas tran vdout0_99ck1740 FIND v(dout0_99) AT=875.025n

.meas tran vdout0_100ck1740 FIND v(dout0_100) AT=875.025n

.meas tran vdout0_101ck1740 FIND v(dout0_101) AT=875.025n

.meas tran vdout0_102ck1740 FIND v(dout0_102) AT=875.025n

.meas tran vdout0_103ck1740 FIND v(dout0_103) AT=875.025n

.meas tran vdout0_104ck1740 FIND v(dout0_104) AT=875.025n

.meas tran vdout0_105ck1740 FIND v(dout0_105) AT=875.025n

.meas tran vdout0_106ck1740 FIND v(dout0_106) AT=875.025n

.meas tran vdout0_107ck1740 FIND v(dout0_107) AT=875.025n

.meas tran vdout0_108ck1740 FIND v(dout0_108) AT=875.025n

.meas tran vdout0_109ck1740 FIND v(dout0_109) AT=875.025n

.meas tran vdout0_110ck1740 FIND v(dout0_110) AT=875.025n

.meas tran vdout0_111ck1740 FIND v(dout0_111) AT=875.025n

.meas tran vdout0_112ck1740 FIND v(dout0_112) AT=875.025n

.meas tran vdout0_113ck1740 FIND v(dout0_113) AT=875.025n

.meas tran vdout0_114ck1740 FIND v(dout0_114) AT=875.025n

.meas tran vdout0_115ck1740 FIND v(dout0_115) AT=875.025n

.meas tran vdout0_116ck1740 FIND v(dout0_116) AT=875.025n

.meas tran vdout0_117ck1740 FIND v(dout0_117) AT=875.025n

.meas tran vdout0_118ck1740 FIND v(dout0_118) AT=875.025n

.meas tran vdout0_119ck1740 FIND v(dout0_119) AT=875.025n

.meas tran vdout0_120ck1740 FIND v(dout0_120) AT=875.025n

.meas tran vdout0_121ck1740 FIND v(dout0_121) AT=875.025n

.meas tran vdout0_122ck1740 FIND v(dout0_122) AT=875.025n

.meas tran vdout0_123ck1740 FIND v(dout0_123) AT=875.025n

.meas tran vdout0_124ck1740 FIND v(dout0_124) AT=875.025n

.meas tran vdout0_125ck1740 FIND v(dout0_125) AT=875.025n

.meas tran vdout0_126ck1740 FIND v(dout0_126) AT=875.025n

.meas tran vdout0_127ck1740 FIND v(dout0_127) AT=875.025n

.meas tran vdout0_128ck1740 FIND v(dout0_128) AT=875.025n

.meas tran vdout0_129ck1740 FIND v(dout0_129) AT=875.025n

.meas tran vdout0_130ck1740 FIND v(dout0_130) AT=875.025n

.meas tran vdout0_131ck1740 FIND v(dout0_131) AT=875.025n

.meas tran vdout0_132ck1740 FIND v(dout0_132) AT=875.025n

.meas tran vdout0_133ck1740 FIND v(dout0_133) AT=875.025n

.meas tran vdout0_134ck1740 FIND v(dout0_134) AT=875.025n

.meas tran vdout0_135ck1740 FIND v(dout0_135) AT=875.025n

.meas tran vdout0_136ck1740 FIND v(dout0_136) AT=875.025n

.meas tran vdout0_137ck1740 FIND v(dout0_137) AT=875.025n

.meas tran vdout0_138ck1740 FIND v(dout0_138) AT=875.025n

.meas tran vdout0_139ck1740 FIND v(dout0_139) AT=875.025n

.meas tran vdout0_140ck1740 FIND v(dout0_140) AT=875.025n

.meas tran vdout0_141ck1740 FIND v(dout0_141) AT=875.025n

.meas tran vdout0_142ck1740 FIND v(dout0_142) AT=875.025n

.meas tran vdout0_143ck1740 FIND v(dout0_143) AT=875.025n

.meas tran vdout0_144ck1740 FIND v(dout0_144) AT=875.025n

.meas tran vdout0_145ck1740 FIND v(dout0_145) AT=875.025n

.meas tran vdout0_146ck1740 FIND v(dout0_146) AT=875.025n

.meas tran vdout0_147ck1740 FIND v(dout0_147) AT=875.025n

.meas tran vdout0_148ck1740 FIND v(dout0_148) AT=875.025n

.meas tran vdout0_149ck1740 FIND v(dout0_149) AT=875.025n

.meas tran vdout0_0ck1760 FIND v(dout0_0) AT=885.025n

.meas tran vdout0_1ck1760 FIND v(dout0_1) AT=885.025n

.meas tran vdout0_2ck1760 FIND v(dout0_2) AT=885.025n

.meas tran vdout0_3ck1760 FIND v(dout0_3) AT=885.025n

.meas tran vdout0_4ck1760 FIND v(dout0_4) AT=885.025n

.meas tran vdout0_5ck1760 FIND v(dout0_5) AT=885.025n

.meas tran vdout0_6ck1760 FIND v(dout0_6) AT=885.025n

.meas tran vdout0_7ck1760 FIND v(dout0_7) AT=885.025n

.meas tran vdout0_8ck1760 FIND v(dout0_8) AT=885.025n

.meas tran vdout0_9ck1760 FIND v(dout0_9) AT=885.025n

.meas tran vdout0_10ck1760 FIND v(dout0_10) AT=885.025n

.meas tran vdout0_11ck1760 FIND v(dout0_11) AT=885.025n

.meas tran vdout0_12ck1760 FIND v(dout0_12) AT=885.025n

.meas tran vdout0_13ck1760 FIND v(dout0_13) AT=885.025n

.meas tran vdout0_14ck1760 FIND v(dout0_14) AT=885.025n

.meas tran vdout0_15ck1760 FIND v(dout0_15) AT=885.025n

.meas tran vdout0_16ck1760 FIND v(dout0_16) AT=885.025n

.meas tran vdout0_17ck1760 FIND v(dout0_17) AT=885.025n

.meas tran vdout0_18ck1760 FIND v(dout0_18) AT=885.025n

.meas tran vdout0_19ck1760 FIND v(dout0_19) AT=885.025n

.meas tran vdout0_20ck1760 FIND v(dout0_20) AT=885.025n

.meas tran vdout0_21ck1760 FIND v(dout0_21) AT=885.025n

.meas tran vdout0_22ck1760 FIND v(dout0_22) AT=885.025n

.meas tran vdout0_23ck1760 FIND v(dout0_23) AT=885.025n

.meas tran vdout0_24ck1760 FIND v(dout0_24) AT=885.025n

.meas tran vdout0_25ck1760 FIND v(dout0_25) AT=885.025n

.meas tran vdout0_26ck1760 FIND v(dout0_26) AT=885.025n

.meas tran vdout0_27ck1760 FIND v(dout0_27) AT=885.025n

.meas tran vdout0_28ck1760 FIND v(dout0_28) AT=885.025n

.meas tran vdout0_29ck1760 FIND v(dout0_29) AT=885.025n

.meas tran vdout0_30ck1760 FIND v(dout0_30) AT=885.025n

.meas tran vdout0_31ck1760 FIND v(dout0_31) AT=885.025n

.meas tran vdout0_32ck1760 FIND v(dout0_32) AT=885.025n

.meas tran vdout0_33ck1760 FIND v(dout0_33) AT=885.025n

.meas tran vdout0_34ck1760 FIND v(dout0_34) AT=885.025n

.meas tran vdout0_35ck1760 FIND v(dout0_35) AT=885.025n

.meas tran vdout0_36ck1760 FIND v(dout0_36) AT=885.025n

.meas tran vdout0_37ck1760 FIND v(dout0_37) AT=885.025n

.meas tran vdout0_38ck1760 FIND v(dout0_38) AT=885.025n

.meas tran vdout0_39ck1760 FIND v(dout0_39) AT=885.025n

.meas tran vdout0_40ck1760 FIND v(dout0_40) AT=885.025n

.meas tran vdout0_41ck1760 FIND v(dout0_41) AT=885.025n

.meas tran vdout0_42ck1760 FIND v(dout0_42) AT=885.025n

.meas tran vdout0_43ck1760 FIND v(dout0_43) AT=885.025n

.meas tran vdout0_44ck1760 FIND v(dout0_44) AT=885.025n

.meas tran vdout0_45ck1760 FIND v(dout0_45) AT=885.025n

.meas tran vdout0_46ck1760 FIND v(dout0_46) AT=885.025n

.meas tran vdout0_47ck1760 FIND v(dout0_47) AT=885.025n

.meas tran vdout0_48ck1760 FIND v(dout0_48) AT=885.025n

.meas tran vdout0_49ck1760 FIND v(dout0_49) AT=885.025n

.meas tran vdout0_50ck1760 FIND v(dout0_50) AT=885.025n

.meas tran vdout0_51ck1760 FIND v(dout0_51) AT=885.025n

.meas tran vdout0_52ck1760 FIND v(dout0_52) AT=885.025n

.meas tran vdout0_53ck1760 FIND v(dout0_53) AT=885.025n

.meas tran vdout0_54ck1760 FIND v(dout0_54) AT=885.025n

.meas tran vdout0_55ck1760 FIND v(dout0_55) AT=885.025n

.meas tran vdout0_56ck1760 FIND v(dout0_56) AT=885.025n

.meas tran vdout0_57ck1760 FIND v(dout0_57) AT=885.025n

.meas tran vdout0_58ck1760 FIND v(dout0_58) AT=885.025n

.meas tran vdout0_59ck1760 FIND v(dout0_59) AT=885.025n

.meas tran vdout0_60ck1760 FIND v(dout0_60) AT=885.025n

.meas tran vdout0_61ck1760 FIND v(dout0_61) AT=885.025n

.meas tran vdout0_62ck1760 FIND v(dout0_62) AT=885.025n

.meas tran vdout0_63ck1760 FIND v(dout0_63) AT=885.025n

.meas tran vdout0_64ck1760 FIND v(dout0_64) AT=885.025n

.meas tran vdout0_65ck1760 FIND v(dout0_65) AT=885.025n

.meas tran vdout0_66ck1760 FIND v(dout0_66) AT=885.025n

.meas tran vdout0_67ck1760 FIND v(dout0_67) AT=885.025n

.meas tran vdout0_68ck1760 FIND v(dout0_68) AT=885.025n

.meas tran vdout0_69ck1760 FIND v(dout0_69) AT=885.025n

.meas tran vdout0_70ck1760 FIND v(dout0_70) AT=885.025n

.meas tran vdout0_71ck1760 FIND v(dout0_71) AT=885.025n

.meas tran vdout0_72ck1760 FIND v(dout0_72) AT=885.025n

.meas tran vdout0_73ck1760 FIND v(dout0_73) AT=885.025n

.meas tran vdout0_74ck1760 FIND v(dout0_74) AT=885.025n

.meas tran vdout0_75ck1760 FIND v(dout0_75) AT=885.025n

.meas tran vdout0_76ck1760 FIND v(dout0_76) AT=885.025n

.meas tran vdout0_77ck1760 FIND v(dout0_77) AT=885.025n

.meas tran vdout0_78ck1760 FIND v(dout0_78) AT=885.025n

.meas tran vdout0_79ck1760 FIND v(dout0_79) AT=885.025n

.meas tran vdout0_80ck1760 FIND v(dout0_80) AT=885.025n

.meas tran vdout0_81ck1760 FIND v(dout0_81) AT=885.025n

.meas tran vdout0_82ck1760 FIND v(dout0_82) AT=885.025n

.meas tran vdout0_83ck1760 FIND v(dout0_83) AT=885.025n

.meas tran vdout0_84ck1760 FIND v(dout0_84) AT=885.025n

.meas tran vdout0_85ck1760 FIND v(dout0_85) AT=885.025n

.meas tran vdout0_86ck1760 FIND v(dout0_86) AT=885.025n

.meas tran vdout0_87ck1760 FIND v(dout0_87) AT=885.025n

.meas tran vdout0_88ck1760 FIND v(dout0_88) AT=885.025n

.meas tran vdout0_89ck1760 FIND v(dout0_89) AT=885.025n

.meas tran vdout0_90ck1760 FIND v(dout0_90) AT=885.025n

.meas tran vdout0_91ck1760 FIND v(dout0_91) AT=885.025n

.meas tran vdout0_92ck1760 FIND v(dout0_92) AT=885.025n

.meas tran vdout0_93ck1760 FIND v(dout0_93) AT=885.025n

.meas tran vdout0_94ck1760 FIND v(dout0_94) AT=885.025n

.meas tran vdout0_95ck1760 FIND v(dout0_95) AT=885.025n

.meas tran vdout0_96ck1760 FIND v(dout0_96) AT=885.025n

.meas tran vdout0_97ck1760 FIND v(dout0_97) AT=885.025n

.meas tran vdout0_98ck1760 FIND v(dout0_98) AT=885.025n

.meas tran vdout0_99ck1760 FIND v(dout0_99) AT=885.025n

.meas tran vdout0_100ck1760 FIND v(dout0_100) AT=885.025n

.meas tran vdout0_101ck1760 FIND v(dout0_101) AT=885.025n

.meas tran vdout0_102ck1760 FIND v(dout0_102) AT=885.025n

.meas tran vdout0_103ck1760 FIND v(dout0_103) AT=885.025n

.meas tran vdout0_104ck1760 FIND v(dout0_104) AT=885.025n

.meas tran vdout0_105ck1760 FIND v(dout0_105) AT=885.025n

.meas tran vdout0_106ck1760 FIND v(dout0_106) AT=885.025n

.meas tran vdout0_107ck1760 FIND v(dout0_107) AT=885.025n

.meas tran vdout0_108ck1760 FIND v(dout0_108) AT=885.025n

.meas tran vdout0_109ck1760 FIND v(dout0_109) AT=885.025n

.meas tran vdout0_110ck1760 FIND v(dout0_110) AT=885.025n

.meas tran vdout0_111ck1760 FIND v(dout0_111) AT=885.025n

.meas tran vdout0_112ck1760 FIND v(dout0_112) AT=885.025n

.meas tran vdout0_113ck1760 FIND v(dout0_113) AT=885.025n

.meas tran vdout0_114ck1760 FIND v(dout0_114) AT=885.025n

.meas tran vdout0_115ck1760 FIND v(dout0_115) AT=885.025n

.meas tran vdout0_116ck1760 FIND v(dout0_116) AT=885.025n

.meas tran vdout0_117ck1760 FIND v(dout0_117) AT=885.025n

.meas tran vdout0_118ck1760 FIND v(dout0_118) AT=885.025n

.meas tran vdout0_119ck1760 FIND v(dout0_119) AT=885.025n

.meas tran vdout0_120ck1760 FIND v(dout0_120) AT=885.025n

.meas tran vdout0_121ck1760 FIND v(dout0_121) AT=885.025n

.meas tran vdout0_122ck1760 FIND v(dout0_122) AT=885.025n

.meas tran vdout0_123ck1760 FIND v(dout0_123) AT=885.025n

.meas tran vdout0_124ck1760 FIND v(dout0_124) AT=885.025n

.meas tran vdout0_125ck1760 FIND v(dout0_125) AT=885.025n

.meas tran vdout0_126ck1760 FIND v(dout0_126) AT=885.025n

.meas tran vdout0_127ck1760 FIND v(dout0_127) AT=885.025n

.meas tran vdout0_128ck1760 FIND v(dout0_128) AT=885.025n

.meas tran vdout0_129ck1760 FIND v(dout0_129) AT=885.025n

.meas tran vdout0_130ck1760 FIND v(dout0_130) AT=885.025n

.meas tran vdout0_131ck1760 FIND v(dout0_131) AT=885.025n

.meas tran vdout0_132ck1760 FIND v(dout0_132) AT=885.025n

.meas tran vdout0_133ck1760 FIND v(dout0_133) AT=885.025n

.meas tran vdout0_134ck1760 FIND v(dout0_134) AT=885.025n

.meas tran vdout0_135ck1760 FIND v(dout0_135) AT=885.025n

.meas tran vdout0_136ck1760 FIND v(dout0_136) AT=885.025n

.meas tran vdout0_137ck1760 FIND v(dout0_137) AT=885.025n

.meas tran vdout0_138ck1760 FIND v(dout0_138) AT=885.025n

.meas tran vdout0_139ck1760 FIND v(dout0_139) AT=885.025n

.meas tran vdout0_140ck1760 FIND v(dout0_140) AT=885.025n

.meas tran vdout0_141ck1760 FIND v(dout0_141) AT=885.025n

.meas tran vdout0_142ck1760 FIND v(dout0_142) AT=885.025n

.meas tran vdout0_143ck1760 FIND v(dout0_143) AT=885.025n

.meas tran vdout0_144ck1760 FIND v(dout0_144) AT=885.025n

.meas tran vdout0_145ck1760 FIND v(dout0_145) AT=885.025n

.meas tran vdout0_146ck1760 FIND v(dout0_146) AT=885.025n

.meas tran vdout0_147ck1760 FIND v(dout0_147) AT=885.025n

.meas tran vdout0_148ck1760 FIND v(dout0_148) AT=885.025n

.meas tran vdout0_149ck1760 FIND v(dout0_149) AT=885.025n

.meas tran vdout0_0ck1790 FIND v(dout0_0) AT=900.025n

.meas tran vdout0_1ck1790 FIND v(dout0_1) AT=900.025n

.meas tran vdout0_2ck1790 FIND v(dout0_2) AT=900.025n

.meas tran vdout0_3ck1790 FIND v(dout0_3) AT=900.025n

.meas tran vdout0_4ck1790 FIND v(dout0_4) AT=900.025n

.meas tran vdout0_5ck1790 FIND v(dout0_5) AT=900.025n

.meas tran vdout0_6ck1790 FIND v(dout0_6) AT=900.025n

.meas tran vdout0_7ck1790 FIND v(dout0_7) AT=900.025n

.meas tran vdout0_8ck1790 FIND v(dout0_8) AT=900.025n

.meas tran vdout0_9ck1790 FIND v(dout0_9) AT=900.025n

.meas tran vdout0_10ck1790 FIND v(dout0_10) AT=900.025n

.meas tran vdout0_11ck1790 FIND v(dout0_11) AT=900.025n

.meas tran vdout0_12ck1790 FIND v(dout0_12) AT=900.025n

.meas tran vdout0_13ck1790 FIND v(dout0_13) AT=900.025n

.meas tran vdout0_14ck1790 FIND v(dout0_14) AT=900.025n

.meas tran vdout0_15ck1790 FIND v(dout0_15) AT=900.025n

.meas tran vdout0_16ck1790 FIND v(dout0_16) AT=900.025n

.meas tran vdout0_17ck1790 FIND v(dout0_17) AT=900.025n

.meas tran vdout0_18ck1790 FIND v(dout0_18) AT=900.025n

.meas tran vdout0_19ck1790 FIND v(dout0_19) AT=900.025n

.meas tran vdout0_20ck1790 FIND v(dout0_20) AT=900.025n

.meas tran vdout0_21ck1790 FIND v(dout0_21) AT=900.025n

.meas tran vdout0_22ck1790 FIND v(dout0_22) AT=900.025n

.meas tran vdout0_23ck1790 FIND v(dout0_23) AT=900.025n

.meas tran vdout0_24ck1790 FIND v(dout0_24) AT=900.025n

.meas tran vdout0_25ck1790 FIND v(dout0_25) AT=900.025n

.meas tran vdout0_26ck1790 FIND v(dout0_26) AT=900.025n

.meas tran vdout0_27ck1790 FIND v(dout0_27) AT=900.025n

.meas tran vdout0_28ck1790 FIND v(dout0_28) AT=900.025n

.meas tran vdout0_29ck1790 FIND v(dout0_29) AT=900.025n

.meas tran vdout0_30ck1790 FIND v(dout0_30) AT=900.025n

.meas tran vdout0_31ck1790 FIND v(dout0_31) AT=900.025n

.meas tran vdout0_32ck1790 FIND v(dout0_32) AT=900.025n

.meas tran vdout0_33ck1790 FIND v(dout0_33) AT=900.025n

.meas tran vdout0_34ck1790 FIND v(dout0_34) AT=900.025n

.meas tran vdout0_35ck1790 FIND v(dout0_35) AT=900.025n

.meas tran vdout0_36ck1790 FIND v(dout0_36) AT=900.025n

.meas tran vdout0_37ck1790 FIND v(dout0_37) AT=900.025n

.meas tran vdout0_38ck1790 FIND v(dout0_38) AT=900.025n

.meas tran vdout0_39ck1790 FIND v(dout0_39) AT=900.025n

.meas tran vdout0_40ck1790 FIND v(dout0_40) AT=900.025n

.meas tran vdout0_41ck1790 FIND v(dout0_41) AT=900.025n

.meas tran vdout0_42ck1790 FIND v(dout0_42) AT=900.025n

.meas tran vdout0_43ck1790 FIND v(dout0_43) AT=900.025n

.meas tran vdout0_44ck1790 FIND v(dout0_44) AT=900.025n

.meas tran vdout0_45ck1790 FIND v(dout0_45) AT=900.025n

.meas tran vdout0_46ck1790 FIND v(dout0_46) AT=900.025n

.meas tran vdout0_47ck1790 FIND v(dout0_47) AT=900.025n

.meas tran vdout0_48ck1790 FIND v(dout0_48) AT=900.025n

.meas tran vdout0_49ck1790 FIND v(dout0_49) AT=900.025n

.meas tran vdout0_50ck1790 FIND v(dout0_50) AT=900.025n

.meas tran vdout0_51ck1790 FIND v(dout0_51) AT=900.025n

.meas tran vdout0_52ck1790 FIND v(dout0_52) AT=900.025n

.meas tran vdout0_53ck1790 FIND v(dout0_53) AT=900.025n

.meas tran vdout0_54ck1790 FIND v(dout0_54) AT=900.025n

.meas tran vdout0_55ck1790 FIND v(dout0_55) AT=900.025n

.meas tran vdout0_56ck1790 FIND v(dout0_56) AT=900.025n

.meas tran vdout0_57ck1790 FIND v(dout0_57) AT=900.025n

.meas tran vdout0_58ck1790 FIND v(dout0_58) AT=900.025n

.meas tran vdout0_59ck1790 FIND v(dout0_59) AT=900.025n

.meas tran vdout0_60ck1790 FIND v(dout0_60) AT=900.025n

.meas tran vdout0_61ck1790 FIND v(dout0_61) AT=900.025n

.meas tran vdout0_62ck1790 FIND v(dout0_62) AT=900.025n

.meas tran vdout0_63ck1790 FIND v(dout0_63) AT=900.025n

.meas tran vdout0_64ck1790 FIND v(dout0_64) AT=900.025n

.meas tran vdout0_65ck1790 FIND v(dout0_65) AT=900.025n

.meas tran vdout0_66ck1790 FIND v(dout0_66) AT=900.025n

.meas tran vdout0_67ck1790 FIND v(dout0_67) AT=900.025n

.meas tran vdout0_68ck1790 FIND v(dout0_68) AT=900.025n

.meas tran vdout0_69ck1790 FIND v(dout0_69) AT=900.025n

.meas tran vdout0_70ck1790 FIND v(dout0_70) AT=900.025n

.meas tran vdout0_71ck1790 FIND v(dout0_71) AT=900.025n

.meas tran vdout0_72ck1790 FIND v(dout0_72) AT=900.025n

.meas tran vdout0_73ck1790 FIND v(dout0_73) AT=900.025n

.meas tran vdout0_74ck1790 FIND v(dout0_74) AT=900.025n

.meas tran vdout0_75ck1790 FIND v(dout0_75) AT=900.025n

.meas tran vdout0_76ck1790 FIND v(dout0_76) AT=900.025n

.meas tran vdout0_77ck1790 FIND v(dout0_77) AT=900.025n

.meas tran vdout0_78ck1790 FIND v(dout0_78) AT=900.025n

.meas tran vdout0_79ck1790 FIND v(dout0_79) AT=900.025n

.meas tran vdout0_80ck1790 FIND v(dout0_80) AT=900.025n

.meas tran vdout0_81ck1790 FIND v(dout0_81) AT=900.025n

.meas tran vdout0_82ck1790 FIND v(dout0_82) AT=900.025n

.meas tran vdout0_83ck1790 FIND v(dout0_83) AT=900.025n

.meas tran vdout0_84ck1790 FIND v(dout0_84) AT=900.025n

.meas tran vdout0_85ck1790 FIND v(dout0_85) AT=900.025n

.meas tran vdout0_86ck1790 FIND v(dout0_86) AT=900.025n

.meas tran vdout0_87ck1790 FIND v(dout0_87) AT=900.025n

.meas tran vdout0_88ck1790 FIND v(dout0_88) AT=900.025n

.meas tran vdout0_89ck1790 FIND v(dout0_89) AT=900.025n

.meas tran vdout0_90ck1790 FIND v(dout0_90) AT=900.025n

.meas tran vdout0_91ck1790 FIND v(dout0_91) AT=900.025n

.meas tran vdout0_92ck1790 FIND v(dout0_92) AT=900.025n

.meas tran vdout0_93ck1790 FIND v(dout0_93) AT=900.025n

.meas tran vdout0_94ck1790 FIND v(dout0_94) AT=900.025n

.meas tran vdout0_95ck1790 FIND v(dout0_95) AT=900.025n

.meas tran vdout0_96ck1790 FIND v(dout0_96) AT=900.025n

.meas tran vdout0_97ck1790 FIND v(dout0_97) AT=900.025n

.meas tran vdout0_98ck1790 FIND v(dout0_98) AT=900.025n

.meas tran vdout0_99ck1790 FIND v(dout0_99) AT=900.025n

.meas tran vdout0_100ck1790 FIND v(dout0_100) AT=900.025n

.meas tran vdout0_101ck1790 FIND v(dout0_101) AT=900.025n

.meas tran vdout0_102ck1790 FIND v(dout0_102) AT=900.025n

.meas tran vdout0_103ck1790 FIND v(dout0_103) AT=900.025n

.meas tran vdout0_104ck1790 FIND v(dout0_104) AT=900.025n

.meas tran vdout0_105ck1790 FIND v(dout0_105) AT=900.025n

.meas tran vdout0_106ck1790 FIND v(dout0_106) AT=900.025n

.meas tran vdout0_107ck1790 FIND v(dout0_107) AT=900.025n

.meas tran vdout0_108ck1790 FIND v(dout0_108) AT=900.025n

.meas tran vdout0_109ck1790 FIND v(dout0_109) AT=900.025n

.meas tran vdout0_110ck1790 FIND v(dout0_110) AT=900.025n

.meas tran vdout0_111ck1790 FIND v(dout0_111) AT=900.025n

.meas tran vdout0_112ck1790 FIND v(dout0_112) AT=900.025n

.meas tran vdout0_113ck1790 FIND v(dout0_113) AT=900.025n

.meas tran vdout0_114ck1790 FIND v(dout0_114) AT=900.025n

.meas tran vdout0_115ck1790 FIND v(dout0_115) AT=900.025n

.meas tran vdout0_116ck1790 FIND v(dout0_116) AT=900.025n

.meas tran vdout0_117ck1790 FIND v(dout0_117) AT=900.025n

.meas tran vdout0_118ck1790 FIND v(dout0_118) AT=900.025n

.meas tran vdout0_119ck1790 FIND v(dout0_119) AT=900.025n

.meas tran vdout0_120ck1790 FIND v(dout0_120) AT=900.025n

.meas tran vdout0_121ck1790 FIND v(dout0_121) AT=900.025n

.meas tran vdout0_122ck1790 FIND v(dout0_122) AT=900.025n

.meas tran vdout0_123ck1790 FIND v(dout0_123) AT=900.025n

.meas tran vdout0_124ck1790 FIND v(dout0_124) AT=900.025n

.meas tran vdout0_125ck1790 FIND v(dout0_125) AT=900.025n

.meas tran vdout0_126ck1790 FIND v(dout0_126) AT=900.025n

.meas tran vdout0_127ck1790 FIND v(dout0_127) AT=900.025n

.meas tran vdout0_128ck1790 FIND v(dout0_128) AT=900.025n

.meas tran vdout0_129ck1790 FIND v(dout0_129) AT=900.025n

.meas tran vdout0_130ck1790 FIND v(dout0_130) AT=900.025n

.meas tran vdout0_131ck1790 FIND v(dout0_131) AT=900.025n

.meas tran vdout0_132ck1790 FIND v(dout0_132) AT=900.025n

.meas tran vdout0_133ck1790 FIND v(dout0_133) AT=900.025n

.meas tran vdout0_134ck1790 FIND v(dout0_134) AT=900.025n

.meas tran vdout0_135ck1790 FIND v(dout0_135) AT=900.025n

.meas tran vdout0_136ck1790 FIND v(dout0_136) AT=900.025n

.meas tran vdout0_137ck1790 FIND v(dout0_137) AT=900.025n

.meas tran vdout0_138ck1790 FIND v(dout0_138) AT=900.025n

.meas tran vdout0_139ck1790 FIND v(dout0_139) AT=900.025n

.meas tran vdout0_140ck1790 FIND v(dout0_140) AT=900.025n

.meas tran vdout0_141ck1790 FIND v(dout0_141) AT=900.025n

.meas tran vdout0_142ck1790 FIND v(dout0_142) AT=900.025n

.meas tran vdout0_143ck1790 FIND v(dout0_143) AT=900.025n

.meas tran vdout0_144ck1790 FIND v(dout0_144) AT=900.025n

.meas tran vdout0_145ck1790 FIND v(dout0_145) AT=900.025n

.meas tran vdout0_146ck1790 FIND v(dout0_146) AT=900.025n

.meas tran vdout0_147ck1790 FIND v(dout0_147) AT=900.025n

.meas tran vdout0_148ck1790 FIND v(dout0_148) AT=900.025n

.meas tran vdout0_149ck1790 FIND v(dout0_149) AT=900.025n

.meas tran vdout0_0ck1830 FIND v(dout0_0) AT=920.025n

.meas tran vdout0_1ck1830 FIND v(dout0_1) AT=920.025n

.meas tran vdout0_2ck1830 FIND v(dout0_2) AT=920.025n

.meas tran vdout0_3ck1830 FIND v(dout0_3) AT=920.025n

.meas tran vdout0_4ck1830 FIND v(dout0_4) AT=920.025n

.meas tran vdout0_5ck1830 FIND v(dout0_5) AT=920.025n

.meas tran vdout0_6ck1830 FIND v(dout0_6) AT=920.025n

.meas tran vdout0_7ck1830 FIND v(dout0_7) AT=920.025n

.meas tran vdout0_8ck1830 FIND v(dout0_8) AT=920.025n

.meas tran vdout0_9ck1830 FIND v(dout0_9) AT=920.025n

.meas tran vdout0_10ck1830 FIND v(dout0_10) AT=920.025n

.meas tran vdout0_11ck1830 FIND v(dout0_11) AT=920.025n

.meas tran vdout0_12ck1830 FIND v(dout0_12) AT=920.025n

.meas tran vdout0_13ck1830 FIND v(dout0_13) AT=920.025n

.meas tran vdout0_14ck1830 FIND v(dout0_14) AT=920.025n

.meas tran vdout0_15ck1830 FIND v(dout0_15) AT=920.025n

.meas tran vdout0_16ck1830 FIND v(dout0_16) AT=920.025n

.meas tran vdout0_17ck1830 FIND v(dout0_17) AT=920.025n

.meas tran vdout0_18ck1830 FIND v(dout0_18) AT=920.025n

.meas tran vdout0_19ck1830 FIND v(dout0_19) AT=920.025n

.meas tran vdout0_20ck1830 FIND v(dout0_20) AT=920.025n

.meas tran vdout0_21ck1830 FIND v(dout0_21) AT=920.025n

.meas tran vdout0_22ck1830 FIND v(dout0_22) AT=920.025n

.meas tran vdout0_23ck1830 FIND v(dout0_23) AT=920.025n

.meas tran vdout0_24ck1830 FIND v(dout0_24) AT=920.025n

.meas tran vdout0_25ck1830 FIND v(dout0_25) AT=920.025n

.meas tran vdout0_26ck1830 FIND v(dout0_26) AT=920.025n

.meas tran vdout0_27ck1830 FIND v(dout0_27) AT=920.025n

.meas tran vdout0_28ck1830 FIND v(dout0_28) AT=920.025n

.meas tran vdout0_29ck1830 FIND v(dout0_29) AT=920.025n

.meas tran vdout0_30ck1830 FIND v(dout0_30) AT=920.025n

.meas tran vdout0_31ck1830 FIND v(dout0_31) AT=920.025n

.meas tran vdout0_32ck1830 FIND v(dout0_32) AT=920.025n

.meas tran vdout0_33ck1830 FIND v(dout0_33) AT=920.025n

.meas tran vdout0_34ck1830 FIND v(dout0_34) AT=920.025n

.meas tran vdout0_35ck1830 FIND v(dout0_35) AT=920.025n

.meas tran vdout0_36ck1830 FIND v(dout0_36) AT=920.025n

.meas tran vdout0_37ck1830 FIND v(dout0_37) AT=920.025n

.meas tran vdout0_38ck1830 FIND v(dout0_38) AT=920.025n

.meas tran vdout0_39ck1830 FIND v(dout0_39) AT=920.025n

.meas tran vdout0_40ck1830 FIND v(dout0_40) AT=920.025n

.meas tran vdout0_41ck1830 FIND v(dout0_41) AT=920.025n

.meas tran vdout0_42ck1830 FIND v(dout0_42) AT=920.025n

.meas tran vdout0_43ck1830 FIND v(dout0_43) AT=920.025n

.meas tran vdout0_44ck1830 FIND v(dout0_44) AT=920.025n

.meas tran vdout0_45ck1830 FIND v(dout0_45) AT=920.025n

.meas tran vdout0_46ck1830 FIND v(dout0_46) AT=920.025n

.meas tran vdout0_47ck1830 FIND v(dout0_47) AT=920.025n

.meas tran vdout0_48ck1830 FIND v(dout0_48) AT=920.025n

.meas tran vdout0_49ck1830 FIND v(dout0_49) AT=920.025n

.meas tran vdout0_50ck1830 FIND v(dout0_50) AT=920.025n

.meas tran vdout0_51ck1830 FIND v(dout0_51) AT=920.025n

.meas tran vdout0_52ck1830 FIND v(dout0_52) AT=920.025n

.meas tran vdout0_53ck1830 FIND v(dout0_53) AT=920.025n

.meas tran vdout0_54ck1830 FIND v(dout0_54) AT=920.025n

.meas tran vdout0_55ck1830 FIND v(dout0_55) AT=920.025n

.meas tran vdout0_56ck1830 FIND v(dout0_56) AT=920.025n

.meas tran vdout0_57ck1830 FIND v(dout0_57) AT=920.025n

.meas tran vdout0_58ck1830 FIND v(dout0_58) AT=920.025n

.meas tran vdout0_59ck1830 FIND v(dout0_59) AT=920.025n

.meas tran vdout0_60ck1830 FIND v(dout0_60) AT=920.025n

.meas tran vdout0_61ck1830 FIND v(dout0_61) AT=920.025n

.meas tran vdout0_62ck1830 FIND v(dout0_62) AT=920.025n

.meas tran vdout0_63ck1830 FIND v(dout0_63) AT=920.025n

.meas tran vdout0_64ck1830 FIND v(dout0_64) AT=920.025n

.meas tran vdout0_65ck1830 FIND v(dout0_65) AT=920.025n

.meas tran vdout0_66ck1830 FIND v(dout0_66) AT=920.025n

.meas tran vdout0_67ck1830 FIND v(dout0_67) AT=920.025n

.meas tran vdout0_68ck1830 FIND v(dout0_68) AT=920.025n

.meas tran vdout0_69ck1830 FIND v(dout0_69) AT=920.025n

.meas tran vdout0_70ck1830 FIND v(dout0_70) AT=920.025n

.meas tran vdout0_71ck1830 FIND v(dout0_71) AT=920.025n

.meas tran vdout0_72ck1830 FIND v(dout0_72) AT=920.025n

.meas tran vdout0_73ck1830 FIND v(dout0_73) AT=920.025n

.meas tran vdout0_74ck1830 FIND v(dout0_74) AT=920.025n

.meas tran vdout0_75ck1830 FIND v(dout0_75) AT=920.025n

.meas tran vdout0_76ck1830 FIND v(dout0_76) AT=920.025n

.meas tran vdout0_77ck1830 FIND v(dout0_77) AT=920.025n

.meas tran vdout0_78ck1830 FIND v(dout0_78) AT=920.025n

.meas tran vdout0_79ck1830 FIND v(dout0_79) AT=920.025n

.meas tran vdout0_80ck1830 FIND v(dout0_80) AT=920.025n

.meas tran vdout0_81ck1830 FIND v(dout0_81) AT=920.025n

.meas tran vdout0_82ck1830 FIND v(dout0_82) AT=920.025n

.meas tran vdout0_83ck1830 FIND v(dout0_83) AT=920.025n

.meas tran vdout0_84ck1830 FIND v(dout0_84) AT=920.025n

.meas tran vdout0_85ck1830 FIND v(dout0_85) AT=920.025n

.meas tran vdout0_86ck1830 FIND v(dout0_86) AT=920.025n

.meas tran vdout0_87ck1830 FIND v(dout0_87) AT=920.025n

.meas tran vdout0_88ck1830 FIND v(dout0_88) AT=920.025n

.meas tran vdout0_89ck1830 FIND v(dout0_89) AT=920.025n

.meas tran vdout0_90ck1830 FIND v(dout0_90) AT=920.025n

.meas tran vdout0_91ck1830 FIND v(dout0_91) AT=920.025n

.meas tran vdout0_92ck1830 FIND v(dout0_92) AT=920.025n

.meas tran vdout0_93ck1830 FIND v(dout0_93) AT=920.025n

.meas tran vdout0_94ck1830 FIND v(dout0_94) AT=920.025n

.meas tran vdout0_95ck1830 FIND v(dout0_95) AT=920.025n

.meas tran vdout0_96ck1830 FIND v(dout0_96) AT=920.025n

.meas tran vdout0_97ck1830 FIND v(dout0_97) AT=920.025n

.meas tran vdout0_98ck1830 FIND v(dout0_98) AT=920.025n

.meas tran vdout0_99ck1830 FIND v(dout0_99) AT=920.025n

.meas tran vdout0_100ck1830 FIND v(dout0_100) AT=920.025n

.meas tran vdout0_101ck1830 FIND v(dout0_101) AT=920.025n

.meas tran vdout0_102ck1830 FIND v(dout0_102) AT=920.025n

.meas tran vdout0_103ck1830 FIND v(dout0_103) AT=920.025n

.meas tran vdout0_104ck1830 FIND v(dout0_104) AT=920.025n

.meas tran vdout0_105ck1830 FIND v(dout0_105) AT=920.025n

.meas tran vdout0_106ck1830 FIND v(dout0_106) AT=920.025n

.meas tran vdout0_107ck1830 FIND v(dout0_107) AT=920.025n

.meas tran vdout0_108ck1830 FIND v(dout0_108) AT=920.025n

.meas tran vdout0_109ck1830 FIND v(dout0_109) AT=920.025n

.meas tran vdout0_110ck1830 FIND v(dout0_110) AT=920.025n

.meas tran vdout0_111ck1830 FIND v(dout0_111) AT=920.025n

.meas tran vdout0_112ck1830 FIND v(dout0_112) AT=920.025n

.meas tran vdout0_113ck1830 FIND v(dout0_113) AT=920.025n

.meas tran vdout0_114ck1830 FIND v(dout0_114) AT=920.025n

.meas tran vdout0_115ck1830 FIND v(dout0_115) AT=920.025n

.meas tran vdout0_116ck1830 FIND v(dout0_116) AT=920.025n

.meas tran vdout0_117ck1830 FIND v(dout0_117) AT=920.025n

.meas tran vdout0_118ck1830 FIND v(dout0_118) AT=920.025n

.meas tran vdout0_119ck1830 FIND v(dout0_119) AT=920.025n

.meas tran vdout0_120ck1830 FIND v(dout0_120) AT=920.025n

.meas tran vdout0_121ck1830 FIND v(dout0_121) AT=920.025n

.meas tran vdout0_122ck1830 FIND v(dout0_122) AT=920.025n

.meas tran vdout0_123ck1830 FIND v(dout0_123) AT=920.025n

.meas tran vdout0_124ck1830 FIND v(dout0_124) AT=920.025n

.meas tran vdout0_125ck1830 FIND v(dout0_125) AT=920.025n

.meas tran vdout0_126ck1830 FIND v(dout0_126) AT=920.025n

.meas tran vdout0_127ck1830 FIND v(dout0_127) AT=920.025n

.meas tran vdout0_128ck1830 FIND v(dout0_128) AT=920.025n

.meas tran vdout0_129ck1830 FIND v(dout0_129) AT=920.025n

.meas tran vdout0_130ck1830 FIND v(dout0_130) AT=920.025n

.meas tran vdout0_131ck1830 FIND v(dout0_131) AT=920.025n

.meas tran vdout0_132ck1830 FIND v(dout0_132) AT=920.025n

.meas tran vdout0_133ck1830 FIND v(dout0_133) AT=920.025n

.meas tran vdout0_134ck1830 FIND v(dout0_134) AT=920.025n

.meas tran vdout0_135ck1830 FIND v(dout0_135) AT=920.025n

.meas tran vdout0_136ck1830 FIND v(dout0_136) AT=920.025n

.meas tran vdout0_137ck1830 FIND v(dout0_137) AT=920.025n

.meas tran vdout0_138ck1830 FIND v(dout0_138) AT=920.025n

.meas tran vdout0_139ck1830 FIND v(dout0_139) AT=920.025n

.meas tran vdout0_140ck1830 FIND v(dout0_140) AT=920.025n

.meas tran vdout0_141ck1830 FIND v(dout0_141) AT=920.025n

.meas tran vdout0_142ck1830 FIND v(dout0_142) AT=920.025n

.meas tran vdout0_143ck1830 FIND v(dout0_143) AT=920.025n

.meas tran vdout0_144ck1830 FIND v(dout0_144) AT=920.025n

.meas tran vdout0_145ck1830 FIND v(dout0_145) AT=920.025n

.meas tran vdout0_146ck1830 FIND v(dout0_146) AT=920.025n

.meas tran vdout0_147ck1830 FIND v(dout0_147) AT=920.025n

.meas tran vdout0_148ck1830 FIND v(dout0_148) AT=920.025n

.meas tran vdout0_149ck1830 FIND v(dout0_149) AT=920.025n

.meas tran vdout0_0ck1860 FIND v(dout0_0) AT=935.025n

.meas tran vdout0_1ck1860 FIND v(dout0_1) AT=935.025n

.meas tran vdout0_2ck1860 FIND v(dout0_2) AT=935.025n

.meas tran vdout0_3ck1860 FIND v(dout0_3) AT=935.025n

.meas tran vdout0_4ck1860 FIND v(dout0_4) AT=935.025n

.meas tran vdout0_5ck1860 FIND v(dout0_5) AT=935.025n

.meas tran vdout0_6ck1860 FIND v(dout0_6) AT=935.025n

.meas tran vdout0_7ck1860 FIND v(dout0_7) AT=935.025n

.meas tran vdout0_8ck1860 FIND v(dout0_8) AT=935.025n

.meas tran vdout0_9ck1860 FIND v(dout0_9) AT=935.025n

.meas tran vdout0_10ck1860 FIND v(dout0_10) AT=935.025n

.meas tran vdout0_11ck1860 FIND v(dout0_11) AT=935.025n

.meas tran vdout0_12ck1860 FIND v(dout0_12) AT=935.025n

.meas tran vdout0_13ck1860 FIND v(dout0_13) AT=935.025n

.meas tran vdout0_14ck1860 FIND v(dout0_14) AT=935.025n

.meas tran vdout0_15ck1860 FIND v(dout0_15) AT=935.025n

.meas tran vdout0_16ck1860 FIND v(dout0_16) AT=935.025n

.meas tran vdout0_17ck1860 FIND v(dout0_17) AT=935.025n

.meas tran vdout0_18ck1860 FIND v(dout0_18) AT=935.025n

.meas tran vdout0_19ck1860 FIND v(dout0_19) AT=935.025n

.meas tran vdout0_20ck1860 FIND v(dout0_20) AT=935.025n

.meas tran vdout0_21ck1860 FIND v(dout0_21) AT=935.025n

.meas tran vdout0_22ck1860 FIND v(dout0_22) AT=935.025n

.meas tran vdout0_23ck1860 FIND v(dout0_23) AT=935.025n

.meas tran vdout0_24ck1860 FIND v(dout0_24) AT=935.025n

.meas tran vdout0_25ck1860 FIND v(dout0_25) AT=935.025n

.meas tran vdout0_26ck1860 FIND v(dout0_26) AT=935.025n

.meas tran vdout0_27ck1860 FIND v(dout0_27) AT=935.025n

.meas tran vdout0_28ck1860 FIND v(dout0_28) AT=935.025n

.meas tran vdout0_29ck1860 FIND v(dout0_29) AT=935.025n

.meas tran vdout0_30ck1860 FIND v(dout0_30) AT=935.025n

.meas tran vdout0_31ck1860 FIND v(dout0_31) AT=935.025n

.meas tran vdout0_32ck1860 FIND v(dout0_32) AT=935.025n

.meas tran vdout0_33ck1860 FIND v(dout0_33) AT=935.025n

.meas tran vdout0_34ck1860 FIND v(dout0_34) AT=935.025n

.meas tran vdout0_35ck1860 FIND v(dout0_35) AT=935.025n

.meas tran vdout0_36ck1860 FIND v(dout0_36) AT=935.025n

.meas tran vdout0_37ck1860 FIND v(dout0_37) AT=935.025n

.meas tran vdout0_38ck1860 FIND v(dout0_38) AT=935.025n

.meas tran vdout0_39ck1860 FIND v(dout0_39) AT=935.025n

.meas tran vdout0_40ck1860 FIND v(dout0_40) AT=935.025n

.meas tran vdout0_41ck1860 FIND v(dout0_41) AT=935.025n

.meas tran vdout0_42ck1860 FIND v(dout0_42) AT=935.025n

.meas tran vdout0_43ck1860 FIND v(dout0_43) AT=935.025n

.meas tran vdout0_44ck1860 FIND v(dout0_44) AT=935.025n

.meas tran vdout0_45ck1860 FIND v(dout0_45) AT=935.025n

.meas tran vdout0_46ck1860 FIND v(dout0_46) AT=935.025n

.meas tran vdout0_47ck1860 FIND v(dout0_47) AT=935.025n

.meas tran vdout0_48ck1860 FIND v(dout0_48) AT=935.025n

.meas tran vdout0_49ck1860 FIND v(dout0_49) AT=935.025n

.meas tran vdout0_50ck1860 FIND v(dout0_50) AT=935.025n

.meas tran vdout0_51ck1860 FIND v(dout0_51) AT=935.025n

.meas tran vdout0_52ck1860 FIND v(dout0_52) AT=935.025n

.meas tran vdout0_53ck1860 FIND v(dout0_53) AT=935.025n

.meas tran vdout0_54ck1860 FIND v(dout0_54) AT=935.025n

.meas tran vdout0_55ck1860 FIND v(dout0_55) AT=935.025n

.meas tran vdout0_56ck1860 FIND v(dout0_56) AT=935.025n

.meas tran vdout0_57ck1860 FIND v(dout0_57) AT=935.025n

.meas tran vdout0_58ck1860 FIND v(dout0_58) AT=935.025n

.meas tran vdout0_59ck1860 FIND v(dout0_59) AT=935.025n

.meas tran vdout0_60ck1860 FIND v(dout0_60) AT=935.025n

.meas tran vdout0_61ck1860 FIND v(dout0_61) AT=935.025n

.meas tran vdout0_62ck1860 FIND v(dout0_62) AT=935.025n

.meas tran vdout0_63ck1860 FIND v(dout0_63) AT=935.025n

.meas tran vdout0_64ck1860 FIND v(dout0_64) AT=935.025n

.meas tran vdout0_65ck1860 FIND v(dout0_65) AT=935.025n

.meas tran vdout0_66ck1860 FIND v(dout0_66) AT=935.025n

.meas tran vdout0_67ck1860 FIND v(dout0_67) AT=935.025n

.meas tran vdout0_68ck1860 FIND v(dout0_68) AT=935.025n

.meas tran vdout0_69ck1860 FIND v(dout0_69) AT=935.025n

.meas tran vdout0_70ck1860 FIND v(dout0_70) AT=935.025n

.meas tran vdout0_71ck1860 FIND v(dout0_71) AT=935.025n

.meas tran vdout0_72ck1860 FIND v(dout0_72) AT=935.025n

.meas tran vdout0_73ck1860 FIND v(dout0_73) AT=935.025n

.meas tran vdout0_74ck1860 FIND v(dout0_74) AT=935.025n

.meas tran vdout0_75ck1860 FIND v(dout0_75) AT=935.025n

.meas tran vdout0_76ck1860 FIND v(dout0_76) AT=935.025n

.meas tran vdout0_77ck1860 FIND v(dout0_77) AT=935.025n

.meas tran vdout0_78ck1860 FIND v(dout0_78) AT=935.025n

.meas tran vdout0_79ck1860 FIND v(dout0_79) AT=935.025n

.meas tran vdout0_80ck1860 FIND v(dout0_80) AT=935.025n

.meas tran vdout0_81ck1860 FIND v(dout0_81) AT=935.025n

.meas tran vdout0_82ck1860 FIND v(dout0_82) AT=935.025n

.meas tran vdout0_83ck1860 FIND v(dout0_83) AT=935.025n

.meas tran vdout0_84ck1860 FIND v(dout0_84) AT=935.025n

.meas tran vdout0_85ck1860 FIND v(dout0_85) AT=935.025n

.meas tran vdout0_86ck1860 FIND v(dout0_86) AT=935.025n

.meas tran vdout0_87ck1860 FIND v(dout0_87) AT=935.025n

.meas tran vdout0_88ck1860 FIND v(dout0_88) AT=935.025n

.meas tran vdout0_89ck1860 FIND v(dout0_89) AT=935.025n

.meas tran vdout0_90ck1860 FIND v(dout0_90) AT=935.025n

.meas tran vdout0_91ck1860 FIND v(dout0_91) AT=935.025n

.meas tran vdout0_92ck1860 FIND v(dout0_92) AT=935.025n

.meas tran vdout0_93ck1860 FIND v(dout0_93) AT=935.025n

.meas tran vdout0_94ck1860 FIND v(dout0_94) AT=935.025n

.meas tran vdout0_95ck1860 FIND v(dout0_95) AT=935.025n

.meas tran vdout0_96ck1860 FIND v(dout0_96) AT=935.025n

.meas tran vdout0_97ck1860 FIND v(dout0_97) AT=935.025n

.meas tran vdout0_98ck1860 FIND v(dout0_98) AT=935.025n

.meas tran vdout0_99ck1860 FIND v(dout0_99) AT=935.025n

.meas tran vdout0_100ck1860 FIND v(dout0_100) AT=935.025n

.meas tran vdout0_101ck1860 FIND v(dout0_101) AT=935.025n

.meas tran vdout0_102ck1860 FIND v(dout0_102) AT=935.025n

.meas tran vdout0_103ck1860 FIND v(dout0_103) AT=935.025n

.meas tran vdout0_104ck1860 FIND v(dout0_104) AT=935.025n

.meas tran vdout0_105ck1860 FIND v(dout0_105) AT=935.025n

.meas tran vdout0_106ck1860 FIND v(dout0_106) AT=935.025n

.meas tran vdout0_107ck1860 FIND v(dout0_107) AT=935.025n

.meas tran vdout0_108ck1860 FIND v(dout0_108) AT=935.025n

.meas tran vdout0_109ck1860 FIND v(dout0_109) AT=935.025n

.meas tran vdout0_110ck1860 FIND v(dout0_110) AT=935.025n

.meas tran vdout0_111ck1860 FIND v(dout0_111) AT=935.025n

.meas tran vdout0_112ck1860 FIND v(dout0_112) AT=935.025n

.meas tran vdout0_113ck1860 FIND v(dout0_113) AT=935.025n

.meas tran vdout0_114ck1860 FIND v(dout0_114) AT=935.025n

.meas tran vdout0_115ck1860 FIND v(dout0_115) AT=935.025n

.meas tran vdout0_116ck1860 FIND v(dout0_116) AT=935.025n

.meas tran vdout0_117ck1860 FIND v(dout0_117) AT=935.025n

.meas tran vdout0_118ck1860 FIND v(dout0_118) AT=935.025n

.meas tran vdout0_119ck1860 FIND v(dout0_119) AT=935.025n

.meas tran vdout0_120ck1860 FIND v(dout0_120) AT=935.025n

.meas tran vdout0_121ck1860 FIND v(dout0_121) AT=935.025n

.meas tran vdout0_122ck1860 FIND v(dout0_122) AT=935.025n

.meas tran vdout0_123ck1860 FIND v(dout0_123) AT=935.025n

.meas tran vdout0_124ck1860 FIND v(dout0_124) AT=935.025n

.meas tran vdout0_125ck1860 FIND v(dout0_125) AT=935.025n

.meas tran vdout0_126ck1860 FIND v(dout0_126) AT=935.025n

.meas tran vdout0_127ck1860 FIND v(dout0_127) AT=935.025n

.meas tran vdout0_128ck1860 FIND v(dout0_128) AT=935.025n

.meas tran vdout0_129ck1860 FIND v(dout0_129) AT=935.025n

.meas tran vdout0_130ck1860 FIND v(dout0_130) AT=935.025n

.meas tran vdout0_131ck1860 FIND v(dout0_131) AT=935.025n

.meas tran vdout0_132ck1860 FIND v(dout0_132) AT=935.025n

.meas tran vdout0_133ck1860 FIND v(dout0_133) AT=935.025n

.meas tran vdout0_134ck1860 FIND v(dout0_134) AT=935.025n

.meas tran vdout0_135ck1860 FIND v(dout0_135) AT=935.025n

.meas tran vdout0_136ck1860 FIND v(dout0_136) AT=935.025n

.meas tran vdout0_137ck1860 FIND v(dout0_137) AT=935.025n

.meas tran vdout0_138ck1860 FIND v(dout0_138) AT=935.025n

.meas tran vdout0_139ck1860 FIND v(dout0_139) AT=935.025n

.meas tran vdout0_140ck1860 FIND v(dout0_140) AT=935.025n

.meas tran vdout0_141ck1860 FIND v(dout0_141) AT=935.025n

.meas tran vdout0_142ck1860 FIND v(dout0_142) AT=935.025n

.meas tran vdout0_143ck1860 FIND v(dout0_143) AT=935.025n

.meas tran vdout0_144ck1860 FIND v(dout0_144) AT=935.025n

.meas tran vdout0_145ck1860 FIND v(dout0_145) AT=935.025n

.meas tran vdout0_146ck1860 FIND v(dout0_146) AT=935.025n

.meas tran vdout0_147ck1860 FIND v(dout0_147) AT=935.025n

.meas tran vdout0_148ck1860 FIND v(dout0_148) AT=935.025n

.meas tran vdout0_149ck1860 FIND v(dout0_149) AT=935.025n

.meas tran vdout0_0ck1880 FIND v(dout0_0) AT=945.025n

.meas tran vdout0_1ck1880 FIND v(dout0_1) AT=945.025n

.meas tran vdout0_2ck1880 FIND v(dout0_2) AT=945.025n

.meas tran vdout0_3ck1880 FIND v(dout0_3) AT=945.025n

.meas tran vdout0_4ck1880 FIND v(dout0_4) AT=945.025n

.meas tran vdout0_5ck1880 FIND v(dout0_5) AT=945.025n

.meas tran vdout0_6ck1880 FIND v(dout0_6) AT=945.025n

.meas tran vdout0_7ck1880 FIND v(dout0_7) AT=945.025n

.meas tran vdout0_8ck1880 FIND v(dout0_8) AT=945.025n

.meas tran vdout0_9ck1880 FIND v(dout0_9) AT=945.025n

.meas tran vdout0_10ck1880 FIND v(dout0_10) AT=945.025n

.meas tran vdout0_11ck1880 FIND v(dout0_11) AT=945.025n

.meas tran vdout0_12ck1880 FIND v(dout0_12) AT=945.025n

.meas tran vdout0_13ck1880 FIND v(dout0_13) AT=945.025n

.meas tran vdout0_14ck1880 FIND v(dout0_14) AT=945.025n

.meas tran vdout0_15ck1880 FIND v(dout0_15) AT=945.025n

.meas tran vdout0_16ck1880 FIND v(dout0_16) AT=945.025n

.meas tran vdout0_17ck1880 FIND v(dout0_17) AT=945.025n

.meas tran vdout0_18ck1880 FIND v(dout0_18) AT=945.025n

.meas tran vdout0_19ck1880 FIND v(dout0_19) AT=945.025n

.meas tran vdout0_20ck1880 FIND v(dout0_20) AT=945.025n

.meas tran vdout0_21ck1880 FIND v(dout0_21) AT=945.025n

.meas tran vdout0_22ck1880 FIND v(dout0_22) AT=945.025n

.meas tran vdout0_23ck1880 FIND v(dout0_23) AT=945.025n

.meas tran vdout0_24ck1880 FIND v(dout0_24) AT=945.025n

.meas tran vdout0_25ck1880 FIND v(dout0_25) AT=945.025n

.meas tran vdout0_26ck1880 FIND v(dout0_26) AT=945.025n

.meas tran vdout0_27ck1880 FIND v(dout0_27) AT=945.025n

.meas tran vdout0_28ck1880 FIND v(dout0_28) AT=945.025n

.meas tran vdout0_29ck1880 FIND v(dout0_29) AT=945.025n

.meas tran vdout0_30ck1880 FIND v(dout0_30) AT=945.025n

.meas tran vdout0_31ck1880 FIND v(dout0_31) AT=945.025n

.meas tran vdout0_32ck1880 FIND v(dout0_32) AT=945.025n

.meas tran vdout0_33ck1880 FIND v(dout0_33) AT=945.025n

.meas tran vdout0_34ck1880 FIND v(dout0_34) AT=945.025n

.meas tran vdout0_35ck1880 FIND v(dout0_35) AT=945.025n

.meas tran vdout0_36ck1880 FIND v(dout0_36) AT=945.025n

.meas tran vdout0_37ck1880 FIND v(dout0_37) AT=945.025n

.meas tran vdout0_38ck1880 FIND v(dout0_38) AT=945.025n

.meas tran vdout0_39ck1880 FIND v(dout0_39) AT=945.025n

.meas tran vdout0_40ck1880 FIND v(dout0_40) AT=945.025n

.meas tran vdout0_41ck1880 FIND v(dout0_41) AT=945.025n

.meas tran vdout0_42ck1880 FIND v(dout0_42) AT=945.025n

.meas tran vdout0_43ck1880 FIND v(dout0_43) AT=945.025n

.meas tran vdout0_44ck1880 FIND v(dout0_44) AT=945.025n

.meas tran vdout0_45ck1880 FIND v(dout0_45) AT=945.025n

.meas tran vdout0_46ck1880 FIND v(dout0_46) AT=945.025n

.meas tran vdout0_47ck1880 FIND v(dout0_47) AT=945.025n

.meas tran vdout0_48ck1880 FIND v(dout0_48) AT=945.025n

.meas tran vdout0_49ck1880 FIND v(dout0_49) AT=945.025n

.meas tran vdout0_50ck1880 FIND v(dout0_50) AT=945.025n

.meas tran vdout0_51ck1880 FIND v(dout0_51) AT=945.025n

.meas tran vdout0_52ck1880 FIND v(dout0_52) AT=945.025n

.meas tran vdout0_53ck1880 FIND v(dout0_53) AT=945.025n

.meas tran vdout0_54ck1880 FIND v(dout0_54) AT=945.025n

.meas tran vdout0_55ck1880 FIND v(dout0_55) AT=945.025n

.meas tran vdout0_56ck1880 FIND v(dout0_56) AT=945.025n

.meas tran vdout0_57ck1880 FIND v(dout0_57) AT=945.025n

.meas tran vdout0_58ck1880 FIND v(dout0_58) AT=945.025n

.meas tran vdout0_59ck1880 FIND v(dout0_59) AT=945.025n

.meas tran vdout0_60ck1880 FIND v(dout0_60) AT=945.025n

.meas tran vdout0_61ck1880 FIND v(dout0_61) AT=945.025n

.meas tran vdout0_62ck1880 FIND v(dout0_62) AT=945.025n

.meas tran vdout0_63ck1880 FIND v(dout0_63) AT=945.025n

.meas tran vdout0_64ck1880 FIND v(dout0_64) AT=945.025n

.meas tran vdout0_65ck1880 FIND v(dout0_65) AT=945.025n

.meas tran vdout0_66ck1880 FIND v(dout0_66) AT=945.025n

.meas tran vdout0_67ck1880 FIND v(dout0_67) AT=945.025n

.meas tran vdout0_68ck1880 FIND v(dout0_68) AT=945.025n

.meas tran vdout0_69ck1880 FIND v(dout0_69) AT=945.025n

.meas tran vdout0_70ck1880 FIND v(dout0_70) AT=945.025n

.meas tran vdout0_71ck1880 FIND v(dout0_71) AT=945.025n

.meas tran vdout0_72ck1880 FIND v(dout0_72) AT=945.025n

.meas tran vdout0_73ck1880 FIND v(dout0_73) AT=945.025n

.meas tran vdout0_74ck1880 FIND v(dout0_74) AT=945.025n

.meas tran vdout0_75ck1880 FIND v(dout0_75) AT=945.025n

.meas tran vdout0_76ck1880 FIND v(dout0_76) AT=945.025n

.meas tran vdout0_77ck1880 FIND v(dout0_77) AT=945.025n

.meas tran vdout0_78ck1880 FIND v(dout0_78) AT=945.025n

.meas tran vdout0_79ck1880 FIND v(dout0_79) AT=945.025n

.meas tran vdout0_80ck1880 FIND v(dout0_80) AT=945.025n

.meas tran vdout0_81ck1880 FIND v(dout0_81) AT=945.025n

.meas tran vdout0_82ck1880 FIND v(dout0_82) AT=945.025n

.meas tran vdout0_83ck1880 FIND v(dout0_83) AT=945.025n

.meas tran vdout0_84ck1880 FIND v(dout0_84) AT=945.025n

.meas tran vdout0_85ck1880 FIND v(dout0_85) AT=945.025n

.meas tran vdout0_86ck1880 FIND v(dout0_86) AT=945.025n

.meas tran vdout0_87ck1880 FIND v(dout0_87) AT=945.025n

.meas tran vdout0_88ck1880 FIND v(dout0_88) AT=945.025n

.meas tran vdout0_89ck1880 FIND v(dout0_89) AT=945.025n

.meas tran vdout0_90ck1880 FIND v(dout0_90) AT=945.025n

.meas tran vdout0_91ck1880 FIND v(dout0_91) AT=945.025n

.meas tran vdout0_92ck1880 FIND v(dout0_92) AT=945.025n

.meas tran vdout0_93ck1880 FIND v(dout0_93) AT=945.025n

.meas tran vdout0_94ck1880 FIND v(dout0_94) AT=945.025n

.meas tran vdout0_95ck1880 FIND v(dout0_95) AT=945.025n

.meas tran vdout0_96ck1880 FIND v(dout0_96) AT=945.025n

.meas tran vdout0_97ck1880 FIND v(dout0_97) AT=945.025n

.meas tran vdout0_98ck1880 FIND v(dout0_98) AT=945.025n

.meas tran vdout0_99ck1880 FIND v(dout0_99) AT=945.025n

.meas tran vdout0_100ck1880 FIND v(dout0_100) AT=945.025n

.meas tran vdout0_101ck1880 FIND v(dout0_101) AT=945.025n

.meas tran vdout0_102ck1880 FIND v(dout0_102) AT=945.025n

.meas tran vdout0_103ck1880 FIND v(dout0_103) AT=945.025n

.meas tran vdout0_104ck1880 FIND v(dout0_104) AT=945.025n

.meas tran vdout0_105ck1880 FIND v(dout0_105) AT=945.025n

.meas tran vdout0_106ck1880 FIND v(dout0_106) AT=945.025n

.meas tran vdout0_107ck1880 FIND v(dout0_107) AT=945.025n

.meas tran vdout0_108ck1880 FIND v(dout0_108) AT=945.025n

.meas tran vdout0_109ck1880 FIND v(dout0_109) AT=945.025n

.meas tran vdout0_110ck1880 FIND v(dout0_110) AT=945.025n

.meas tran vdout0_111ck1880 FIND v(dout0_111) AT=945.025n

.meas tran vdout0_112ck1880 FIND v(dout0_112) AT=945.025n

.meas tran vdout0_113ck1880 FIND v(dout0_113) AT=945.025n

.meas tran vdout0_114ck1880 FIND v(dout0_114) AT=945.025n

.meas tran vdout0_115ck1880 FIND v(dout0_115) AT=945.025n

.meas tran vdout0_116ck1880 FIND v(dout0_116) AT=945.025n

.meas tran vdout0_117ck1880 FIND v(dout0_117) AT=945.025n

.meas tran vdout0_118ck1880 FIND v(dout0_118) AT=945.025n

.meas tran vdout0_119ck1880 FIND v(dout0_119) AT=945.025n

.meas tran vdout0_120ck1880 FIND v(dout0_120) AT=945.025n

.meas tran vdout0_121ck1880 FIND v(dout0_121) AT=945.025n

.meas tran vdout0_122ck1880 FIND v(dout0_122) AT=945.025n

.meas tran vdout0_123ck1880 FIND v(dout0_123) AT=945.025n

.meas tran vdout0_124ck1880 FIND v(dout0_124) AT=945.025n

.meas tran vdout0_125ck1880 FIND v(dout0_125) AT=945.025n

.meas tran vdout0_126ck1880 FIND v(dout0_126) AT=945.025n

.meas tran vdout0_127ck1880 FIND v(dout0_127) AT=945.025n

.meas tran vdout0_128ck1880 FIND v(dout0_128) AT=945.025n

.meas tran vdout0_129ck1880 FIND v(dout0_129) AT=945.025n

.meas tran vdout0_130ck1880 FIND v(dout0_130) AT=945.025n

.meas tran vdout0_131ck1880 FIND v(dout0_131) AT=945.025n

.meas tran vdout0_132ck1880 FIND v(dout0_132) AT=945.025n

.meas tran vdout0_133ck1880 FIND v(dout0_133) AT=945.025n

.meas tran vdout0_134ck1880 FIND v(dout0_134) AT=945.025n

.meas tran vdout0_135ck1880 FIND v(dout0_135) AT=945.025n

.meas tran vdout0_136ck1880 FIND v(dout0_136) AT=945.025n

.meas tran vdout0_137ck1880 FIND v(dout0_137) AT=945.025n

.meas tran vdout0_138ck1880 FIND v(dout0_138) AT=945.025n

.meas tran vdout0_139ck1880 FIND v(dout0_139) AT=945.025n

.meas tran vdout0_140ck1880 FIND v(dout0_140) AT=945.025n

.meas tran vdout0_141ck1880 FIND v(dout0_141) AT=945.025n

.meas tran vdout0_142ck1880 FIND v(dout0_142) AT=945.025n

.meas tran vdout0_143ck1880 FIND v(dout0_143) AT=945.025n

.meas tran vdout0_144ck1880 FIND v(dout0_144) AT=945.025n

.meas tran vdout0_145ck1880 FIND v(dout0_145) AT=945.025n

.meas tran vdout0_146ck1880 FIND v(dout0_146) AT=945.025n

.meas tran vdout0_147ck1880 FIND v(dout0_147) AT=945.025n

.meas tran vdout0_148ck1880 FIND v(dout0_148) AT=945.025n

.meas tran vdout0_149ck1880 FIND v(dout0_149) AT=945.025n

.meas tran vdout0_0ck1890 FIND v(dout0_0) AT=950.025n

.meas tran vdout0_1ck1890 FIND v(dout0_1) AT=950.025n

.meas tran vdout0_2ck1890 FIND v(dout0_2) AT=950.025n

.meas tran vdout0_3ck1890 FIND v(dout0_3) AT=950.025n

.meas tran vdout0_4ck1890 FIND v(dout0_4) AT=950.025n

.meas tran vdout0_5ck1890 FIND v(dout0_5) AT=950.025n

.meas tran vdout0_6ck1890 FIND v(dout0_6) AT=950.025n

.meas tran vdout0_7ck1890 FIND v(dout0_7) AT=950.025n

.meas tran vdout0_8ck1890 FIND v(dout0_8) AT=950.025n

.meas tran vdout0_9ck1890 FIND v(dout0_9) AT=950.025n

.meas tran vdout0_10ck1890 FIND v(dout0_10) AT=950.025n

.meas tran vdout0_11ck1890 FIND v(dout0_11) AT=950.025n

.meas tran vdout0_12ck1890 FIND v(dout0_12) AT=950.025n

.meas tran vdout0_13ck1890 FIND v(dout0_13) AT=950.025n

.meas tran vdout0_14ck1890 FIND v(dout0_14) AT=950.025n

.meas tran vdout0_15ck1890 FIND v(dout0_15) AT=950.025n

.meas tran vdout0_16ck1890 FIND v(dout0_16) AT=950.025n

.meas tran vdout0_17ck1890 FIND v(dout0_17) AT=950.025n

.meas tran vdout0_18ck1890 FIND v(dout0_18) AT=950.025n

.meas tran vdout0_19ck1890 FIND v(dout0_19) AT=950.025n

.meas tran vdout0_20ck1890 FIND v(dout0_20) AT=950.025n

.meas tran vdout0_21ck1890 FIND v(dout0_21) AT=950.025n

.meas tran vdout0_22ck1890 FIND v(dout0_22) AT=950.025n

.meas tran vdout0_23ck1890 FIND v(dout0_23) AT=950.025n

.meas tran vdout0_24ck1890 FIND v(dout0_24) AT=950.025n

.meas tran vdout0_25ck1890 FIND v(dout0_25) AT=950.025n

.meas tran vdout0_26ck1890 FIND v(dout0_26) AT=950.025n

.meas tran vdout0_27ck1890 FIND v(dout0_27) AT=950.025n

.meas tran vdout0_28ck1890 FIND v(dout0_28) AT=950.025n

.meas tran vdout0_29ck1890 FIND v(dout0_29) AT=950.025n

.meas tran vdout0_30ck1890 FIND v(dout0_30) AT=950.025n

.meas tran vdout0_31ck1890 FIND v(dout0_31) AT=950.025n

.meas tran vdout0_32ck1890 FIND v(dout0_32) AT=950.025n

.meas tran vdout0_33ck1890 FIND v(dout0_33) AT=950.025n

.meas tran vdout0_34ck1890 FIND v(dout0_34) AT=950.025n

.meas tran vdout0_35ck1890 FIND v(dout0_35) AT=950.025n

.meas tran vdout0_36ck1890 FIND v(dout0_36) AT=950.025n

.meas tran vdout0_37ck1890 FIND v(dout0_37) AT=950.025n

.meas tran vdout0_38ck1890 FIND v(dout0_38) AT=950.025n

.meas tran vdout0_39ck1890 FIND v(dout0_39) AT=950.025n

.meas tran vdout0_40ck1890 FIND v(dout0_40) AT=950.025n

.meas tran vdout0_41ck1890 FIND v(dout0_41) AT=950.025n

.meas tran vdout0_42ck1890 FIND v(dout0_42) AT=950.025n

.meas tran vdout0_43ck1890 FIND v(dout0_43) AT=950.025n

.meas tran vdout0_44ck1890 FIND v(dout0_44) AT=950.025n

.meas tran vdout0_45ck1890 FIND v(dout0_45) AT=950.025n

.meas tran vdout0_46ck1890 FIND v(dout0_46) AT=950.025n

.meas tran vdout0_47ck1890 FIND v(dout0_47) AT=950.025n

.meas tran vdout0_48ck1890 FIND v(dout0_48) AT=950.025n

.meas tran vdout0_49ck1890 FIND v(dout0_49) AT=950.025n

.meas tran vdout0_50ck1890 FIND v(dout0_50) AT=950.025n

.meas tran vdout0_51ck1890 FIND v(dout0_51) AT=950.025n

.meas tran vdout0_52ck1890 FIND v(dout0_52) AT=950.025n

.meas tran vdout0_53ck1890 FIND v(dout0_53) AT=950.025n

.meas tran vdout0_54ck1890 FIND v(dout0_54) AT=950.025n

.meas tran vdout0_55ck1890 FIND v(dout0_55) AT=950.025n

.meas tran vdout0_56ck1890 FIND v(dout0_56) AT=950.025n

.meas tran vdout0_57ck1890 FIND v(dout0_57) AT=950.025n

.meas tran vdout0_58ck1890 FIND v(dout0_58) AT=950.025n

.meas tran vdout0_59ck1890 FIND v(dout0_59) AT=950.025n

.meas tran vdout0_60ck1890 FIND v(dout0_60) AT=950.025n

.meas tran vdout0_61ck1890 FIND v(dout0_61) AT=950.025n

.meas tran vdout0_62ck1890 FIND v(dout0_62) AT=950.025n

.meas tran vdout0_63ck1890 FIND v(dout0_63) AT=950.025n

.meas tran vdout0_64ck1890 FIND v(dout0_64) AT=950.025n

.meas tran vdout0_65ck1890 FIND v(dout0_65) AT=950.025n

.meas tran vdout0_66ck1890 FIND v(dout0_66) AT=950.025n

.meas tran vdout0_67ck1890 FIND v(dout0_67) AT=950.025n

.meas tran vdout0_68ck1890 FIND v(dout0_68) AT=950.025n

.meas tran vdout0_69ck1890 FIND v(dout0_69) AT=950.025n

.meas tran vdout0_70ck1890 FIND v(dout0_70) AT=950.025n

.meas tran vdout0_71ck1890 FIND v(dout0_71) AT=950.025n

.meas tran vdout0_72ck1890 FIND v(dout0_72) AT=950.025n

.meas tran vdout0_73ck1890 FIND v(dout0_73) AT=950.025n

.meas tran vdout0_74ck1890 FIND v(dout0_74) AT=950.025n

.meas tran vdout0_75ck1890 FIND v(dout0_75) AT=950.025n

.meas tran vdout0_76ck1890 FIND v(dout0_76) AT=950.025n

.meas tran vdout0_77ck1890 FIND v(dout0_77) AT=950.025n

.meas tran vdout0_78ck1890 FIND v(dout0_78) AT=950.025n

.meas tran vdout0_79ck1890 FIND v(dout0_79) AT=950.025n

.meas tran vdout0_80ck1890 FIND v(dout0_80) AT=950.025n

.meas tran vdout0_81ck1890 FIND v(dout0_81) AT=950.025n

.meas tran vdout0_82ck1890 FIND v(dout0_82) AT=950.025n

.meas tran vdout0_83ck1890 FIND v(dout0_83) AT=950.025n

.meas tran vdout0_84ck1890 FIND v(dout0_84) AT=950.025n

.meas tran vdout0_85ck1890 FIND v(dout0_85) AT=950.025n

.meas tran vdout0_86ck1890 FIND v(dout0_86) AT=950.025n

.meas tran vdout0_87ck1890 FIND v(dout0_87) AT=950.025n

.meas tran vdout0_88ck1890 FIND v(dout0_88) AT=950.025n

.meas tran vdout0_89ck1890 FIND v(dout0_89) AT=950.025n

.meas tran vdout0_90ck1890 FIND v(dout0_90) AT=950.025n

.meas tran vdout0_91ck1890 FIND v(dout0_91) AT=950.025n

.meas tran vdout0_92ck1890 FIND v(dout0_92) AT=950.025n

.meas tran vdout0_93ck1890 FIND v(dout0_93) AT=950.025n

.meas tran vdout0_94ck1890 FIND v(dout0_94) AT=950.025n

.meas tran vdout0_95ck1890 FIND v(dout0_95) AT=950.025n

.meas tran vdout0_96ck1890 FIND v(dout0_96) AT=950.025n

.meas tran vdout0_97ck1890 FIND v(dout0_97) AT=950.025n

.meas tran vdout0_98ck1890 FIND v(dout0_98) AT=950.025n

.meas tran vdout0_99ck1890 FIND v(dout0_99) AT=950.025n

.meas tran vdout0_100ck1890 FIND v(dout0_100) AT=950.025n

.meas tran vdout0_101ck1890 FIND v(dout0_101) AT=950.025n

.meas tran vdout0_102ck1890 FIND v(dout0_102) AT=950.025n

.meas tran vdout0_103ck1890 FIND v(dout0_103) AT=950.025n

.meas tran vdout0_104ck1890 FIND v(dout0_104) AT=950.025n

.meas tran vdout0_105ck1890 FIND v(dout0_105) AT=950.025n

.meas tran vdout0_106ck1890 FIND v(dout0_106) AT=950.025n

.meas tran vdout0_107ck1890 FIND v(dout0_107) AT=950.025n

.meas tran vdout0_108ck1890 FIND v(dout0_108) AT=950.025n

.meas tran vdout0_109ck1890 FIND v(dout0_109) AT=950.025n

.meas tran vdout0_110ck1890 FIND v(dout0_110) AT=950.025n

.meas tran vdout0_111ck1890 FIND v(dout0_111) AT=950.025n

.meas tran vdout0_112ck1890 FIND v(dout0_112) AT=950.025n

.meas tran vdout0_113ck1890 FIND v(dout0_113) AT=950.025n

.meas tran vdout0_114ck1890 FIND v(dout0_114) AT=950.025n

.meas tran vdout0_115ck1890 FIND v(dout0_115) AT=950.025n

.meas tran vdout0_116ck1890 FIND v(dout0_116) AT=950.025n

.meas tran vdout0_117ck1890 FIND v(dout0_117) AT=950.025n

.meas tran vdout0_118ck1890 FIND v(dout0_118) AT=950.025n

.meas tran vdout0_119ck1890 FIND v(dout0_119) AT=950.025n

.meas tran vdout0_120ck1890 FIND v(dout0_120) AT=950.025n

.meas tran vdout0_121ck1890 FIND v(dout0_121) AT=950.025n

.meas tran vdout0_122ck1890 FIND v(dout0_122) AT=950.025n

.meas tran vdout0_123ck1890 FIND v(dout0_123) AT=950.025n

.meas tran vdout0_124ck1890 FIND v(dout0_124) AT=950.025n

.meas tran vdout0_125ck1890 FIND v(dout0_125) AT=950.025n

.meas tran vdout0_126ck1890 FIND v(dout0_126) AT=950.025n

.meas tran vdout0_127ck1890 FIND v(dout0_127) AT=950.025n

.meas tran vdout0_128ck1890 FIND v(dout0_128) AT=950.025n

.meas tran vdout0_129ck1890 FIND v(dout0_129) AT=950.025n

.meas tran vdout0_130ck1890 FIND v(dout0_130) AT=950.025n

.meas tran vdout0_131ck1890 FIND v(dout0_131) AT=950.025n

.meas tran vdout0_132ck1890 FIND v(dout0_132) AT=950.025n

.meas tran vdout0_133ck1890 FIND v(dout0_133) AT=950.025n

.meas tran vdout0_134ck1890 FIND v(dout0_134) AT=950.025n

.meas tran vdout0_135ck1890 FIND v(dout0_135) AT=950.025n

.meas tran vdout0_136ck1890 FIND v(dout0_136) AT=950.025n

.meas tran vdout0_137ck1890 FIND v(dout0_137) AT=950.025n

.meas tran vdout0_138ck1890 FIND v(dout0_138) AT=950.025n

.meas tran vdout0_139ck1890 FIND v(dout0_139) AT=950.025n

.meas tran vdout0_140ck1890 FIND v(dout0_140) AT=950.025n

.meas tran vdout0_141ck1890 FIND v(dout0_141) AT=950.025n

.meas tran vdout0_142ck1890 FIND v(dout0_142) AT=950.025n

.meas tran vdout0_143ck1890 FIND v(dout0_143) AT=950.025n

.meas tran vdout0_144ck1890 FIND v(dout0_144) AT=950.025n

.meas tran vdout0_145ck1890 FIND v(dout0_145) AT=950.025n

.meas tran vdout0_146ck1890 FIND v(dout0_146) AT=950.025n

.meas tran vdout0_147ck1890 FIND v(dout0_147) AT=950.025n

.meas tran vdout0_148ck1890 FIND v(dout0_148) AT=950.025n

.meas tran vdout0_149ck1890 FIND v(dout0_149) AT=950.025n

.meas tran vdout0_0ck1910 FIND v(dout0_0) AT=960.025n

.meas tran vdout0_1ck1910 FIND v(dout0_1) AT=960.025n

.meas tran vdout0_2ck1910 FIND v(dout0_2) AT=960.025n

.meas tran vdout0_3ck1910 FIND v(dout0_3) AT=960.025n

.meas tran vdout0_4ck1910 FIND v(dout0_4) AT=960.025n

.meas tran vdout0_5ck1910 FIND v(dout0_5) AT=960.025n

.meas tran vdout0_6ck1910 FIND v(dout0_6) AT=960.025n

.meas tran vdout0_7ck1910 FIND v(dout0_7) AT=960.025n

.meas tran vdout0_8ck1910 FIND v(dout0_8) AT=960.025n

.meas tran vdout0_9ck1910 FIND v(dout0_9) AT=960.025n

.meas tran vdout0_10ck1910 FIND v(dout0_10) AT=960.025n

.meas tran vdout0_11ck1910 FIND v(dout0_11) AT=960.025n

.meas tran vdout0_12ck1910 FIND v(dout0_12) AT=960.025n

.meas tran vdout0_13ck1910 FIND v(dout0_13) AT=960.025n

.meas tran vdout0_14ck1910 FIND v(dout0_14) AT=960.025n

.meas tran vdout0_15ck1910 FIND v(dout0_15) AT=960.025n

.meas tran vdout0_16ck1910 FIND v(dout0_16) AT=960.025n

.meas tran vdout0_17ck1910 FIND v(dout0_17) AT=960.025n

.meas tran vdout0_18ck1910 FIND v(dout0_18) AT=960.025n

.meas tran vdout0_19ck1910 FIND v(dout0_19) AT=960.025n

.meas tran vdout0_20ck1910 FIND v(dout0_20) AT=960.025n

.meas tran vdout0_21ck1910 FIND v(dout0_21) AT=960.025n

.meas tran vdout0_22ck1910 FIND v(dout0_22) AT=960.025n

.meas tran vdout0_23ck1910 FIND v(dout0_23) AT=960.025n

.meas tran vdout0_24ck1910 FIND v(dout0_24) AT=960.025n

.meas tran vdout0_25ck1910 FIND v(dout0_25) AT=960.025n

.meas tran vdout0_26ck1910 FIND v(dout0_26) AT=960.025n

.meas tran vdout0_27ck1910 FIND v(dout0_27) AT=960.025n

.meas tran vdout0_28ck1910 FIND v(dout0_28) AT=960.025n

.meas tran vdout0_29ck1910 FIND v(dout0_29) AT=960.025n

.meas tran vdout0_30ck1910 FIND v(dout0_30) AT=960.025n

.meas tran vdout0_31ck1910 FIND v(dout0_31) AT=960.025n

.meas tran vdout0_32ck1910 FIND v(dout0_32) AT=960.025n

.meas tran vdout0_33ck1910 FIND v(dout0_33) AT=960.025n

.meas tran vdout0_34ck1910 FIND v(dout0_34) AT=960.025n

.meas tran vdout0_35ck1910 FIND v(dout0_35) AT=960.025n

.meas tran vdout0_36ck1910 FIND v(dout0_36) AT=960.025n

.meas tran vdout0_37ck1910 FIND v(dout0_37) AT=960.025n

.meas tran vdout0_38ck1910 FIND v(dout0_38) AT=960.025n

.meas tran vdout0_39ck1910 FIND v(dout0_39) AT=960.025n

.meas tran vdout0_40ck1910 FIND v(dout0_40) AT=960.025n

.meas tran vdout0_41ck1910 FIND v(dout0_41) AT=960.025n

.meas tran vdout0_42ck1910 FIND v(dout0_42) AT=960.025n

.meas tran vdout0_43ck1910 FIND v(dout0_43) AT=960.025n

.meas tran vdout0_44ck1910 FIND v(dout0_44) AT=960.025n

.meas tran vdout0_45ck1910 FIND v(dout0_45) AT=960.025n

.meas tran vdout0_46ck1910 FIND v(dout0_46) AT=960.025n

.meas tran vdout0_47ck1910 FIND v(dout0_47) AT=960.025n

.meas tran vdout0_48ck1910 FIND v(dout0_48) AT=960.025n

.meas tran vdout0_49ck1910 FIND v(dout0_49) AT=960.025n

.meas tran vdout0_50ck1910 FIND v(dout0_50) AT=960.025n

.meas tran vdout0_51ck1910 FIND v(dout0_51) AT=960.025n

.meas tran vdout0_52ck1910 FIND v(dout0_52) AT=960.025n

.meas tran vdout0_53ck1910 FIND v(dout0_53) AT=960.025n

.meas tran vdout0_54ck1910 FIND v(dout0_54) AT=960.025n

.meas tran vdout0_55ck1910 FIND v(dout0_55) AT=960.025n

.meas tran vdout0_56ck1910 FIND v(dout0_56) AT=960.025n

.meas tran vdout0_57ck1910 FIND v(dout0_57) AT=960.025n

.meas tran vdout0_58ck1910 FIND v(dout0_58) AT=960.025n

.meas tran vdout0_59ck1910 FIND v(dout0_59) AT=960.025n

.meas tran vdout0_60ck1910 FIND v(dout0_60) AT=960.025n

.meas tran vdout0_61ck1910 FIND v(dout0_61) AT=960.025n

.meas tran vdout0_62ck1910 FIND v(dout0_62) AT=960.025n

.meas tran vdout0_63ck1910 FIND v(dout0_63) AT=960.025n

.meas tran vdout0_64ck1910 FIND v(dout0_64) AT=960.025n

.meas tran vdout0_65ck1910 FIND v(dout0_65) AT=960.025n

.meas tran vdout0_66ck1910 FIND v(dout0_66) AT=960.025n

.meas tran vdout0_67ck1910 FIND v(dout0_67) AT=960.025n

.meas tran vdout0_68ck1910 FIND v(dout0_68) AT=960.025n

.meas tran vdout0_69ck1910 FIND v(dout0_69) AT=960.025n

.meas tran vdout0_70ck1910 FIND v(dout0_70) AT=960.025n

.meas tran vdout0_71ck1910 FIND v(dout0_71) AT=960.025n

.meas tran vdout0_72ck1910 FIND v(dout0_72) AT=960.025n

.meas tran vdout0_73ck1910 FIND v(dout0_73) AT=960.025n

.meas tran vdout0_74ck1910 FIND v(dout0_74) AT=960.025n

.meas tran vdout0_75ck1910 FIND v(dout0_75) AT=960.025n

.meas tran vdout0_76ck1910 FIND v(dout0_76) AT=960.025n

.meas tran vdout0_77ck1910 FIND v(dout0_77) AT=960.025n

.meas tran vdout0_78ck1910 FIND v(dout0_78) AT=960.025n

.meas tran vdout0_79ck1910 FIND v(dout0_79) AT=960.025n

.meas tran vdout0_80ck1910 FIND v(dout0_80) AT=960.025n

.meas tran vdout0_81ck1910 FIND v(dout0_81) AT=960.025n

.meas tran vdout0_82ck1910 FIND v(dout0_82) AT=960.025n

.meas tran vdout0_83ck1910 FIND v(dout0_83) AT=960.025n

.meas tran vdout0_84ck1910 FIND v(dout0_84) AT=960.025n

.meas tran vdout0_85ck1910 FIND v(dout0_85) AT=960.025n

.meas tran vdout0_86ck1910 FIND v(dout0_86) AT=960.025n

.meas tran vdout0_87ck1910 FIND v(dout0_87) AT=960.025n

.meas tran vdout0_88ck1910 FIND v(dout0_88) AT=960.025n

.meas tran vdout0_89ck1910 FIND v(dout0_89) AT=960.025n

.meas tran vdout0_90ck1910 FIND v(dout0_90) AT=960.025n

.meas tran vdout0_91ck1910 FIND v(dout0_91) AT=960.025n

.meas tran vdout0_92ck1910 FIND v(dout0_92) AT=960.025n

.meas tran vdout0_93ck1910 FIND v(dout0_93) AT=960.025n

.meas tran vdout0_94ck1910 FIND v(dout0_94) AT=960.025n

.meas tran vdout0_95ck1910 FIND v(dout0_95) AT=960.025n

.meas tran vdout0_96ck1910 FIND v(dout0_96) AT=960.025n

.meas tran vdout0_97ck1910 FIND v(dout0_97) AT=960.025n

.meas tran vdout0_98ck1910 FIND v(dout0_98) AT=960.025n

.meas tran vdout0_99ck1910 FIND v(dout0_99) AT=960.025n

.meas tran vdout0_100ck1910 FIND v(dout0_100) AT=960.025n

.meas tran vdout0_101ck1910 FIND v(dout0_101) AT=960.025n

.meas tran vdout0_102ck1910 FIND v(dout0_102) AT=960.025n

.meas tran vdout0_103ck1910 FIND v(dout0_103) AT=960.025n

.meas tran vdout0_104ck1910 FIND v(dout0_104) AT=960.025n

.meas tran vdout0_105ck1910 FIND v(dout0_105) AT=960.025n

.meas tran vdout0_106ck1910 FIND v(dout0_106) AT=960.025n

.meas tran vdout0_107ck1910 FIND v(dout0_107) AT=960.025n

.meas tran vdout0_108ck1910 FIND v(dout0_108) AT=960.025n

.meas tran vdout0_109ck1910 FIND v(dout0_109) AT=960.025n

.meas tran vdout0_110ck1910 FIND v(dout0_110) AT=960.025n

.meas tran vdout0_111ck1910 FIND v(dout0_111) AT=960.025n

.meas tran vdout0_112ck1910 FIND v(dout0_112) AT=960.025n

.meas tran vdout0_113ck1910 FIND v(dout0_113) AT=960.025n

.meas tran vdout0_114ck1910 FIND v(dout0_114) AT=960.025n

.meas tran vdout0_115ck1910 FIND v(dout0_115) AT=960.025n

.meas tran vdout0_116ck1910 FIND v(dout0_116) AT=960.025n

.meas tran vdout0_117ck1910 FIND v(dout0_117) AT=960.025n

.meas tran vdout0_118ck1910 FIND v(dout0_118) AT=960.025n

.meas tran vdout0_119ck1910 FIND v(dout0_119) AT=960.025n

.meas tran vdout0_120ck1910 FIND v(dout0_120) AT=960.025n

.meas tran vdout0_121ck1910 FIND v(dout0_121) AT=960.025n

.meas tran vdout0_122ck1910 FIND v(dout0_122) AT=960.025n

.meas tran vdout0_123ck1910 FIND v(dout0_123) AT=960.025n

.meas tran vdout0_124ck1910 FIND v(dout0_124) AT=960.025n

.meas tran vdout0_125ck1910 FIND v(dout0_125) AT=960.025n

.meas tran vdout0_126ck1910 FIND v(dout0_126) AT=960.025n

.meas tran vdout0_127ck1910 FIND v(dout0_127) AT=960.025n

.meas tran vdout0_128ck1910 FIND v(dout0_128) AT=960.025n

.meas tran vdout0_129ck1910 FIND v(dout0_129) AT=960.025n

.meas tran vdout0_130ck1910 FIND v(dout0_130) AT=960.025n

.meas tran vdout0_131ck1910 FIND v(dout0_131) AT=960.025n

.meas tran vdout0_132ck1910 FIND v(dout0_132) AT=960.025n

.meas tran vdout0_133ck1910 FIND v(dout0_133) AT=960.025n

.meas tran vdout0_134ck1910 FIND v(dout0_134) AT=960.025n

.meas tran vdout0_135ck1910 FIND v(dout0_135) AT=960.025n

.meas tran vdout0_136ck1910 FIND v(dout0_136) AT=960.025n

.meas tran vdout0_137ck1910 FIND v(dout0_137) AT=960.025n

.meas tran vdout0_138ck1910 FIND v(dout0_138) AT=960.025n

.meas tran vdout0_139ck1910 FIND v(dout0_139) AT=960.025n

.meas tran vdout0_140ck1910 FIND v(dout0_140) AT=960.025n

.meas tran vdout0_141ck1910 FIND v(dout0_141) AT=960.025n

.meas tran vdout0_142ck1910 FIND v(dout0_142) AT=960.025n

.meas tran vdout0_143ck1910 FIND v(dout0_143) AT=960.025n

.meas tran vdout0_144ck1910 FIND v(dout0_144) AT=960.025n

.meas tran vdout0_145ck1910 FIND v(dout0_145) AT=960.025n

.meas tran vdout0_146ck1910 FIND v(dout0_146) AT=960.025n

.meas tran vdout0_147ck1910 FIND v(dout0_147) AT=960.025n

.meas tran vdout0_148ck1910 FIND v(dout0_148) AT=960.025n

.meas tran vdout0_149ck1910 FIND v(dout0_149) AT=960.025n

.meas tran vdout0_0ck1930 FIND v(dout0_0) AT=970.025n

.meas tran vdout0_1ck1930 FIND v(dout0_1) AT=970.025n

.meas tran vdout0_2ck1930 FIND v(dout0_2) AT=970.025n

.meas tran vdout0_3ck1930 FIND v(dout0_3) AT=970.025n

.meas tran vdout0_4ck1930 FIND v(dout0_4) AT=970.025n

.meas tran vdout0_5ck1930 FIND v(dout0_5) AT=970.025n

.meas tran vdout0_6ck1930 FIND v(dout0_6) AT=970.025n

.meas tran vdout0_7ck1930 FIND v(dout0_7) AT=970.025n

.meas tran vdout0_8ck1930 FIND v(dout0_8) AT=970.025n

.meas tran vdout0_9ck1930 FIND v(dout0_9) AT=970.025n

.meas tran vdout0_10ck1930 FIND v(dout0_10) AT=970.025n

.meas tran vdout0_11ck1930 FIND v(dout0_11) AT=970.025n

.meas tran vdout0_12ck1930 FIND v(dout0_12) AT=970.025n

.meas tran vdout0_13ck1930 FIND v(dout0_13) AT=970.025n

.meas tran vdout0_14ck1930 FIND v(dout0_14) AT=970.025n

.meas tran vdout0_15ck1930 FIND v(dout0_15) AT=970.025n

.meas tran vdout0_16ck1930 FIND v(dout0_16) AT=970.025n

.meas tran vdout0_17ck1930 FIND v(dout0_17) AT=970.025n

.meas tran vdout0_18ck1930 FIND v(dout0_18) AT=970.025n

.meas tran vdout0_19ck1930 FIND v(dout0_19) AT=970.025n

.meas tran vdout0_20ck1930 FIND v(dout0_20) AT=970.025n

.meas tran vdout0_21ck1930 FIND v(dout0_21) AT=970.025n

.meas tran vdout0_22ck1930 FIND v(dout0_22) AT=970.025n

.meas tran vdout0_23ck1930 FIND v(dout0_23) AT=970.025n

.meas tran vdout0_24ck1930 FIND v(dout0_24) AT=970.025n

.meas tran vdout0_25ck1930 FIND v(dout0_25) AT=970.025n

.meas tran vdout0_26ck1930 FIND v(dout0_26) AT=970.025n

.meas tran vdout0_27ck1930 FIND v(dout0_27) AT=970.025n

.meas tran vdout0_28ck1930 FIND v(dout0_28) AT=970.025n

.meas tran vdout0_29ck1930 FIND v(dout0_29) AT=970.025n

.meas tran vdout0_30ck1930 FIND v(dout0_30) AT=970.025n

.meas tran vdout0_31ck1930 FIND v(dout0_31) AT=970.025n

.meas tran vdout0_32ck1930 FIND v(dout0_32) AT=970.025n

.meas tran vdout0_33ck1930 FIND v(dout0_33) AT=970.025n

.meas tran vdout0_34ck1930 FIND v(dout0_34) AT=970.025n

.meas tran vdout0_35ck1930 FIND v(dout0_35) AT=970.025n

.meas tran vdout0_36ck1930 FIND v(dout0_36) AT=970.025n

.meas tran vdout0_37ck1930 FIND v(dout0_37) AT=970.025n

.meas tran vdout0_38ck1930 FIND v(dout0_38) AT=970.025n

.meas tran vdout0_39ck1930 FIND v(dout0_39) AT=970.025n

.meas tran vdout0_40ck1930 FIND v(dout0_40) AT=970.025n

.meas tran vdout0_41ck1930 FIND v(dout0_41) AT=970.025n

.meas tran vdout0_42ck1930 FIND v(dout0_42) AT=970.025n

.meas tran vdout0_43ck1930 FIND v(dout0_43) AT=970.025n

.meas tran vdout0_44ck1930 FIND v(dout0_44) AT=970.025n

.meas tran vdout0_45ck1930 FIND v(dout0_45) AT=970.025n

.meas tran vdout0_46ck1930 FIND v(dout0_46) AT=970.025n

.meas tran vdout0_47ck1930 FIND v(dout0_47) AT=970.025n

.meas tran vdout0_48ck1930 FIND v(dout0_48) AT=970.025n

.meas tran vdout0_49ck1930 FIND v(dout0_49) AT=970.025n

.meas tran vdout0_50ck1930 FIND v(dout0_50) AT=970.025n

.meas tran vdout0_51ck1930 FIND v(dout0_51) AT=970.025n

.meas tran vdout0_52ck1930 FIND v(dout0_52) AT=970.025n

.meas tran vdout0_53ck1930 FIND v(dout0_53) AT=970.025n

.meas tran vdout0_54ck1930 FIND v(dout0_54) AT=970.025n

.meas tran vdout0_55ck1930 FIND v(dout0_55) AT=970.025n

.meas tran vdout0_56ck1930 FIND v(dout0_56) AT=970.025n

.meas tran vdout0_57ck1930 FIND v(dout0_57) AT=970.025n

.meas tran vdout0_58ck1930 FIND v(dout0_58) AT=970.025n

.meas tran vdout0_59ck1930 FIND v(dout0_59) AT=970.025n

.meas tran vdout0_60ck1930 FIND v(dout0_60) AT=970.025n

.meas tran vdout0_61ck1930 FIND v(dout0_61) AT=970.025n

.meas tran vdout0_62ck1930 FIND v(dout0_62) AT=970.025n

.meas tran vdout0_63ck1930 FIND v(dout0_63) AT=970.025n

.meas tran vdout0_64ck1930 FIND v(dout0_64) AT=970.025n

.meas tran vdout0_65ck1930 FIND v(dout0_65) AT=970.025n

.meas tran vdout0_66ck1930 FIND v(dout0_66) AT=970.025n

.meas tran vdout0_67ck1930 FIND v(dout0_67) AT=970.025n

.meas tran vdout0_68ck1930 FIND v(dout0_68) AT=970.025n

.meas tran vdout0_69ck1930 FIND v(dout0_69) AT=970.025n

.meas tran vdout0_70ck1930 FIND v(dout0_70) AT=970.025n

.meas tran vdout0_71ck1930 FIND v(dout0_71) AT=970.025n

.meas tran vdout0_72ck1930 FIND v(dout0_72) AT=970.025n

.meas tran vdout0_73ck1930 FIND v(dout0_73) AT=970.025n

.meas tran vdout0_74ck1930 FIND v(dout0_74) AT=970.025n

.meas tran vdout0_75ck1930 FIND v(dout0_75) AT=970.025n

.meas tran vdout0_76ck1930 FIND v(dout0_76) AT=970.025n

.meas tran vdout0_77ck1930 FIND v(dout0_77) AT=970.025n

.meas tran vdout0_78ck1930 FIND v(dout0_78) AT=970.025n

.meas tran vdout0_79ck1930 FIND v(dout0_79) AT=970.025n

.meas tran vdout0_80ck1930 FIND v(dout0_80) AT=970.025n

.meas tran vdout0_81ck1930 FIND v(dout0_81) AT=970.025n

.meas tran vdout0_82ck1930 FIND v(dout0_82) AT=970.025n

.meas tran vdout0_83ck1930 FIND v(dout0_83) AT=970.025n

.meas tran vdout0_84ck1930 FIND v(dout0_84) AT=970.025n

.meas tran vdout0_85ck1930 FIND v(dout0_85) AT=970.025n

.meas tran vdout0_86ck1930 FIND v(dout0_86) AT=970.025n

.meas tran vdout0_87ck1930 FIND v(dout0_87) AT=970.025n

.meas tran vdout0_88ck1930 FIND v(dout0_88) AT=970.025n

.meas tran vdout0_89ck1930 FIND v(dout0_89) AT=970.025n

.meas tran vdout0_90ck1930 FIND v(dout0_90) AT=970.025n

.meas tran vdout0_91ck1930 FIND v(dout0_91) AT=970.025n

.meas tran vdout0_92ck1930 FIND v(dout0_92) AT=970.025n

.meas tran vdout0_93ck1930 FIND v(dout0_93) AT=970.025n

.meas tran vdout0_94ck1930 FIND v(dout0_94) AT=970.025n

.meas tran vdout0_95ck1930 FIND v(dout0_95) AT=970.025n

.meas tran vdout0_96ck1930 FIND v(dout0_96) AT=970.025n

.meas tran vdout0_97ck1930 FIND v(dout0_97) AT=970.025n

.meas tran vdout0_98ck1930 FIND v(dout0_98) AT=970.025n

.meas tran vdout0_99ck1930 FIND v(dout0_99) AT=970.025n

.meas tran vdout0_100ck1930 FIND v(dout0_100) AT=970.025n

.meas tran vdout0_101ck1930 FIND v(dout0_101) AT=970.025n

.meas tran vdout0_102ck1930 FIND v(dout0_102) AT=970.025n

.meas tran vdout0_103ck1930 FIND v(dout0_103) AT=970.025n

.meas tran vdout0_104ck1930 FIND v(dout0_104) AT=970.025n

.meas tran vdout0_105ck1930 FIND v(dout0_105) AT=970.025n

.meas tran vdout0_106ck1930 FIND v(dout0_106) AT=970.025n

.meas tran vdout0_107ck1930 FIND v(dout0_107) AT=970.025n

.meas tran vdout0_108ck1930 FIND v(dout0_108) AT=970.025n

.meas tran vdout0_109ck1930 FIND v(dout0_109) AT=970.025n

.meas tran vdout0_110ck1930 FIND v(dout0_110) AT=970.025n

.meas tran vdout0_111ck1930 FIND v(dout0_111) AT=970.025n

.meas tran vdout0_112ck1930 FIND v(dout0_112) AT=970.025n

.meas tran vdout0_113ck1930 FIND v(dout0_113) AT=970.025n

.meas tran vdout0_114ck1930 FIND v(dout0_114) AT=970.025n

.meas tran vdout0_115ck1930 FIND v(dout0_115) AT=970.025n

.meas tran vdout0_116ck1930 FIND v(dout0_116) AT=970.025n

.meas tran vdout0_117ck1930 FIND v(dout0_117) AT=970.025n

.meas tran vdout0_118ck1930 FIND v(dout0_118) AT=970.025n

.meas tran vdout0_119ck1930 FIND v(dout0_119) AT=970.025n

.meas tran vdout0_120ck1930 FIND v(dout0_120) AT=970.025n

.meas tran vdout0_121ck1930 FIND v(dout0_121) AT=970.025n

.meas tran vdout0_122ck1930 FIND v(dout0_122) AT=970.025n

.meas tran vdout0_123ck1930 FIND v(dout0_123) AT=970.025n

.meas tran vdout0_124ck1930 FIND v(dout0_124) AT=970.025n

.meas tran vdout0_125ck1930 FIND v(dout0_125) AT=970.025n

.meas tran vdout0_126ck1930 FIND v(dout0_126) AT=970.025n

.meas tran vdout0_127ck1930 FIND v(dout0_127) AT=970.025n

.meas tran vdout0_128ck1930 FIND v(dout0_128) AT=970.025n

.meas tran vdout0_129ck1930 FIND v(dout0_129) AT=970.025n

.meas tran vdout0_130ck1930 FIND v(dout0_130) AT=970.025n

.meas tran vdout0_131ck1930 FIND v(dout0_131) AT=970.025n

.meas tran vdout0_132ck1930 FIND v(dout0_132) AT=970.025n

.meas tran vdout0_133ck1930 FIND v(dout0_133) AT=970.025n

.meas tran vdout0_134ck1930 FIND v(dout0_134) AT=970.025n

.meas tran vdout0_135ck1930 FIND v(dout0_135) AT=970.025n

.meas tran vdout0_136ck1930 FIND v(dout0_136) AT=970.025n

.meas tran vdout0_137ck1930 FIND v(dout0_137) AT=970.025n

.meas tran vdout0_138ck1930 FIND v(dout0_138) AT=970.025n

.meas tran vdout0_139ck1930 FIND v(dout0_139) AT=970.025n

.meas tran vdout0_140ck1930 FIND v(dout0_140) AT=970.025n

.meas tran vdout0_141ck1930 FIND v(dout0_141) AT=970.025n

.meas tran vdout0_142ck1930 FIND v(dout0_142) AT=970.025n

.meas tran vdout0_143ck1930 FIND v(dout0_143) AT=970.025n

.meas tran vdout0_144ck1930 FIND v(dout0_144) AT=970.025n

.meas tran vdout0_145ck1930 FIND v(dout0_145) AT=970.025n

.meas tran vdout0_146ck1930 FIND v(dout0_146) AT=970.025n

.meas tran vdout0_147ck1930 FIND v(dout0_147) AT=970.025n

.meas tran vdout0_148ck1930 FIND v(dout0_148) AT=970.025n

.meas tran vdout0_149ck1930 FIND v(dout0_149) AT=970.025n

.meas tran vdout0_0ck1940 FIND v(dout0_0) AT=975.025n

.meas tran vdout0_1ck1940 FIND v(dout0_1) AT=975.025n

.meas tran vdout0_2ck1940 FIND v(dout0_2) AT=975.025n

.meas tran vdout0_3ck1940 FIND v(dout0_3) AT=975.025n

.meas tran vdout0_4ck1940 FIND v(dout0_4) AT=975.025n

.meas tran vdout0_5ck1940 FIND v(dout0_5) AT=975.025n

.meas tran vdout0_6ck1940 FIND v(dout0_6) AT=975.025n

.meas tran vdout0_7ck1940 FIND v(dout0_7) AT=975.025n

.meas tran vdout0_8ck1940 FIND v(dout0_8) AT=975.025n

.meas tran vdout0_9ck1940 FIND v(dout0_9) AT=975.025n

.meas tran vdout0_10ck1940 FIND v(dout0_10) AT=975.025n

.meas tran vdout0_11ck1940 FIND v(dout0_11) AT=975.025n

.meas tran vdout0_12ck1940 FIND v(dout0_12) AT=975.025n

.meas tran vdout0_13ck1940 FIND v(dout0_13) AT=975.025n

.meas tran vdout0_14ck1940 FIND v(dout0_14) AT=975.025n

.meas tran vdout0_15ck1940 FIND v(dout0_15) AT=975.025n

.meas tran vdout0_16ck1940 FIND v(dout0_16) AT=975.025n

.meas tran vdout0_17ck1940 FIND v(dout0_17) AT=975.025n

.meas tran vdout0_18ck1940 FIND v(dout0_18) AT=975.025n

.meas tran vdout0_19ck1940 FIND v(dout0_19) AT=975.025n

.meas tran vdout0_20ck1940 FIND v(dout0_20) AT=975.025n

.meas tran vdout0_21ck1940 FIND v(dout0_21) AT=975.025n

.meas tran vdout0_22ck1940 FIND v(dout0_22) AT=975.025n

.meas tran vdout0_23ck1940 FIND v(dout0_23) AT=975.025n

.meas tran vdout0_24ck1940 FIND v(dout0_24) AT=975.025n

.meas tran vdout0_25ck1940 FIND v(dout0_25) AT=975.025n

.meas tran vdout0_26ck1940 FIND v(dout0_26) AT=975.025n

.meas tran vdout0_27ck1940 FIND v(dout0_27) AT=975.025n

.meas tran vdout0_28ck1940 FIND v(dout0_28) AT=975.025n

.meas tran vdout0_29ck1940 FIND v(dout0_29) AT=975.025n

.meas tran vdout0_30ck1940 FIND v(dout0_30) AT=975.025n

.meas tran vdout0_31ck1940 FIND v(dout0_31) AT=975.025n

.meas tran vdout0_32ck1940 FIND v(dout0_32) AT=975.025n

.meas tran vdout0_33ck1940 FIND v(dout0_33) AT=975.025n

.meas tran vdout0_34ck1940 FIND v(dout0_34) AT=975.025n

.meas tran vdout0_35ck1940 FIND v(dout0_35) AT=975.025n

.meas tran vdout0_36ck1940 FIND v(dout0_36) AT=975.025n

.meas tran vdout0_37ck1940 FIND v(dout0_37) AT=975.025n

.meas tran vdout0_38ck1940 FIND v(dout0_38) AT=975.025n

.meas tran vdout0_39ck1940 FIND v(dout0_39) AT=975.025n

.meas tran vdout0_40ck1940 FIND v(dout0_40) AT=975.025n

.meas tran vdout0_41ck1940 FIND v(dout0_41) AT=975.025n

.meas tran vdout0_42ck1940 FIND v(dout0_42) AT=975.025n

.meas tran vdout0_43ck1940 FIND v(dout0_43) AT=975.025n

.meas tran vdout0_44ck1940 FIND v(dout0_44) AT=975.025n

.meas tran vdout0_45ck1940 FIND v(dout0_45) AT=975.025n

.meas tran vdout0_46ck1940 FIND v(dout0_46) AT=975.025n

.meas tran vdout0_47ck1940 FIND v(dout0_47) AT=975.025n

.meas tran vdout0_48ck1940 FIND v(dout0_48) AT=975.025n

.meas tran vdout0_49ck1940 FIND v(dout0_49) AT=975.025n

.meas tran vdout0_50ck1940 FIND v(dout0_50) AT=975.025n

.meas tran vdout0_51ck1940 FIND v(dout0_51) AT=975.025n

.meas tran vdout0_52ck1940 FIND v(dout0_52) AT=975.025n

.meas tran vdout0_53ck1940 FIND v(dout0_53) AT=975.025n

.meas tran vdout0_54ck1940 FIND v(dout0_54) AT=975.025n

.meas tran vdout0_55ck1940 FIND v(dout0_55) AT=975.025n

.meas tran vdout0_56ck1940 FIND v(dout0_56) AT=975.025n

.meas tran vdout0_57ck1940 FIND v(dout0_57) AT=975.025n

.meas tran vdout0_58ck1940 FIND v(dout0_58) AT=975.025n

.meas tran vdout0_59ck1940 FIND v(dout0_59) AT=975.025n

.meas tran vdout0_60ck1940 FIND v(dout0_60) AT=975.025n

.meas tran vdout0_61ck1940 FIND v(dout0_61) AT=975.025n

.meas tran vdout0_62ck1940 FIND v(dout0_62) AT=975.025n

.meas tran vdout0_63ck1940 FIND v(dout0_63) AT=975.025n

.meas tran vdout0_64ck1940 FIND v(dout0_64) AT=975.025n

.meas tran vdout0_65ck1940 FIND v(dout0_65) AT=975.025n

.meas tran vdout0_66ck1940 FIND v(dout0_66) AT=975.025n

.meas tran vdout0_67ck1940 FIND v(dout0_67) AT=975.025n

.meas tran vdout0_68ck1940 FIND v(dout0_68) AT=975.025n

.meas tran vdout0_69ck1940 FIND v(dout0_69) AT=975.025n

.meas tran vdout0_70ck1940 FIND v(dout0_70) AT=975.025n

.meas tran vdout0_71ck1940 FIND v(dout0_71) AT=975.025n

.meas tran vdout0_72ck1940 FIND v(dout0_72) AT=975.025n

.meas tran vdout0_73ck1940 FIND v(dout0_73) AT=975.025n

.meas tran vdout0_74ck1940 FIND v(dout0_74) AT=975.025n

.meas tran vdout0_75ck1940 FIND v(dout0_75) AT=975.025n

.meas tran vdout0_76ck1940 FIND v(dout0_76) AT=975.025n

.meas tran vdout0_77ck1940 FIND v(dout0_77) AT=975.025n

.meas tran vdout0_78ck1940 FIND v(dout0_78) AT=975.025n

.meas tran vdout0_79ck1940 FIND v(dout0_79) AT=975.025n

.meas tran vdout0_80ck1940 FIND v(dout0_80) AT=975.025n

.meas tran vdout0_81ck1940 FIND v(dout0_81) AT=975.025n

.meas tran vdout0_82ck1940 FIND v(dout0_82) AT=975.025n

.meas tran vdout0_83ck1940 FIND v(dout0_83) AT=975.025n

.meas tran vdout0_84ck1940 FIND v(dout0_84) AT=975.025n

.meas tran vdout0_85ck1940 FIND v(dout0_85) AT=975.025n

.meas tran vdout0_86ck1940 FIND v(dout0_86) AT=975.025n

.meas tran vdout0_87ck1940 FIND v(dout0_87) AT=975.025n

.meas tran vdout0_88ck1940 FIND v(dout0_88) AT=975.025n

.meas tran vdout0_89ck1940 FIND v(dout0_89) AT=975.025n

.meas tran vdout0_90ck1940 FIND v(dout0_90) AT=975.025n

.meas tran vdout0_91ck1940 FIND v(dout0_91) AT=975.025n

.meas tran vdout0_92ck1940 FIND v(dout0_92) AT=975.025n

.meas tran vdout0_93ck1940 FIND v(dout0_93) AT=975.025n

.meas tran vdout0_94ck1940 FIND v(dout0_94) AT=975.025n

.meas tran vdout0_95ck1940 FIND v(dout0_95) AT=975.025n

.meas tran vdout0_96ck1940 FIND v(dout0_96) AT=975.025n

.meas tran vdout0_97ck1940 FIND v(dout0_97) AT=975.025n

.meas tran vdout0_98ck1940 FIND v(dout0_98) AT=975.025n

.meas tran vdout0_99ck1940 FIND v(dout0_99) AT=975.025n

.meas tran vdout0_100ck1940 FIND v(dout0_100) AT=975.025n

.meas tran vdout0_101ck1940 FIND v(dout0_101) AT=975.025n

.meas tran vdout0_102ck1940 FIND v(dout0_102) AT=975.025n

.meas tran vdout0_103ck1940 FIND v(dout0_103) AT=975.025n

.meas tran vdout0_104ck1940 FIND v(dout0_104) AT=975.025n

.meas tran vdout0_105ck1940 FIND v(dout0_105) AT=975.025n

.meas tran vdout0_106ck1940 FIND v(dout0_106) AT=975.025n

.meas tran vdout0_107ck1940 FIND v(dout0_107) AT=975.025n

.meas tran vdout0_108ck1940 FIND v(dout0_108) AT=975.025n

.meas tran vdout0_109ck1940 FIND v(dout0_109) AT=975.025n

.meas tran vdout0_110ck1940 FIND v(dout0_110) AT=975.025n

.meas tran vdout0_111ck1940 FIND v(dout0_111) AT=975.025n

.meas tran vdout0_112ck1940 FIND v(dout0_112) AT=975.025n

.meas tran vdout0_113ck1940 FIND v(dout0_113) AT=975.025n

.meas tran vdout0_114ck1940 FIND v(dout0_114) AT=975.025n

.meas tran vdout0_115ck1940 FIND v(dout0_115) AT=975.025n

.meas tran vdout0_116ck1940 FIND v(dout0_116) AT=975.025n

.meas tran vdout0_117ck1940 FIND v(dout0_117) AT=975.025n

.meas tran vdout0_118ck1940 FIND v(dout0_118) AT=975.025n

.meas tran vdout0_119ck1940 FIND v(dout0_119) AT=975.025n

.meas tran vdout0_120ck1940 FIND v(dout0_120) AT=975.025n

.meas tran vdout0_121ck1940 FIND v(dout0_121) AT=975.025n

.meas tran vdout0_122ck1940 FIND v(dout0_122) AT=975.025n

.meas tran vdout0_123ck1940 FIND v(dout0_123) AT=975.025n

.meas tran vdout0_124ck1940 FIND v(dout0_124) AT=975.025n

.meas tran vdout0_125ck1940 FIND v(dout0_125) AT=975.025n

.meas tran vdout0_126ck1940 FIND v(dout0_126) AT=975.025n

.meas tran vdout0_127ck1940 FIND v(dout0_127) AT=975.025n

.meas tran vdout0_128ck1940 FIND v(dout0_128) AT=975.025n

.meas tran vdout0_129ck1940 FIND v(dout0_129) AT=975.025n

.meas tran vdout0_130ck1940 FIND v(dout0_130) AT=975.025n

.meas tran vdout0_131ck1940 FIND v(dout0_131) AT=975.025n

.meas tran vdout0_132ck1940 FIND v(dout0_132) AT=975.025n

.meas tran vdout0_133ck1940 FIND v(dout0_133) AT=975.025n

.meas tran vdout0_134ck1940 FIND v(dout0_134) AT=975.025n

.meas tran vdout0_135ck1940 FIND v(dout0_135) AT=975.025n

.meas tran vdout0_136ck1940 FIND v(dout0_136) AT=975.025n

.meas tran vdout0_137ck1940 FIND v(dout0_137) AT=975.025n

.meas tran vdout0_138ck1940 FIND v(dout0_138) AT=975.025n

.meas tran vdout0_139ck1940 FIND v(dout0_139) AT=975.025n

.meas tran vdout0_140ck1940 FIND v(dout0_140) AT=975.025n

.meas tran vdout0_141ck1940 FIND v(dout0_141) AT=975.025n

.meas tran vdout0_142ck1940 FIND v(dout0_142) AT=975.025n

.meas tran vdout0_143ck1940 FIND v(dout0_143) AT=975.025n

.meas tran vdout0_144ck1940 FIND v(dout0_144) AT=975.025n

.meas tran vdout0_145ck1940 FIND v(dout0_145) AT=975.025n

.meas tran vdout0_146ck1940 FIND v(dout0_146) AT=975.025n

.meas tran vdout0_147ck1940 FIND v(dout0_147) AT=975.025n

.meas tran vdout0_148ck1940 FIND v(dout0_148) AT=975.025n

.meas tran vdout0_149ck1940 FIND v(dout0_149) AT=975.025n

.meas tran vdout0_0ck1970 FIND v(dout0_0) AT=990.025n

.meas tran vdout0_1ck1970 FIND v(dout0_1) AT=990.025n

.meas tran vdout0_2ck1970 FIND v(dout0_2) AT=990.025n

.meas tran vdout0_3ck1970 FIND v(dout0_3) AT=990.025n

.meas tran vdout0_4ck1970 FIND v(dout0_4) AT=990.025n

.meas tran vdout0_5ck1970 FIND v(dout0_5) AT=990.025n

.meas tran vdout0_6ck1970 FIND v(dout0_6) AT=990.025n

.meas tran vdout0_7ck1970 FIND v(dout0_7) AT=990.025n

.meas tran vdout0_8ck1970 FIND v(dout0_8) AT=990.025n

.meas tran vdout0_9ck1970 FIND v(dout0_9) AT=990.025n

.meas tran vdout0_10ck1970 FIND v(dout0_10) AT=990.025n

.meas tran vdout0_11ck1970 FIND v(dout0_11) AT=990.025n

.meas tran vdout0_12ck1970 FIND v(dout0_12) AT=990.025n

.meas tran vdout0_13ck1970 FIND v(dout0_13) AT=990.025n

.meas tran vdout0_14ck1970 FIND v(dout0_14) AT=990.025n

.meas tran vdout0_15ck1970 FIND v(dout0_15) AT=990.025n

.meas tran vdout0_16ck1970 FIND v(dout0_16) AT=990.025n

.meas tran vdout0_17ck1970 FIND v(dout0_17) AT=990.025n

.meas tran vdout0_18ck1970 FIND v(dout0_18) AT=990.025n

.meas tran vdout0_19ck1970 FIND v(dout0_19) AT=990.025n

.meas tran vdout0_20ck1970 FIND v(dout0_20) AT=990.025n

.meas tran vdout0_21ck1970 FIND v(dout0_21) AT=990.025n

.meas tran vdout0_22ck1970 FIND v(dout0_22) AT=990.025n

.meas tran vdout0_23ck1970 FIND v(dout0_23) AT=990.025n

.meas tran vdout0_24ck1970 FIND v(dout0_24) AT=990.025n

.meas tran vdout0_25ck1970 FIND v(dout0_25) AT=990.025n

.meas tran vdout0_26ck1970 FIND v(dout0_26) AT=990.025n

.meas tran vdout0_27ck1970 FIND v(dout0_27) AT=990.025n

.meas tran vdout0_28ck1970 FIND v(dout0_28) AT=990.025n

.meas tran vdout0_29ck1970 FIND v(dout0_29) AT=990.025n

.meas tran vdout0_30ck1970 FIND v(dout0_30) AT=990.025n

.meas tran vdout0_31ck1970 FIND v(dout0_31) AT=990.025n

.meas tran vdout0_32ck1970 FIND v(dout0_32) AT=990.025n

.meas tran vdout0_33ck1970 FIND v(dout0_33) AT=990.025n

.meas tran vdout0_34ck1970 FIND v(dout0_34) AT=990.025n

.meas tran vdout0_35ck1970 FIND v(dout0_35) AT=990.025n

.meas tran vdout0_36ck1970 FIND v(dout0_36) AT=990.025n

.meas tran vdout0_37ck1970 FIND v(dout0_37) AT=990.025n

.meas tran vdout0_38ck1970 FIND v(dout0_38) AT=990.025n

.meas tran vdout0_39ck1970 FIND v(dout0_39) AT=990.025n

.meas tran vdout0_40ck1970 FIND v(dout0_40) AT=990.025n

.meas tran vdout0_41ck1970 FIND v(dout0_41) AT=990.025n

.meas tran vdout0_42ck1970 FIND v(dout0_42) AT=990.025n

.meas tran vdout0_43ck1970 FIND v(dout0_43) AT=990.025n

.meas tran vdout0_44ck1970 FIND v(dout0_44) AT=990.025n

.meas tran vdout0_45ck1970 FIND v(dout0_45) AT=990.025n

.meas tran vdout0_46ck1970 FIND v(dout0_46) AT=990.025n

.meas tran vdout0_47ck1970 FIND v(dout0_47) AT=990.025n

.meas tran vdout0_48ck1970 FIND v(dout0_48) AT=990.025n

.meas tran vdout0_49ck1970 FIND v(dout0_49) AT=990.025n

.meas tran vdout0_50ck1970 FIND v(dout0_50) AT=990.025n

.meas tran vdout0_51ck1970 FIND v(dout0_51) AT=990.025n

.meas tran vdout0_52ck1970 FIND v(dout0_52) AT=990.025n

.meas tran vdout0_53ck1970 FIND v(dout0_53) AT=990.025n

.meas tran vdout0_54ck1970 FIND v(dout0_54) AT=990.025n

.meas tran vdout0_55ck1970 FIND v(dout0_55) AT=990.025n

.meas tran vdout0_56ck1970 FIND v(dout0_56) AT=990.025n

.meas tran vdout0_57ck1970 FIND v(dout0_57) AT=990.025n

.meas tran vdout0_58ck1970 FIND v(dout0_58) AT=990.025n

.meas tran vdout0_59ck1970 FIND v(dout0_59) AT=990.025n

.meas tran vdout0_60ck1970 FIND v(dout0_60) AT=990.025n

.meas tran vdout0_61ck1970 FIND v(dout0_61) AT=990.025n

.meas tran vdout0_62ck1970 FIND v(dout0_62) AT=990.025n

.meas tran vdout0_63ck1970 FIND v(dout0_63) AT=990.025n

.meas tran vdout0_64ck1970 FIND v(dout0_64) AT=990.025n

.meas tran vdout0_65ck1970 FIND v(dout0_65) AT=990.025n

.meas tran vdout0_66ck1970 FIND v(dout0_66) AT=990.025n

.meas tran vdout0_67ck1970 FIND v(dout0_67) AT=990.025n

.meas tran vdout0_68ck1970 FIND v(dout0_68) AT=990.025n

.meas tran vdout0_69ck1970 FIND v(dout0_69) AT=990.025n

.meas tran vdout0_70ck1970 FIND v(dout0_70) AT=990.025n

.meas tran vdout0_71ck1970 FIND v(dout0_71) AT=990.025n

.meas tran vdout0_72ck1970 FIND v(dout0_72) AT=990.025n

.meas tran vdout0_73ck1970 FIND v(dout0_73) AT=990.025n

.meas tran vdout0_74ck1970 FIND v(dout0_74) AT=990.025n

.meas tran vdout0_75ck1970 FIND v(dout0_75) AT=990.025n

.meas tran vdout0_76ck1970 FIND v(dout0_76) AT=990.025n

.meas tran vdout0_77ck1970 FIND v(dout0_77) AT=990.025n

.meas tran vdout0_78ck1970 FIND v(dout0_78) AT=990.025n

.meas tran vdout0_79ck1970 FIND v(dout0_79) AT=990.025n

.meas tran vdout0_80ck1970 FIND v(dout0_80) AT=990.025n

.meas tran vdout0_81ck1970 FIND v(dout0_81) AT=990.025n

.meas tran vdout0_82ck1970 FIND v(dout0_82) AT=990.025n

.meas tran vdout0_83ck1970 FIND v(dout0_83) AT=990.025n

.meas tran vdout0_84ck1970 FIND v(dout0_84) AT=990.025n

.meas tran vdout0_85ck1970 FIND v(dout0_85) AT=990.025n

.meas tran vdout0_86ck1970 FIND v(dout0_86) AT=990.025n

.meas tran vdout0_87ck1970 FIND v(dout0_87) AT=990.025n

.meas tran vdout0_88ck1970 FIND v(dout0_88) AT=990.025n

.meas tran vdout0_89ck1970 FIND v(dout0_89) AT=990.025n

.meas tran vdout0_90ck1970 FIND v(dout0_90) AT=990.025n

.meas tran vdout0_91ck1970 FIND v(dout0_91) AT=990.025n

.meas tran vdout0_92ck1970 FIND v(dout0_92) AT=990.025n

.meas tran vdout0_93ck1970 FIND v(dout0_93) AT=990.025n

.meas tran vdout0_94ck1970 FIND v(dout0_94) AT=990.025n

.meas tran vdout0_95ck1970 FIND v(dout0_95) AT=990.025n

.meas tran vdout0_96ck1970 FIND v(dout0_96) AT=990.025n

.meas tran vdout0_97ck1970 FIND v(dout0_97) AT=990.025n

.meas tran vdout0_98ck1970 FIND v(dout0_98) AT=990.025n

.meas tran vdout0_99ck1970 FIND v(dout0_99) AT=990.025n

.meas tran vdout0_100ck1970 FIND v(dout0_100) AT=990.025n

.meas tran vdout0_101ck1970 FIND v(dout0_101) AT=990.025n

.meas tran vdout0_102ck1970 FIND v(dout0_102) AT=990.025n

.meas tran vdout0_103ck1970 FIND v(dout0_103) AT=990.025n

.meas tran vdout0_104ck1970 FIND v(dout0_104) AT=990.025n

.meas tran vdout0_105ck1970 FIND v(dout0_105) AT=990.025n

.meas tran vdout0_106ck1970 FIND v(dout0_106) AT=990.025n

.meas tran vdout0_107ck1970 FIND v(dout0_107) AT=990.025n

.meas tran vdout0_108ck1970 FIND v(dout0_108) AT=990.025n

.meas tran vdout0_109ck1970 FIND v(dout0_109) AT=990.025n

.meas tran vdout0_110ck1970 FIND v(dout0_110) AT=990.025n

.meas tran vdout0_111ck1970 FIND v(dout0_111) AT=990.025n

.meas tran vdout0_112ck1970 FIND v(dout0_112) AT=990.025n

.meas tran vdout0_113ck1970 FIND v(dout0_113) AT=990.025n

.meas tran vdout0_114ck1970 FIND v(dout0_114) AT=990.025n

.meas tran vdout0_115ck1970 FIND v(dout0_115) AT=990.025n

.meas tran vdout0_116ck1970 FIND v(dout0_116) AT=990.025n

.meas tran vdout0_117ck1970 FIND v(dout0_117) AT=990.025n

.meas tran vdout0_118ck1970 FIND v(dout0_118) AT=990.025n

.meas tran vdout0_119ck1970 FIND v(dout0_119) AT=990.025n

.meas tran vdout0_120ck1970 FIND v(dout0_120) AT=990.025n

.meas tran vdout0_121ck1970 FIND v(dout0_121) AT=990.025n

.meas tran vdout0_122ck1970 FIND v(dout0_122) AT=990.025n

.meas tran vdout0_123ck1970 FIND v(dout0_123) AT=990.025n

.meas tran vdout0_124ck1970 FIND v(dout0_124) AT=990.025n

.meas tran vdout0_125ck1970 FIND v(dout0_125) AT=990.025n

.meas tran vdout0_126ck1970 FIND v(dout0_126) AT=990.025n

.meas tran vdout0_127ck1970 FIND v(dout0_127) AT=990.025n

.meas tran vdout0_128ck1970 FIND v(dout0_128) AT=990.025n

.meas tran vdout0_129ck1970 FIND v(dout0_129) AT=990.025n

.meas tran vdout0_130ck1970 FIND v(dout0_130) AT=990.025n

.meas tran vdout0_131ck1970 FIND v(dout0_131) AT=990.025n

.meas tran vdout0_132ck1970 FIND v(dout0_132) AT=990.025n

.meas tran vdout0_133ck1970 FIND v(dout0_133) AT=990.025n

.meas tran vdout0_134ck1970 FIND v(dout0_134) AT=990.025n

.meas tran vdout0_135ck1970 FIND v(dout0_135) AT=990.025n

.meas tran vdout0_136ck1970 FIND v(dout0_136) AT=990.025n

.meas tran vdout0_137ck1970 FIND v(dout0_137) AT=990.025n

.meas tran vdout0_138ck1970 FIND v(dout0_138) AT=990.025n

.meas tran vdout0_139ck1970 FIND v(dout0_139) AT=990.025n

.meas tran vdout0_140ck1970 FIND v(dout0_140) AT=990.025n

.meas tran vdout0_141ck1970 FIND v(dout0_141) AT=990.025n

.meas tran vdout0_142ck1970 FIND v(dout0_142) AT=990.025n

.meas tran vdout0_143ck1970 FIND v(dout0_143) AT=990.025n

.meas tran vdout0_144ck1970 FIND v(dout0_144) AT=990.025n

.meas tran vdout0_145ck1970 FIND v(dout0_145) AT=990.025n

.meas tran vdout0_146ck1970 FIND v(dout0_146) AT=990.025n

.meas tran vdout0_147ck1970 FIND v(dout0_147) AT=990.025n

.meas tran vdout0_148ck1970 FIND v(dout0_148) AT=990.025n

.meas tran vdout0_149ck1970 FIND v(dout0_149) AT=990.025n

.meas tran vdout0_0ck2040 FIND v(dout0_0) AT=1025.025n

.meas tran vdout0_1ck2040 FIND v(dout0_1) AT=1025.025n

.meas tran vdout0_2ck2040 FIND v(dout0_2) AT=1025.025n

.meas tran vdout0_3ck2040 FIND v(dout0_3) AT=1025.025n

.meas tran vdout0_4ck2040 FIND v(dout0_4) AT=1025.025n

.meas tran vdout0_5ck2040 FIND v(dout0_5) AT=1025.025n

.meas tran vdout0_6ck2040 FIND v(dout0_6) AT=1025.025n

.meas tran vdout0_7ck2040 FIND v(dout0_7) AT=1025.025n

.meas tran vdout0_8ck2040 FIND v(dout0_8) AT=1025.025n

.meas tran vdout0_9ck2040 FIND v(dout0_9) AT=1025.025n

.meas tran vdout0_10ck2040 FIND v(dout0_10) AT=1025.025n

.meas tran vdout0_11ck2040 FIND v(dout0_11) AT=1025.025n

.meas tran vdout0_12ck2040 FIND v(dout0_12) AT=1025.025n

.meas tran vdout0_13ck2040 FIND v(dout0_13) AT=1025.025n

.meas tran vdout0_14ck2040 FIND v(dout0_14) AT=1025.025n

.meas tran vdout0_15ck2040 FIND v(dout0_15) AT=1025.025n

.meas tran vdout0_16ck2040 FIND v(dout0_16) AT=1025.025n

.meas tran vdout0_17ck2040 FIND v(dout0_17) AT=1025.025n

.meas tran vdout0_18ck2040 FIND v(dout0_18) AT=1025.025n

.meas tran vdout0_19ck2040 FIND v(dout0_19) AT=1025.025n

.meas tran vdout0_20ck2040 FIND v(dout0_20) AT=1025.025n

.meas tran vdout0_21ck2040 FIND v(dout0_21) AT=1025.025n

.meas tran vdout0_22ck2040 FIND v(dout0_22) AT=1025.025n

.meas tran vdout0_23ck2040 FIND v(dout0_23) AT=1025.025n

.meas tran vdout0_24ck2040 FIND v(dout0_24) AT=1025.025n

.meas tran vdout0_25ck2040 FIND v(dout0_25) AT=1025.025n

.meas tran vdout0_26ck2040 FIND v(dout0_26) AT=1025.025n

.meas tran vdout0_27ck2040 FIND v(dout0_27) AT=1025.025n

.meas tran vdout0_28ck2040 FIND v(dout0_28) AT=1025.025n

.meas tran vdout0_29ck2040 FIND v(dout0_29) AT=1025.025n

.meas tran vdout0_30ck2040 FIND v(dout0_30) AT=1025.025n

.meas tran vdout0_31ck2040 FIND v(dout0_31) AT=1025.025n

.meas tran vdout0_32ck2040 FIND v(dout0_32) AT=1025.025n

.meas tran vdout0_33ck2040 FIND v(dout0_33) AT=1025.025n

.meas tran vdout0_34ck2040 FIND v(dout0_34) AT=1025.025n

.meas tran vdout0_35ck2040 FIND v(dout0_35) AT=1025.025n

.meas tran vdout0_36ck2040 FIND v(dout0_36) AT=1025.025n

.meas tran vdout0_37ck2040 FIND v(dout0_37) AT=1025.025n

.meas tran vdout0_38ck2040 FIND v(dout0_38) AT=1025.025n

.meas tran vdout0_39ck2040 FIND v(dout0_39) AT=1025.025n

.meas tran vdout0_40ck2040 FIND v(dout0_40) AT=1025.025n

.meas tran vdout0_41ck2040 FIND v(dout0_41) AT=1025.025n

.meas tran vdout0_42ck2040 FIND v(dout0_42) AT=1025.025n

.meas tran vdout0_43ck2040 FIND v(dout0_43) AT=1025.025n

.meas tran vdout0_44ck2040 FIND v(dout0_44) AT=1025.025n

.meas tran vdout0_45ck2040 FIND v(dout0_45) AT=1025.025n

.meas tran vdout0_46ck2040 FIND v(dout0_46) AT=1025.025n

.meas tran vdout0_47ck2040 FIND v(dout0_47) AT=1025.025n

.meas tran vdout0_48ck2040 FIND v(dout0_48) AT=1025.025n

.meas tran vdout0_49ck2040 FIND v(dout0_49) AT=1025.025n

.meas tran vdout0_50ck2040 FIND v(dout0_50) AT=1025.025n

.meas tran vdout0_51ck2040 FIND v(dout0_51) AT=1025.025n

.meas tran vdout0_52ck2040 FIND v(dout0_52) AT=1025.025n

.meas tran vdout0_53ck2040 FIND v(dout0_53) AT=1025.025n

.meas tran vdout0_54ck2040 FIND v(dout0_54) AT=1025.025n

.meas tran vdout0_55ck2040 FIND v(dout0_55) AT=1025.025n

.meas tran vdout0_56ck2040 FIND v(dout0_56) AT=1025.025n

.meas tran vdout0_57ck2040 FIND v(dout0_57) AT=1025.025n

.meas tran vdout0_58ck2040 FIND v(dout0_58) AT=1025.025n

.meas tran vdout0_59ck2040 FIND v(dout0_59) AT=1025.025n

.meas tran vdout0_60ck2040 FIND v(dout0_60) AT=1025.025n

.meas tran vdout0_61ck2040 FIND v(dout0_61) AT=1025.025n

.meas tran vdout0_62ck2040 FIND v(dout0_62) AT=1025.025n

.meas tran vdout0_63ck2040 FIND v(dout0_63) AT=1025.025n

.meas tran vdout0_64ck2040 FIND v(dout0_64) AT=1025.025n

.meas tran vdout0_65ck2040 FIND v(dout0_65) AT=1025.025n

.meas tran vdout0_66ck2040 FIND v(dout0_66) AT=1025.025n

.meas tran vdout0_67ck2040 FIND v(dout0_67) AT=1025.025n

.meas tran vdout0_68ck2040 FIND v(dout0_68) AT=1025.025n

.meas tran vdout0_69ck2040 FIND v(dout0_69) AT=1025.025n

.meas tran vdout0_70ck2040 FIND v(dout0_70) AT=1025.025n

.meas tran vdout0_71ck2040 FIND v(dout0_71) AT=1025.025n

.meas tran vdout0_72ck2040 FIND v(dout0_72) AT=1025.025n

.meas tran vdout0_73ck2040 FIND v(dout0_73) AT=1025.025n

.meas tran vdout0_74ck2040 FIND v(dout0_74) AT=1025.025n

.meas tran vdout0_75ck2040 FIND v(dout0_75) AT=1025.025n

.meas tran vdout0_76ck2040 FIND v(dout0_76) AT=1025.025n

.meas tran vdout0_77ck2040 FIND v(dout0_77) AT=1025.025n

.meas tran vdout0_78ck2040 FIND v(dout0_78) AT=1025.025n

.meas tran vdout0_79ck2040 FIND v(dout0_79) AT=1025.025n

.meas tran vdout0_80ck2040 FIND v(dout0_80) AT=1025.025n

.meas tran vdout0_81ck2040 FIND v(dout0_81) AT=1025.025n

.meas tran vdout0_82ck2040 FIND v(dout0_82) AT=1025.025n

.meas tran vdout0_83ck2040 FIND v(dout0_83) AT=1025.025n

.meas tran vdout0_84ck2040 FIND v(dout0_84) AT=1025.025n

.meas tran vdout0_85ck2040 FIND v(dout0_85) AT=1025.025n

.meas tran vdout0_86ck2040 FIND v(dout0_86) AT=1025.025n

.meas tran vdout0_87ck2040 FIND v(dout0_87) AT=1025.025n

.meas tran vdout0_88ck2040 FIND v(dout0_88) AT=1025.025n

.meas tran vdout0_89ck2040 FIND v(dout0_89) AT=1025.025n

.meas tran vdout0_90ck2040 FIND v(dout0_90) AT=1025.025n

.meas tran vdout0_91ck2040 FIND v(dout0_91) AT=1025.025n

.meas tran vdout0_92ck2040 FIND v(dout0_92) AT=1025.025n

.meas tran vdout0_93ck2040 FIND v(dout0_93) AT=1025.025n

.meas tran vdout0_94ck2040 FIND v(dout0_94) AT=1025.025n

.meas tran vdout0_95ck2040 FIND v(dout0_95) AT=1025.025n

.meas tran vdout0_96ck2040 FIND v(dout0_96) AT=1025.025n

.meas tran vdout0_97ck2040 FIND v(dout0_97) AT=1025.025n

.meas tran vdout0_98ck2040 FIND v(dout0_98) AT=1025.025n

.meas tran vdout0_99ck2040 FIND v(dout0_99) AT=1025.025n

.meas tran vdout0_100ck2040 FIND v(dout0_100) AT=1025.025n

.meas tran vdout0_101ck2040 FIND v(dout0_101) AT=1025.025n

.meas tran vdout0_102ck2040 FIND v(dout0_102) AT=1025.025n

.meas tran vdout0_103ck2040 FIND v(dout0_103) AT=1025.025n

.meas tran vdout0_104ck2040 FIND v(dout0_104) AT=1025.025n

.meas tran vdout0_105ck2040 FIND v(dout0_105) AT=1025.025n

.meas tran vdout0_106ck2040 FIND v(dout0_106) AT=1025.025n

.meas tran vdout0_107ck2040 FIND v(dout0_107) AT=1025.025n

.meas tran vdout0_108ck2040 FIND v(dout0_108) AT=1025.025n

.meas tran vdout0_109ck2040 FIND v(dout0_109) AT=1025.025n

.meas tran vdout0_110ck2040 FIND v(dout0_110) AT=1025.025n

.meas tran vdout0_111ck2040 FIND v(dout0_111) AT=1025.025n

.meas tran vdout0_112ck2040 FIND v(dout0_112) AT=1025.025n

.meas tran vdout0_113ck2040 FIND v(dout0_113) AT=1025.025n

.meas tran vdout0_114ck2040 FIND v(dout0_114) AT=1025.025n

.meas tran vdout0_115ck2040 FIND v(dout0_115) AT=1025.025n

.meas tran vdout0_116ck2040 FIND v(dout0_116) AT=1025.025n

.meas tran vdout0_117ck2040 FIND v(dout0_117) AT=1025.025n

.meas tran vdout0_118ck2040 FIND v(dout0_118) AT=1025.025n

.meas tran vdout0_119ck2040 FIND v(dout0_119) AT=1025.025n

.meas tran vdout0_120ck2040 FIND v(dout0_120) AT=1025.025n

.meas tran vdout0_121ck2040 FIND v(dout0_121) AT=1025.025n

.meas tran vdout0_122ck2040 FIND v(dout0_122) AT=1025.025n

.meas tran vdout0_123ck2040 FIND v(dout0_123) AT=1025.025n

.meas tran vdout0_124ck2040 FIND v(dout0_124) AT=1025.025n

.meas tran vdout0_125ck2040 FIND v(dout0_125) AT=1025.025n

.meas tran vdout0_126ck2040 FIND v(dout0_126) AT=1025.025n

.meas tran vdout0_127ck2040 FIND v(dout0_127) AT=1025.025n

.meas tran vdout0_128ck2040 FIND v(dout0_128) AT=1025.025n

.meas tran vdout0_129ck2040 FIND v(dout0_129) AT=1025.025n

.meas tran vdout0_130ck2040 FIND v(dout0_130) AT=1025.025n

.meas tran vdout0_131ck2040 FIND v(dout0_131) AT=1025.025n

.meas tran vdout0_132ck2040 FIND v(dout0_132) AT=1025.025n

.meas tran vdout0_133ck2040 FIND v(dout0_133) AT=1025.025n

.meas tran vdout0_134ck2040 FIND v(dout0_134) AT=1025.025n

.meas tran vdout0_135ck2040 FIND v(dout0_135) AT=1025.025n

.meas tran vdout0_136ck2040 FIND v(dout0_136) AT=1025.025n

.meas tran vdout0_137ck2040 FIND v(dout0_137) AT=1025.025n

.meas tran vdout0_138ck2040 FIND v(dout0_138) AT=1025.025n

.meas tran vdout0_139ck2040 FIND v(dout0_139) AT=1025.025n

.meas tran vdout0_140ck2040 FIND v(dout0_140) AT=1025.025n

.meas tran vdout0_141ck2040 FIND v(dout0_141) AT=1025.025n

.meas tran vdout0_142ck2040 FIND v(dout0_142) AT=1025.025n

.meas tran vdout0_143ck2040 FIND v(dout0_143) AT=1025.025n

.meas tran vdout0_144ck2040 FIND v(dout0_144) AT=1025.025n

.meas tran vdout0_145ck2040 FIND v(dout0_145) AT=1025.025n

.meas tran vdout0_146ck2040 FIND v(dout0_146) AT=1025.025n

.meas tran vdout0_147ck2040 FIND v(dout0_147) AT=1025.025n

.meas tran vdout0_148ck2040 FIND v(dout0_148) AT=1025.025n

.meas tran vdout0_149ck2040 FIND v(dout0_149) AT=1025.025n
