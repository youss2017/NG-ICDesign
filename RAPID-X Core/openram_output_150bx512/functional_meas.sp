.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_128ck40 FIND v(dout0_128) AT=25.025n

.meas tran vdout0_129ck40 FIND v(dout0_129) AT=25.025n

.meas tran vdout0_130ck40 FIND v(dout0_130) AT=25.025n

.meas tran vdout0_131ck40 FIND v(dout0_131) AT=25.025n

.meas tran vdout0_132ck40 FIND v(dout0_132) AT=25.025n

.meas tran vdout0_133ck40 FIND v(dout0_133) AT=25.025n

.meas tran vdout0_134ck40 FIND v(dout0_134) AT=25.025n

.meas tran vdout0_135ck40 FIND v(dout0_135) AT=25.025n

.meas tran vdout0_136ck40 FIND v(dout0_136) AT=25.025n

.meas tran vdout0_137ck40 FIND v(dout0_137) AT=25.025n

.meas tran vdout0_138ck40 FIND v(dout0_138) AT=25.025n

.meas tran vdout0_139ck40 FIND v(dout0_139) AT=25.025n

.meas tran vdout0_140ck40 FIND v(dout0_140) AT=25.025n

.meas tran vdout0_141ck40 FIND v(dout0_141) AT=25.025n

.meas tran vdout0_142ck40 FIND v(dout0_142) AT=25.025n

.meas tran vdout0_143ck40 FIND v(dout0_143) AT=25.025n

.meas tran vdout0_144ck40 FIND v(dout0_144) AT=25.025n

.meas tran vdout0_145ck40 FIND v(dout0_145) AT=25.025n

.meas tran vdout0_146ck40 FIND v(dout0_146) AT=25.025n

.meas tran vdout0_147ck40 FIND v(dout0_147) AT=25.025n

.meas tran vdout0_148ck40 FIND v(dout0_148) AT=25.025n

.meas tran vdout0_149ck40 FIND v(dout0_149) AT=25.025n

.meas tran vdout0_0ck70 FIND v(dout0_0) AT=40.025n

.meas tran vdout0_1ck70 FIND v(dout0_1) AT=40.025n

.meas tran vdout0_2ck70 FIND v(dout0_2) AT=40.025n

.meas tran vdout0_3ck70 FIND v(dout0_3) AT=40.025n

.meas tran vdout0_4ck70 FIND v(dout0_4) AT=40.025n

.meas tran vdout0_5ck70 FIND v(dout0_5) AT=40.025n

.meas tran vdout0_6ck70 FIND v(dout0_6) AT=40.025n

.meas tran vdout0_7ck70 FIND v(dout0_7) AT=40.025n

.meas tran vdout0_8ck70 FIND v(dout0_8) AT=40.025n

.meas tran vdout0_9ck70 FIND v(dout0_9) AT=40.025n

.meas tran vdout0_10ck70 FIND v(dout0_10) AT=40.025n

.meas tran vdout0_11ck70 FIND v(dout0_11) AT=40.025n

.meas tran vdout0_12ck70 FIND v(dout0_12) AT=40.025n

.meas tran vdout0_13ck70 FIND v(dout0_13) AT=40.025n

.meas tran vdout0_14ck70 FIND v(dout0_14) AT=40.025n

.meas tran vdout0_15ck70 FIND v(dout0_15) AT=40.025n

.meas tran vdout0_16ck70 FIND v(dout0_16) AT=40.025n

.meas tran vdout0_17ck70 FIND v(dout0_17) AT=40.025n

.meas tran vdout0_18ck70 FIND v(dout0_18) AT=40.025n

.meas tran vdout0_19ck70 FIND v(dout0_19) AT=40.025n

.meas tran vdout0_20ck70 FIND v(dout0_20) AT=40.025n

.meas tran vdout0_21ck70 FIND v(dout0_21) AT=40.025n

.meas tran vdout0_22ck70 FIND v(dout0_22) AT=40.025n

.meas tran vdout0_23ck70 FIND v(dout0_23) AT=40.025n

.meas tran vdout0_24ck70 FIND v(dout0_24) AT=40.025n

.meas tran vdout0_25ck70 FIND v(dout0_25) AT=40.025n

.meas tran vdout0_26ck70 FIND v(dout0_26) AT=40.025n

.meas tran vdout0_27ck70 FIND v(dout0_27) AT=40.025n

.meas tran vdout0_28ck70 FIND v(dout0_28) AT=40.025n

.meas tran vdout0_29ck70 FIND v(dout0_29) AT=40.025n

.meas tran vdout0_30ck70 FIND v(dout0_30) AT=40.025n

.meas tran vdout0_31ck70 FIND v(dout0_31) AT=40.025n

.meas tran vdout0_32ck70 FIND v(dout0_32) AT=40.025n

.meas tran vdout0_33ck70 FIND v(dout0_33) AT=40.025n

.meas tran vdout0_34ck70 FIND v(dout0_34) AT=40.025n

.meas tran vdout0_35ck70 FIND v(dout0_35) AT=40.025n

.meas tran vdout0_36ck70 FIND v(dout0_36) AT=40.025n

.meas tran vdout0_37ck70 FIND v(dout0_37) AT=40.025n

.meas tran vdout0_38ck70 FIND v(dout0_38) AT=40.025n

.meas tran vdout0_39ck70 FIND v(dout0_39) AT=40.025n

.meas tran vdout0_40ck70 FIND v(dout0_40) AT=40.025n

.meas tran vdout0_41ck70 FIND v(dout0_41) AT=40.025n

.meas tran vdout0_42ck70 FIND v(dout0_42) AT=40.025n

.meas tran vdout0_43ck70 FIND v(dout0_43) AT=40.025n

.meas tran vdout0_44ck70 FIND v(dout0_44) AT=40.025n

.meas tran vdout0_45ck70 FIND v(dout0_45) AT=40.025n

.meas tran vdout0_46ck70 FIND v(dout0_46) AT=40.025n

.meas tran vdout0_47ck70 FIND v(dout0_47) AT=40.025n

.meas tran vdout0_48ck70 FIND v(dout0_48) AT=40.025n

.meas tran vdout0_49ck70 FIND v(dout0_49) AT=40.025n

.meas tran vdout0_50ck70 FIND v(dout0_50) AT=40.025n

.meas tran vdout0_51ck70 FIND v(dout0_51) AT=40.025n

.meas tran vdout0_52ck70 FIND v(dout0_52) AT=40.025n

.meas tran vdout0_53ck70 FIND v(dout0_53) AT=40.025n

.meas tran vdout0_54ck70 FIND v(dout0_54) AT=40.025n

.meas tran vdout0_55ck70 FIND v(dout0_55) AT=40.025n

.meas tran vdout0_56ck70 FIND v(dout0_56) AT=40.025n

.meas tran vdout0_57ck70 FIND v(dout0_57) AT=40.025n

.meas tran vdout0_58ck70 FIND v(dout0_58) AT=40.025n

.meas tran vdout0_59ck70 FIND v(dout0_59) AT=40.025n

.meas tran vdout0_60ck70 FIND v(dout0_60) AT=40.025n

.meas tran vdout0_61ck70 FIND v(dout0_61) AT=40.025n

.meas tran vdout0_62ck70 FIND v(dout0_62) AT=40.025n

.meas tran vdout0_63ck70 FIND v(dout0_63) AT=40.025n

.meas tran vdout0_64ck70 FIND v(dout0_64) AT=40.025n

.meas tran vdout0_65ck70 FIND v(dout0_65) AT=40.025n

.meas tran vdout0_66ck70 FIND v(dout0_66) AT=40.025n

.meas tran vdout0_67ck70 FIND v(dout0_67) AT=40.025n

.meas tran vdout0_68ck70 FIND v(dout0_68) AT=40.025n

.meas tran vdout0_69ck70 FIND v(dout0_69) AT=40.025n

.meas tran vdout0_70ck70 FIND v(dout0_70) AT=40.025n

.meas tran vdout0_71ck70 FIND v(dout0_71) AT=40.025n

.meas tran vdout0_72ck70 FIND v(dout0_72) AT=40.025n

.meas tran vdout0_73ck70 FIND v(dout0_73) AT=40.025n

.meas tran vdout0_74ck70 FIND v(dout0_74) AT=40.025n

.meas tran vdout0_75ck70 FIND v(dout0_75) AT=40.025n

.meas tran vdout0_76ck70 FIND v(dout0_76) AT=40.025n

.meas tran vdout0_77ck70 FIND v(dout0_77) AT=40.025n

.meas tran vdout0_78ck70 FIND v(dout0_78) AT=40.025n

.meas tran vdout0_79ck70 FIND v(dout0_79) AT=40.025n

.meas tran vdout0_80ck70 FIND v(dout0_80) AT=40.025n

.meas tran vdout0_81ck70 FIND v(dout0_81) AT=40.025n

.meas tran vdout0_82ck70 FIND v(dout0_82) AT=40.025n

.meas tran vdout0_83ck70 FIND v(dout0_83) AT=40.025n

.meas tran vdout0_84ck70 FIND v(dout0_84) AT=40.025n

.meas tran vdout0_85ck70 FIND v(dout0_85) AT=40.025n

.meas tran vdout0_86ck70 FIND v(dout0_86) AT=40.025n

.meas tran vdout0_87ck70 FIND v(dout0_87) AT=40.025n

.meas tran vdout0_88ck70 FIND v(dout0_88) AT=40.025n

.meas tran vdout0_89ck70 FIND v(dout0_89) AT=40.025n

.meas tran vdout0_90ck70 FIND v(dout0_90) AT=40.025n

.meas tran vdout0_91ck70 FIND v(dout0_91) AT=40.025n

.meas tran vdout0_92ck70 FIND v(dout0_92) AT=40.025n

.meas tran vdout0_93ck70 FIND v(dout0_93) AT=40.025n

.meas tran vdout0_94ck70 FIND v(dout0_94) AT=40.025n

.meas tran vdout0_95ck70 FIND v(dout0_95) AT=40.025n

.meas tran vdout0_96ck70 FIND v(dout0_96) AT=40.025n

.meas tran vdout0_97ck70 FIND v(dout0_97) AT=40.025n

.meas tran vdout0_98ck70 FIND v(dout0_98) AT=40.025n

.meas tran vdout0_99ck70 FIND v(dout0_99) AT=40.025n

.meas tran vdout0_100ck70 FIND v(dout0_100) AT=40.025n

.meas tran vdout0_101ck70 FIND v(dout0_101) AT=40.025n

.meas tran vdout0_102ck70 FIND v(dout0_102) AT=40.025n

.meas tran vdout0_103ck70 FIND v(dout0_103) AT=40.025n

.meas tran vdout0_104ck70 FIND v(dout0_104) AT=40.025n

.meas tran vdout0_105ck70 FIND v(dout0_105) AT=40.025n

.meas tran vdout0_106ck70 FIND v(dout0_106) AT=40.025n

.meas tran vdout0_107ck70 FIND v(dout0_107) AT=40.025n

.meas tran vdout0_108ck70 FIND v(dout0_108) AT=40.025n

.meas tran vdout0_109ck70 FIND v(dout0_109) AT=40.025n

.meas tran vdout0_110ck70 FIND v(dout0_110) AT=40.025n

.meas tran vdout0_111ck70 FIND v(dout0_111) AT=40.025n

.meas tran vdout0_112ck70 FIND v(dout0_112) AT=40.025n

.meas tran vdout0_113ck70 FIND v(dout0_113) AT=40.025n

.meas tran vdout0_114ck70 FIND v(dout0_114) AT=40.025n

.meas tran vdout0_115ck70 FIND v(dout0_115) AT=40.025n

.meas tran vdout0_116ck70 FIND v(dout0_116) AT=40.025n

.meas tran vdout0_117ck70 FIND v(dout0_117) AT=40.025n

.meas tran vdout0_118ck70 FIND v(dout0_118) AT=40.025n

.meas tran vdout0_119ck70 FIND v(dout0_119) AT=40.025n

.meas tran vdout0_120ck70 FIND v(dout0_120) AT=40.025n

.meas tran vdout0_121ck70 FIND v(dout0_121) AT=40.025n

.meas tran vdout0_122ck70 FIND v(dout0_122) AT=40.025n

.meas tran vdout0_123ck70 FIND v(dout0_123) AT=40.025n

.meas tran vdout0_124ck70 FIND v(dout0_124) AT=40.025n

.meas tran vdout0_125ck70 FIND v(dout0_125) AT=40.025n

.meas tran vdout0_126ck70 FIND v(dout0_126) AT=40.025n

.meas tran vdout0_127ck70 FIND v(dout0_127) AT=40.025n

.meas tran vdout0_128ck70 FIND v(dout0_128) AT=40.025n

.meas tran vdout0_129ck70 FIND v(dout0_129) AT=40.025n

.meas tran vdout0_130ck70 FIND v(dout0_130) AT=40.025n

.meas tran vdout0_131ck70 FIND v(dout0_131) AT=40.025n

.meas tran vdout0_132ck70 FIND v(dout0_132) AT=40.025n

.meas tran vdout0_133ck70 FIND v(dout0_133) AT=40.025n

.meas tran vdout0_134ck70 FIND v(dout0_134) AT=40.025n

.meas tran vdout0_135ck70 FIND v(dout0_135) AT=40.025n

.meas tran vdout0_136ck70 FIND v(dout0_136) AT=40.025n

.meas tran vdout0_137ck70 FIND v(dout0_137) AT=40.025n

.meas tran vdout0_138ck70 FIND v(dout0_138) AT=40.025n

.meas tran vdout0_139ck70 FIND v(dout0_139) AT=40.025n

.meas tran vdout0_140ck70 FIND v(dout0_140) AT=40.025n

.meas tran vdout0_141ck70 FIND v(dout0_141) AT=40.025n

.meas tran vdout0_142ck70 FIND v(dout0_142) AT=40.025n

.meas tran vdout0_143ck70 FIND v(dout0_143) AT=40.025n

.meas tran vdout0_144ck70 FIND v(dout0_144) AT=40.025n

.meas tran vdout0_145ck70 FIND v(dout0_145) AT=40.025n

.meas tran vdout0_146ck70 FIND v(dout0_146) AT=40.025n

.meas tran vdout0_147ck70 FIND v(dout0_147) AT=40.025n

.meas tran vdout0_148ck70 FIND v(dout0_148) AT=40.025n

.meas tran vdout0_149ck70 FIND v(dout0_149) AT=40.025n

.meas tran vdout0_0ck80 FIND v(dout0_0) AT=45.025n

.meas tran vdout0_1ck80 FIND v(dout0_1) AT=45.025n

.meas tran vdout0_2ck80 FIND v(dout0_2) AT=45.025n

.meas tran vdout0_3ck80 FIND v(dout0_3) AT=45.025n

.meas tran vdout0_4ck80 FIND v(dout0_4) AT=45.025n

.meas tran vdout0_5ck80 FIND v(dout0_5) AT=45.025n

.meas tran vdout0_6ck80 FIND v(dout0_6) AT=45.025n

.meas tran vdout0_7ck80 FIND v(dout0_7) AT=45.025n

.meas tran vdout0_8ck80 FIND v(dout0_8) AT=45.025n

.meas tran vdout0_9ck80 FIND v(dout0_9) AT=45.025n

.meas tran vdout0_10ck80 FIND v(dout0_10) AT=45.025n

.meas tran vdout0_11ck80 FIND v(dout0_11) AT=45.025n

.meas tran vdout0_12ck80 FIND v(dout0_12) AT=45.025n

.meas tran vdout0_13ck80 FIND v(dout0_13) AT=45.025n

.meas tran vdout0_14ck80 FIND v(dout0_14) AT=45.025n

.meas tran vdout0_15ck80 FIND v(dout0_15) AT=45.025n

.meas tran vdout0_16ck80 FIND v(dout0_16) AT=45.025n

.meas tran vdout0_17ck80 FIND v(dout0_17) AT=45.025n

.meas tran vdout0_18ck80 FIND v(dout0_18) AT=45.025n

.meas tran vdout0_19ck80 FIND v(dout0_19) AT=45.025n

.meas tran vdout0_20ck80 FIND v(dout0_20) AT=45.025n

.meas tran vdout0_21ck80 FIND v(dout0_21) AT=45.025n

.meas tran vdout0_22ck80 FIND v(dout0_22) AT=45.025n

.meas tran vdout0_23ck80 FIND v(dout0_23) AT=45.025n

.meas tran vdout0_24ck80 FIND v(dout0_24) AT=45.025n

.meas tran vdout0_25ck80 FIND v(dout0_25) AT=45.025n

.meas tran vdout0_26ck80 FIND v(dout0_26) AT=45.025n

.meas tran vdout0_27ck80 FIND v(dout0_27) AT=45.025n

.meas tran vdout0_28ck80 FIND v(dout0_28) AT=45.025n

.meas tran vdout0_29ck80 FIND v(dout0_29) AT=45.025n

.meas tran vdout0_30ck80 FIND v(dout0_30) AT=45.025n

.meas tran vdout0_31ck80 FIND v(dout0_31) AT=45.025n

.meas tran vdout0_32ck80 FIND v(dout0_32) AT=45.025n

.meas tran vdout0_33ck80 FIND v(dout0_33) AT=45.025n

.meas tran vdout0_34ck80 FIND v(dout0_34) AT=45.025n

.meas tran vdout0_35ck80 FIND v(dout0_35) AT=45.025n

.meas tran vdout0_36ck80 FIND v(dout0_36) AT=45.025n

.meas tran vdout0_37ck80 FIND v(dout0_37) AT=45.025n

.meas tran vdout0_38ck80 FIND v(dout0_38) AT=45.025n

.meas tran vdout0_39ck80 FIND v(dout0_39) AT=45.025n

.meas tran vdout0_40ck80 FIND v(dout0_40) AT=45.025n

.meas tran vdout0_41ck80 FIND v(dout0_41) AT=45.025n

.meas tran vdout0_42ck80 FIND v(dout0_42) AT=45.025n

.meas tran vdout0_43ck80 FIND v(dout0_43) AT=45.025n

.meas tran vdout0_44ck80 FIND v(dout0_44) AT=45.025n

.meas tran vdout0_45ck80 FIND v(dout0_45) AT=45.025n

.meas tran vdout0_46ck80 FIND v(dout0_46) AT=45.025n

.meas tran vdout0_47ck80 FIND v(dout0_47) AT=45.025n

.meas tran vdout0_48ck80 FIND v(dout0_48) AT=45.025n

.meas tran vdout0_49ck80 FIND v(dout0_49) AT=45.025n

.meas tran vdout0_50ck80 FIND v(dout0_50) AT=45.025n

.meas tran vdout0_51ck80 FIND v(dout0_51) AT=45.025n

.meas tran vdout0_52ck80 FIND v(dout0_52) AT=45.025n

.meas tran vdout0_53ck80 FIND v(dout0_53) AT=45.025n

.meas tran vdout0_54ck80 FIND v(dout0_54) AT=45.025n

.meas tran vdout0_55ck80 FIND v(dout0_55) AT=45.025n

.meas tran vdout0_56ck80 FIND v(dout0_56) AT=45.025n

.meas tran vdout0_57ck80 FIND v(dout0_57) AT=45.025n

.meas tran vdout0_58ck80 FIND v(dout0_58) AT=45.025n

.meas tran vdout0_59ck80 FIND v(dout0_59) AT=45.025n

.meas tran vdout0_60ck80 FIND v(dout0_60) AT=45.025n

.meas tran vdout0_61ck80 FIND v(dout0_61) AT=45.025n

.meas tran vdout0_62ck80 FIND v(dout0_62) AT=45.025n

.meas tran vdout0_63ck80 FIND v(dout0_63) AT=45.025n

.meas tran vdout0_64ck80 FIND v(dout0_64) AT=45.025n

.meas tran vdout0_65ck80 FIND v(dout0_65) AT=45.025n

.meas tran vdout0_66ck80 FIND v(dout0_66) AT=45.025n

.meas tran vdout0_67ck80 FIND v(dout0_67) AT=45.025n

.meas tran vdout0_68ck80 FIND v(dout0_68) AT=45.025n

.meas tran vdout0_69ck80 FIND v(dout0_69) AT=45.025n

.meas tran vdout0_70ck80 FIND v(dout0_70) AT=45.025n

.meas tran vdout0_71ck80 FIND v(dout0_71) AT=45.025n

.meas tran vdout0_72ck80 FIND v(dout0_72) AT=45.025n

.meas tran vdout0_73ck80 FIND v(dout0_73) AT=45.025n

.meas tran vdout0_74ck80 FIND v(dout0_74) AT=45.025n

.meas tran vdout0_75ck80 FIND v(dout0_75) AT=45.025n

.meas tran vdout0_76ck80 FIND v(dout0_76) AT=45.025n

.meas tran vdout0_77ck80 FIND v(dout0_77) AT=45.025n

.meas tran vdout0_78ck80 FIND v(dout0_78) AT=45.025n

.meas tran vdout0_79ck80 FIND v(dout0_79) AT=45.025n

.meas tran vdout0_80ck80 FIND v(dout0_80) AT=45.025n

.meas tran vdout0_81ck80 FIND v(dout0_81) AT=45.025n

.meas tran vdout0_82ck80 FIND v(dout0_82) AT=45.025n

.meas tran vdout0_83ck80 FIND v(dout0_83) AT=45.025n

.meas tran vdout0_84ck80 FIND v(dout0_84) AT=45.025n

.meas tran vdout0_85ck80 FIND v(dout0_85) AT=45.025n

.meas tran vdout0_86ck80 FIND v(dout0_86) AT=45.025n

.meas tran vdout0_87ck80 FIND v(dout0_87) AT=45.025n

.meas tran vdout0_88ck80 FIND v(dout0_88) AT=45.025n

.meas tran vdout0_89ck80 FIND v(dout0_89) AT=45.025n

.meas tran vdout0_90ck80 FIND v(dout0_90) AT=45.025n

.meas tran vdout0_91ck80 FIND v(dout0_91) AT=45.025n

.meas tran vdout0_92ck80 FIND v(dout0_92) AT=45.025n

.meas tran vdout0_93ck80 FIND v(dout0_93) AT=45.025n

.meas tran vdout0_94ck80 FIND v(dout0_94) AT=45.025n

.meas tran vdout0_95ck80 FIND v(dout0_95) AT=45.025n

.meas tran vdout0_96ck80 FIND v(dout0_96) AT=45.025n

.meas tran vdout0_97ck80 FIND v(dout0_97) AT=45.025n

.meas tran vdout0_98ck80 FIND v(dout0_98) AT=45.025n

.meas tran vdout0_99ck80 FIND v(dout0_99) AT=45.025n

.meas tran vdout0_100ck80 FIND v(dout0_100) AT=45.025n

.meas tran vdout0_101ck80 FIND v(dout0_101) AT=45.025n

.meas tran vdout0_102ck80 FIND v(dout0_102) AT=45.025n

.meas tran vdout0_103ck80 FIND v(dout0_103) AT=45.025n

.meas tran vdout0_104ck80 FIND v(dout0_104) AT=45.025n

.meas tran vdout0_105ck80 FIND v(dout0_105) AT=45.025n

.meas tran vdout0_106ck80 FIND v(dout0_106) AT=45.025n

.meas tran vdout0_107ck80 FIND v(dout0_107) AT=45.025n

.meas tran vdout0_108ck80 FIND v(dout0_108) AT=45.025n

.meas tran vdout0_109ck80 FIND v(dout0_109) AT=45.025n

.meas tran vdout0_110ck80 FIND v(dout0_110) AT=45.025n

.meas tran vdout0_111ck80 FIND v(dout0_111) AT=45.025n

.meas tran vdout0_112ck80 FIND v(dout0_112) AT=45.025n

.meas tran vdout0_113ck80 FIND v(dout0_113) AT=45.025n

.meas tran vdout0_114ck80 FIND v(dout0_114) AT=45.025n

.meas tran vdout0_115ck80 FIND v(dout0_115) AT=45.025n

.meas tran vdout0_116ck80 FIND v(dout0_116) AT=45.025n

.meas tran vdout0_117ck80 FIND v(dout0_117) AT=45.025n

.meas tran vdout0_118ck80 FIND v(dout0_118) AT=45.025n

.meas tran vdout0_119ck80 FIND v(dout0_119) AT=45.025n

.meas tran vdout0_120ck80 FIND v(dout0_120) AT=45.025n

.meas tran vdout0_121ck80 FIND v(dout0_121) AT=45.025n

.meas tran vdout0_122ck80 FIND v(dout0_122) AT=45.025n

.meas tran vdout0_123ck80 FIND v(dout0_123) AT=45.025n

.meas tran vdout0_124ck80 FIND v(dout0_124) AT=45.025n

.meas tran vdout0_125ck80 FIND v(dout0_125) AT=45.025n

.meas tran vdout0_126ck80 FIND v(dout0_126) AT=45.025n

.meas tran vdout0_127ck80 FIND v(dout0_127) AT=45.025n

.meas tran vdout0_128ck80 FIND v(dout0_128) AT=45.025n

.meas tran vdout0_129ck80 FIND v(dout0_129) AT=45.025n

.meas tran vdout0_130ck80 FIND v(dout0_130) AT=45.025n

.meas tran vdout0_131ck80 FIND v(dout0_131) AT=45.025n

.meas tran vdout0_132ck80 FIND v(dout0_132) AT=45.025n

.meas tran vdout0_133ck80 FIND v(dout0_133) AT=45.025n

.meas tran vdout0_134ck80 FIND v(dout0_134) AT=45.025n

.meas tran vdout0_135ck80 FIND v(dout0_135) AT=45.025n

.meas tran vdout0_136ck80 FIND v(dout0_136) AT=45.025n

.meas tran vdout0_137ck80 FIND v(dout0_137) AT=45.025n

.meas tran vdout0_138ck80 FIND v(dout0_138) AT=45.025n

.meas tran vdout0_139ck80 FIND v(dout0_139) AT=45.025n

.meas tran vdout0_140ck80 FIND v(dout0_140) AT=45.025n

.meas tran vdout0_141ck80 FIND v(dout0_141) AT=45.025n

.meas tran vdout0_142ck80 FIND v(dout0_142) AT=45.025n

.meas tran vdout0_143ck80 FIND v(dout0_143) AT=45.025n

.meas tran vdout0_144ck80 FIND v(dout0_144) AT=45.025n

.meas tran vdout0_145ck80 FIND v(dout0_145) AT=45.025n

.meas tran vdout0_146ck80 FIND v(dout0_146) AT=45.025n

.meas tran vdout0_147ck80 FIND v(dout0_147) AT=45.025n

.meas tran vdout0_148ck80 FIND v(dout0_148) AT=45.025n

.meas tran vdout0_149ck80 FIND v(dout0_149) AT=45.025n

.meas tran vdout0_0ck100 FIND v(dout0_0) AT=55.025n

.meas tran vdout0_1ck100 FIND v(dout0_1) AT=55.025n

.meas tran vdout0_2ck100 FIND v(dout0_2) AT=55.025n

.meas tran vdout0_3ck100 FIND v(dout0_3) AT=55.025n

.meas tran vdout0_4ck100 FIND v(dout0_4) AT=55.025n

.meas tran vdout0_5ck100 FIND v(dout0_5) AT=55.025n

.meas tran vdout0_6ck100 FIND v(dout0_6) AT=55.025n

.meas tran vdout0_7ck100 FIND v(dout0_7) AT=55.025n

.meas tran vdout0_8ck100 FIND v(dout0_8) AT=55.025n

.meas tran vdout0_9ck100 FIND v(dout0_9) AT=55.025n

.meas tran vdout0_10ck100 FIND v(dout0_10) AT=55.025n

.meas tran vdout0_11ck100 FIND v(dout0_11) AT=55.025n

.meas tran vdout0_12ck100 FIND v(dout0_12) AT=55.025n

.meas tran vdout0_13ck100 FIND v(dout0_13) AT=55.025n

.meas tran vdout0_14ck100 FIND v(dout0_14) AT=55.025n

.meas tran vdout0_15ck100 FIND v(dout0_15) AT=55.025n

.meas tran vdout0_16ck100 FIND v(dout0_16) AT=55.025n

.meas tran vdout0_17ck100 FIND v(dout0_17) AT=55.025n

.meas tran vdout0_18ck100 FIND v(dout0_18) AT=55.025n

.meas tran vdout0_19ck100 FIND v(dout0_19) AT=55.025n

.meas tran vdout0_20ck100 FIND v(dout0_20) AT=55.025n

.meas tran vdout0_21ck100 FIND v(dout0_21) AT=55.025n

.meas tran vdout0_22ck100 FIND v(dout0_22) AT=55.025n

.meas tran vdout0_23ck100 FIND v(dout0_23) AT=55.025n

.meas tran vdout0_24ck100 FIND v(dout0_24) AT=55.025n

.meas tran vdout0_25ck100 FIND v(dout0_25) AT=55.025n

.meas tran vdout0_26ck100 FIND v(dout0_26) AT=55.025n

.meas tran vdout0_27ck100 FIND v(dout0_27) AT=55.025n

.meas tran vdout0_28ck100 FIND v(dout0_28) AT=55.025n

.meas tran vdout0_29ck100 FIND v(dout0_29) AT=55.025n

.meas tran vdout0_30ck100 FIND v(dout0_30) AT=55.025n

.meas tran vdout0_31ck100 FIND v(dout0_31) AT=55.025n

.meas tran vdout0_32ck100 FIND v(dout0_32) AT=55.025n

.meas tran vdout0_33ck100 FIND v(dout0_33) AT=55.025n

.meas tran vdout0_34ck100 FIND v(dout0_34) AT=55.025n

.meas tran vdout0_35ck100 FIND v(dout0_35) AT=55.025n

.meas tran vdout0_36ck100 FIND v(dout0_36) AT=55.025n

.meas tran vdout0_37ck100 FIND v(dout0_37) AT=55.025n

.meas tran vdout0_38ck100 FIND v(dout0_38) AT=55.025n

.meas tran vdout0_39ck100 FIND v(dout0_39) AT=55.025n

.meas tran vdout0_40ck100 FIND v(dout0_40) AT=55.025n

.meas tran vdout0_41ck100 FIND v(dout0_41) AT=55.025n

.meas tran vdout0_42ck100 FIND v(dout0_42) AT=55.025n

.meas tran vdout0_43ck100 FIND v(dout0_43) AT=55.025n

.meas tran vdout0_44ck100 FIND v(dout0_44) AT=55.025n

.meas tran vdout0_45ck100 FIND v(dout0_45) AT=55.025n

.meas tran vdout0_46ck100 FIND v(dout0_46) AT=55.025n

.meas tran vdout0_47ck100 FIND v(dout0_47) AT=55.025n

.meas tran vdout0_48ck100 FIND v(dout0_48) AT=55.025n

.meas tran vdout0_49ck100 FIND v(dout0_49) AT=55.025n

.meas tran vdout0_50ck100 FIND v(dout0_50) AT=55.025n

.meas tran vdout0_51ck100 FIND v(dout0_51) AT=55.025n

.meas tran vdout0_52ck100 FIND v(dout0_52) AT=55.025n

.meas tran vdout0_53ck100 FIND v(dout0_53) AT=55.025n

.meas tran vdout0_54ck100 FIND v(dout0_54) AT=55.025n

.meas tran vdout0_55ck100 FIND v(dout0_55) AT=55.025n

.meas tran vdout0_56ck100 FIND v(dout0_56) AT=55.025n

.meas tran vdout0_57ck100 FIND v(dout0_57) AT=55.025n

.meas tran vdout0_58ck100 FIND v(dout0_58) AT=55.025n

.meas tran vdout0_59ck100 FIND v(dout0_59) AT=55.025n

.meas tran vdout0_60ck100 FIND v(dout0_60) AT=55.025n

.meas tran vdout0_61ck100 FIND v(dout0_61) AT=55.025n

.meas tran vdout0_62ck100 FIND v(dout0_62) AT=55.025n

.meas tran vdout0_63ck100 FIND v(dout0_63) AT=55.025n

.meas tran vdout0_64ck100 FIND v(dout0_64) AT=55.025n

.meas tran vdout0_65ck100 FIND v(dout0_65) AT=55.025n

.meas tran vdout0_66ck100 FIND v(dout0_66) AT=55.025n

.meas tran vdout0_67ck100 FIND v(dout0_67) AT=55.025n

.meas tran vdout0_68ck100 FIND v(dout0_68) AT=55.025n

.meas tran vdout0_69ck100 FIND v(dout0_69) AT=55.025n

.meas tran vdout0_70ck100 FIND v(dout0_70) AT=55.025n

.meas tran vdout0_71ck100 FIND v(dout0_71) AT=55.025n

.meas tran vdout0_72ck100 FIND v(dout0_72) AT=55.025n

.meas tran vdout0_73ck100 FIND v(dout0_73) AT=55.025n

.meas tran vdout0_74ck100 FIND v(dout0_74) AT=55.025n

.meas tran vdout0_75ck100 FIND v(dout0_75) AT=55.025n

.meas tran vdout0_76ck100 FIND v(dout0_76) AT=55.025n

.meas tran vdout0_77ck100 FIND v(dout0_77) AT=55.025n

.meas tran vdout0_78ck100 FIND v(dout0_78) AT=55.025n

.meas tran vdout0_79ck100 FIND v(dout0_79) AT=55.025n

.meas tran vdout0_80ck100 FIND v(dout0_80) AT=55.025n

.meas tran vdout0_81ck100 FIND v(dout0_81) AT=55.025n

.meas tran vdout0_82ck100 FIND v(dout0_82) AT=55.025n

.meas tran vdout0_83ck100 FIND v(dout0_83) AT=55.025n

.meas tran vdout0_84ck100 FIND v(dout0_84) AT=55.025n

.meas tran vdout0_85ck100 FIND v(dout0_85) AT=55.025n

.meas tran vdout0_86ck100 FIND v(dout0_86) AT=55.025n

.meas tran vdout0_87ck100 FIND v(dout0_87) AT=55.025n

.meas tran vdout0_88ck100 FIND v(dout0_88) AT=55.025n

.meas tran vdout0_89ck100 FIND v(dout0_89) AT=55.025n

.meas tran vdout0_90ck100 FIND v(dout0_90) AT=55.025n

.meas tran vdout0_91ck100 FIND v(dout0_91) AT=55.025n

.meas tran vdout0_92ck100 FIND v(dout0_92) AT=55.025n

.meas tran vdout0_93ck100 FIND v(dout0_93) AT=55.025n

.meas tran vdout0_94ck100 FIND v(dout0_94) AT=55.025n

.meas tran vdout0_95ck100 FIND v(dout0_95) AT=55.025n

.meas tran vdout0_96ck100 FIND v(dout0_96) AT=55.025n

.meas tran vdout0_97ck100 FIND v(dout0_97) AT=55.025n

.meas tran vdout0_98ck100 FIND v(dout0_98) AT=55.025n

.meas tran vdout0_99ck100 FIND v(dout0_99) AT=55.025n

.meas tran vdout0_100ck100 FIND v(dout0_100) AT=55.025n

.meas tran vdout0_101ck100 FIND v(dout0_101) AT=55.025n

.meas tran vdout0_102ck100 FIND v(dout0_102) AT=55.025n

.meas tran vdout0_103ck100 FIND v(dout0_103) AT=55.025n

.meas tran vdout0_104ck100 FIND v(dout0_104) AT=55.025n

.meas tran vdout0_105ck100 FIND v(dout0_105) AT=55.025n

.meas tran vdout0_106ck100 FIND v(dout0_106) AT=55.025n

.meas tran vdout0_107ck100 FIND v(dout0_107) AT=55.025n

.meas tran vdout0_108ck100 FIND v(dout0_108) AT=55.025n

.meas tran vdout0_109ck100 FIND v(dout0_109) AT=55.025n

.meas tran vdout0_110ck100 FIND v(dout0_110) AT=55.025n

.meas tran vdout0_111ck100 FIND v(dout0_111) AT=55.025n

.meas tran vdout0_112ck100 FIND v(dout0_112) AT=55.025n

.meas tran vdout0_113ck100 FIND v(dout0_113) AT=55.025n

.meas tran vdout0_114ck100 FIND v(dout0_114) AT=55.025n

.meas tran vdout0_115ck100 FIND v(dout0_115) AT=55.025n

.meas tran vdout0_116ck100 FIND v(dout0_116) AT=55.025n

.meas tran vdout0_117ck100 FIND v(dout0_117) AT=55.025n

.meas tran vdout0_118ck100 FIND v(dout0_118) AT=55.025n

.meas tran vdout0_119ck100 FIND v(dout0_119) AT=55.025n

.meas tran vdout0_120ck100 FIND v(dout0_120) AT=55.025n

.meas tran vdout0_121ck100 FIND v(dout0_121) AT=55.025n

.meas tran vdout0_122ck100 FIND v(dout0_122) AT=55.025n

.meas tran vdout0_123ck100 FIND v(dout0_123) AT=55.025n

.meas tran vdout0_124ck100 FIND v(dout0_124) AT=55.025n

.meas tran vdout0_125ck100 FIND v(dout0_125) AT=55.025n

.meas tran vdout0_126ck100 FIND v(dout0_126) AT=55.025n

.meas tran vdout0_127ck100 FIND v(dout0_127) AT=55.025n

.meas tran vdout0_128ck100 FIND v(dout0_128) AT=55.025n

.meas tran vdout0_129ck100 FIND v(dout0_129) AT=55.025n

.meas tran vdout0_130ck100 FIND v(dout0_130) AT=55.025n

.meas tran vdout0_131ck100 FIND v(dout0_131) AT=55.025n

.meas tran vdout0_132ck100 FIND v(dout0_132) AT=55.025n

.meas tran vdout0_133ck100 FIND v(dout0_133) AT=55.025n

.meas tran vdout0_134ck100 FIND v(dout0_134) AT=55.025n

.meas tran vdout0_135ck100 FIND v(dout0_135) AT=55.025n

.meas tran vdout0_136ck100 FIND v(dout0_136) AT=55.025n

.meas tran vdout0_137ck100 FIND v(dout0_137) AT=55.025n

.meas tran vdout0_138ck100 FIND v(dout0_138) AT=55.025n

.meas tran vdout0_139ck100 FIND v(dout0_139) AT=55.025n

.meas tran vdout0_140ck100 FIND v(dout0_140) AT=55.025n

.meas tran vdout0_141ck100 FIND v(dout0_141) AT=55.025n

.meas tran vdout0_142ck100 FIND v(dout0_142) AT=55.025n

.meas tran vdout0_143ck100 FIND v(dout0_143) AT=55.025n

.meas tran vdout0_144ck100 FIND v(dout0_144) AT=55.025n

.meas tran vdout0_145ck100 FIND v(dout0_145) AT=55.025n

.meas tran vdout0_146ck100 FIND v(dout0_146) AT=55.025n

.meas tran vdout0_147ck100 FIND v(dout0_147) AT=55.025n

.meas tran vdout0_148ck100 FIND v(dout0_148) AT=55.025n

.meas tran vdout0_149ck100 FIND v(dout0_149) AT=55.025n

.meas tran vdout0_0ck120 FIND v(dout0_0) AT=65.025n

.meas tran vdout0_1ck120 FIND v(dout0_1) AT=65.025n

.meas tran vdout0_2ck120 FIND v(dout0_2) AT=65.025n

.meas tran vdout0_3ck120 FIND v(dout0_3) AT=65.025n

.meas tran vdout0_4ck120 FIND v(dout0_4) AT=65.025n

.meas tran vdout0_5ck120 FIND v(dout0_5) AT=65.025n

.meas tran vdout0_6ck120 FIND v(dout0_6) AT=65.025n

.meas tran vdout0_7ck120 FIND v(dout0_7) AT=65.025n

.meas tran vdout0_8ck120 FIND v(dout0_8) AT=65.025n

.meas tran vdout0_9ck120 FIND v(dout0_9) AT=65.025n

.meas tran vdout0_10ck120 FIND v(dout0_10) AT=65.025n

.meas tran vdout0_11ck120 FIND v(dout0_11) AT=65.025n

.meas tran vdout0_12ck120 FIND v(dout0_12) AT=65.025n

.meas tran vdout0_13ck120 FIND v(dout0_13) AT=65.025n

.meas tran vdout0_14ck120 FIND v(dout0_14) AT=65.025n

.meas tran vdout0_15ck120 FIND v(dout0_15) AT=65.025n

.meas tran vdout0_16ck120 FIND v(dout0_16) AT=65.025n

.meas tran vdout0_17ck120 FIND v(dout0_17) AT=65.025n

.meas tran vdout0_18ck120 FIND v(dout0_18) AT=65.025n

.meas tran vdout0_19ck120 FIND v(dout0_19) AT=65.025n

.meas tran vdout0_20ck120 FIND v(dout0_20) AT=65.025n

.meas tran vdout0_21ck120 FIND v(dout0_21) AT=65.025n

.meas tran vdout0_22ck120 FIND v(dout0_22) AT=65.025n

.meas tran vdout0_23ck120 FIND v(dout0_23) AT=65.025n

.meas tran vdout0_24ck120 FIND v(dout0_24) AT=65.025n

.meas tran vdout0_25ck120 FIND v(dout0_25) AT=65.025n

.meas tran vdout0_26ck120 FIND v(dout0_26) AT=65.025n

.meas tran vdout0_27ck120 FIND v(dout0_27) AT=65.025n

.meas tran vdout0_28ck120 FIND v(dout0_28) AT=65.025n

.meas tran vdout0_29ck120 FIND v(dout0_29) AT=65.025n

.meas tran vdout0_30ck120 FIND v(dout0_30) AT=65.025n

.meas tran vdout0_31ck120 FIND v(dout0_31) AT=65.025n

.meas tran vdout0_32ck120 FIND v(dout0_32) AT=65.025n

.meas tran vdout0_33ck120 FIND v(dout0_33) AT=65.025n

.meas tran vdout0_34ck120 FIND v(dout0_34) AT=65.025n

.meas tran vdout0_35ck120 FIND v(dout0_35) AT=65.025n

.meas tran vdout0_36ck120 FIND v(dout0_36) AT=65.025n

.meas tran vdout0_37ck120 FIND v(dout0_37) AT=65.025n

.meas tran vdout0_38ck120 FIND v(dout0_38) AT=65.025n

.meas tran vdout0_39ck120 FIND v(dout0_39) AT=65.025n

.meas tran vdout0_40ck120 FIND v(dout0_40) AT=65.025n

.meas tran vdout0_41ck120 FIND v(dout0_41) AT=65.025n

.meas tran vdout0_42ck120 FIND v(dout0_42) AT=65.025n

.meas tran vdout0_43ck120 FIND v(dout0_43) AT=65.025n

.meas tran vdout0_44ck120 FIND v(dout0_44) AT=65.025n

.meas tran vdout0_45ck120 FIND v(dout0_45) AT=65.025n

.meas tran vdout0_46ck120 FIND v(dout0_46) AT=65.025n

.meas tran vdout0_47ck120 FIND v(dout0_47) AT=65.025n

.meas tran vdout0_48ck120 FIND v(dout0_48) AT=65.025n

.meas tran vdout0_49ck120 FIND v(dout0_49) AT=65.025n

.meas tran vdout0_50ck120 FIND v(dout0_50) AT=65.025n

.meas tran vdout0_51ck120 FIND v(dout0_51) AT=65.025n

.meas tran vdout0_52ck120 FIND v(dout0_52) AT=65.025n

.meas tran vdout0_53ck120 FIND v(dout0_53) AT=65.025n

.meas tran vdout0_54ck120 FIND v(dout0_54) AT=65.025n

.meas tran vdout0_55ck120 FIND v(dout0_55) AT=65.025n

.meas tran vdout0_56ck120 FIND v(dout0_56) AT=65.025n

.meas tran vdout0_57ck120 FIND v(dout0_57) AT=65.025n

.meas tran vdout0_58ck120 FIND v(dout0_58) AT=65.025n

.meas tran vdout0_59ck120 FIND v(dout0_59) AT=65.025n

.meas tran vdout0_60ck120 FIND v(dout0_60) AT=65.025n

.meas tran vdout0_61ck120 FIND v(dout0_61) AT=65.025n

.meas tran vdout0_62ck120 FIND v(dout0_62) AT=65.025n

.meas tran vdout0_63ck120 FIND v(dout0_63) AT=65.025n

.meas tran vdout0_64ck120 FIND v(dout0_64) AT=65.025n

.meas tran vdout0_65ck120 FIND v(dout0_65) AT=65.025n

.meas tran vdout0_66ck120 FIND v(dout0_66) AT=65.025n

.meas tran vdout0_67ck120 FIND v(dout0_67) AT=65.025n

.meas tran vdout0_68ck120 FIND v(dout0_68) AT=65.025n

.meas tran vdout0_69ck120 FIND v(dout0_69) AT=65.025n

.meas tran vdout0_70ck120 FIND v(dout0_70) AT=65.025n

.meas tran vdout0_71ck120 FIND v(dout0_71) AT=65.025n

.meas tran vdout0_72ck120 FIND v(dout0_72) AT=65.025n

.meas tran vdout0_73ck120 FIND v(dout0_73) AT=65.025n

.meas tran vdout0_74ck120 FIND v(dout0_74) AT=65.025n

.meas tran vdout0_75ck120 FIND v(dout0_75) AT=65.025n

.meas tran vdout0_76ck120 FIND v(dout0_76) AT=65.025n

.meas tran vdout0_77ck120 FIND v(dout0_77) AT=65.025n

.meas tran vdout0_78ck120 FIND v(dout0_78) AT=65.025n

.meas tran vdout0_79ck120 FIND v(dout0_79) AT=65.025n

.meas tran vdout0_80ck120 FIND v(dout0_80) AT=65.025n

.meas tran vdout0_81ck120 FIND v(dout0_81) AT=65.025n

.meas tran vdout0_82ck120 FIND v(dout0_82) AT=65.025n

.meas tran vdout0_83ck120 FIND v(dout0_83) AT=65.025n

.meas tran vdout0_84ck120 FIND v(dout0_84) AT=65.025n

.meas tran vdout0_85ck120 FIND v(dout0_85) AT=65.025n

.meas tran vdout0_86ck120 FIND v(dout0_86) AT=65.025n

.meas tran vdout0_87ck120 FIND v(dout0_87) AT=65.025n

.meas tran vdout0_88ck120 FIND v(dout0_88) AT=65.025n

.meas tran vdout0_89ck120 FIND v(dout0_89) AT=65.025n

.meas tran vdout0_90ck120 FIND v(dout0_90) AT=65.025n

.meas tran vdout0_91ck120 FIND v(dout0_91) AT=65.025n

.meas tran vdout0_92ck120 FIND v(dout0_92) AT=65.025n

.meas tran vdout0_93ck120 FIND v(dout0_93) AT=65.025n

.meas tran vdout0_94ck120 FIND v(dout0_94) AT=65.025n

.meas tran vdout0_95ck120 FIND v(dout0_95) AT=65.025n

.meas tran vdout0_96ck120 FIND v(dout0_96) AT=65.025n

.meas tran vdout0_97ck120 FIND v(dout0_97) AT=65.025n

.meas tran vdout0_98ck120 FIND v(dout0_98) AT=65.025n

.meas tran vdout0_99ck120 FIND v(dout0_99) AT=65.025n

.meas tran vdout0_100ck120 FIND v(dout0_100) AT=65.025n

.meas tran vdout0_101ck120 FIND v(dout0_101) AT=65.025n

.meas tran vdout0_102ck120 FIND v(dout0_102) AT=65.025n

.meas tran vdout0_103ck120 FIND v(dout0_103) AT=65.025n

.meas tran vdout0_104ck120 FIND v(dout0_104) AT=65.025n

.meas tran vdout0_105ck120 FIND v(dout0_105) AT=65.025n

.meas tran vdout0_106ck120 FIND v(dout0_106) AT=65.025n

.meas tran vdout0_107ck120 FIND v(dout0_107) AT=65.025n

.meas tran vdout0_108ck120 FIND v(dout0_108) AT=65.025n

.meas tran vdout0_109ck120 FIND v(dout0_109) AT=65.025n

.meas tran vdout0_110ck120 FIND v(dout0_110) AT=65.025n

.meas tran vdout0_111ck120 FIND v(dout0_111) AT=65.025n

.meas tran vdout0_112ck120 FIND v(dout0_112) AT=65.025n

.meas tran vdout0_113ck120 FIND v(dout0_113) AT=65.025n

.meas tran vdout0_114ck120 FIND v(dout0_114) AT=65.025n

.meas tran vdout0_115ck120 FIND v(dout0_115) AT=65.025n

.meas tran vdout0_116ck120 FIND v(dout0_116) AT=65.025n

.meas tran vdout0_117ck120 FIND v(dout0_117) AT=65.025n

.meas tran vdout0_118ck120 FIND v(dout0_118) AT=65.025n

.meas tran vdout0_119ck120 FIND v(dout0_119) AT=65.025n

.meas tran vdout0_120ck120 FIND v(dout0_120) AT=65.025n

.meas tran vdout0_121ck120 FIND v(dout0_121) AT=65.025n

.meas tran vdout0_122ck120 FIND v(dout0_122) AT=65.025n

.meas tran vdout0_123ck120 FIND v(dout0_123) AT=65.025n

.meas tran vdout0_124ck120 FIND v(dout0_124) AT=65.025n

.meas tran vdout0_125ck120 FIND v(dout0_125) AT=65.025n

.meas tran vdout0_126ck120 FIND v(dout0_126) AT=65.025n

.meas tran vdout0_127ck120 FIND v(dout0_127) AT=65.025n

.meas tran vdout0_128ck120 FIND v(dout0_128) AT=65.025n

.meas tran vdout0_129ck120 FIND v(dout0_129) AT=65.025n

.meas tran vdout0_130ck120 FIND v(dout0_130) AT=65.025n

.meas tran vdout0_131ck120 FIND v(dout0_131) AT=65.025n

.meas tran vdout0_132ck120 FIND v(dout0_132) AT=65.025n

.meas tran vdout0_133ck120 FIND v(dout0_133) AT=65.025n

.meas tran vdout0_134ck120 FIND v(dout0_134) AT=65.025n

.meas tran vdout0_135ck120 FIND v(dout0_135) AT=65.025n

.meas tran vdout0_136ck120 FIND v(dout0_136) AT=65.025n

.meas tran vdout0_137ck120 FIND v(dout0_137) AT=65.025n

.meas tran vdout0_138ck120 FIND v(dout0_138) AT=65.025n

.meas tran vdout0_139ck120 FIND v(dout0_139) AT=65.025n

.meas tran vdout0_140ck120 FIND v(dout0_140) AT=65.025n

.meas tran vdout0_141ck120 FIND v(dout0_141) AT=65.025n

.meas tran vdout0_142ck120 FIND v(dout0_142) AT=65.025n

.meas tran vdout0_143ck120 FIND v(dout0_143) AT=65.025n

.meas tran vdout0_144ck120 FIND v(dout0_144) AT=65.025n

.meas tran vdout0_145ck120 FIND v(dout0_145) AT=65.025n

.meas tran vdout0_146ck120 FIND v(dout0_146) AT=65.025n

.meas tran vdout0_147ck120 FIND v(dout0_147) AT=65.025n

.meas tran vdout0_148ck120 FIND v(dout0_148) AT=65.025n

.meas tran vdout0_149ck120 FIND v(dout0_149) AT=65.025n

.meas tran vdout0_0ck130 FIND v(dout0_0) AT=70.025n

.meas tran vdout0_1ck130 FIND v(dout0_1) AT=70.025n

.meas tran vdout0_2ck130 FIND v(dout0_2) AT=70.025n

.meas tran vdout0_3ck130 FIND v(dout0_3) AT=70.025n

.meas tran vdout0_4ck130 FIND v(dout0_4) AT=70.025n

.meas tran vdout0_5ck130 FIND v(dout0_5) AT=70.025n

.meas tran vdout0_6ck130 FIND v(dout0_6) AT=70.025n

.meas tran vdout0_7ck130 FIND v(dout0_7) AT=70.025n

.meas tran vdout0_8ck130 FIND v(dout0_8) AT=70.025n

.meas tran vdout0_9ck130 FIND v(dout0_9) AT=70.025n

.meas tran vdout0_10ck130 FIND v(dout0_10) AT=70.025n

.meas tran vdout0_11ck130 FIND v(dout0_11) AT=70.025n

.meas tran vdout0_12ck130 FIND v(dout0_12) AT=70.025n

.meas tran vdout0_13ck130 FIND v(dout0_13) AT=70.025n

.meas tran vdout0_14ck130 FIND v(dout0_14) AT=70.025n

.meas tran vdout0_15ck130 FIND v(dout0_15) AT=70.025n

.meas tran vdout0_16ck130 FIND v(dout0_16) AT=70.025n

.meas tran vdout0_17ck130 FIND v(dout0_17) AT=70.025n

.meas tran vdout0_18ck130 FIND v(dout0_18) AT=70.025n

.meas tran vdout0_19ck130 FIND v(dout0_19) AT=70.025n

.meas tran vdout0_20ck130 FIND v(dout0_20) AT=70.025n

.meas tran vdout0_21ck130 FIND v(dout0_21) AT=70.025n

.meas tran vdout0_22ck130 FIND v(dout0_22) AT=70.025n

.meas tran vdout0_23ck130 FIND v(dout0_23) AT=70.025n

.meas tran vdout0_24ck130 FIND v(dout0_24) AT=70.025n

.meas tran vdout0_25ck130 FIND v(dout0_25) AT=70.025n

.meas tran vdout0_26ck130 FIND v(dout0_26) AT=70.025n

.meas tran vdout0_27ck130 FIND v(dout0_27) AT=70.025n

.meas tran vdout0_28ck130 FIND v(dout0_28) AT=70.025n

.meas tran vdout0_29ck130 FIND v(dout0_29) AT=70.025n

.meas tran vdout0_30ck130 FIND v(dout0_30) AT=70.025n

.meas tran vdout0_31ck130 FIND v(dout0_31) AT=70.025n

.meas tran vdout0_32ck130 FIND v(dout0_32) AT=70.025n

.meas tran vdout0_33ck130 FIND v(dout0_33) AT=70.025n

.meas tran vdout0_34ck130 FIND v(dout0_34) AT=70.025n

.meas tran vdout0_35ck130 FIND v(dout0_35) AT=70.025n

.meas tran vdout0_36ck130 FIND v(dout0_36) AT=70.025n

.meas tran vdout0_37ck130 FIND v(dout0_37) AT=70.025n

.meas tran vdout0_38ck130 FIND v(dout0_38) AT=70.025n

.meas tran vdout0_39ck130 FIND v(dout0_39) AT=70.025n

.meas tran vdout0_40ck130 FIND v(dout0_40) AT=70.025n

.meas tran vdout0_41ck130 FIND v(dout0_41) AT=70.025n

.meas tran vdout0_42ck130 FIND v(dout0_42) AT=70.025n

.meas tran vdout0_43ck130 FIND v(dout0_43) AT=70.025n

.meas tran vdout0_44ck130 FIND v(dout0_44) AT=70.025n

.meas tran vdout0_45ck130 FIND v(dout0_45) AT=70.025n

.meas tran vdout0_46ck130 FIND v(dout0_46) AT=70.025n

.meas tran vdout0_47ck130 FIND v(dout0_47) AT=70.025n

.meas tran vdout0_48ck130 FIND v(dout0_48) AT=70.025n

.meas tran vdout0_49ck130 FIND v(dout0_49) AT=70.025n

.meas tran vdout0_50ck130 FIND v(dout0_50) AT=70.025n

.meas tran vdout0_51ck130 FIND v(dout0_51) AT=70.025n

.meas tran vdout0_52ck130 FIND v(dout0_52) AT=70.025n

.meas tran vdout0_53ck130 FIND v(dout0_53) AT=70.025n

.meas tran vdout0_54ck130 FIND v(dout0_54) AT=70.025n

.meas tran vdout0_55ck130 FIND v(dout0_55) AT=70.025n

.meas tran vdout0_56ck130 FIND v(dout0_56) AT=70.025n

.meas tran vdout0_57ck130 FIND v(dout0_57) AT=70.025n

.meas tran vdout0_58ck130 FIND v(dout0_58) AT=70.025n

.meas tran vdout0_59ck130 FIND v(dout0_59) AT=70.025n

.meas tran vdout0_60ck130 FIND v(dout0_60) AT=70.025n

.meas tran vdout0_61ck130 FIND v(dout0_61) AT=70.025n

.meas tran vdout0_62ck130 FIND v(dout0_62) AT=70.025n

.meas tran vdout0_63ck130 FIND v(dout0_63) AT=70.025n

.meas tran vdout0_64ck130 FIND v(dout0_64) AT=70.025n

.meas tran vdout0_65ck130 FIND v(dout0_65) AT=70.025n

.meas tran vdout0_66ck130 FIND v(dout0_66) AT=70.025n

.meas tran vdout0_67ck130 FIND v(dout0_67) AT=70.025n

.meas tran vdout0_68ck130 FIND v(dout0_68) AT=70.025n

.meas tran vdout0_69ck130 FIND v(dout0_69) AT=70.025n

.meas tran vdout0_70ck130 FIND v(dout0_70) AT=70.025n

.meas tran vdout0_71ck130 FIND v(dout0_71) AT=70.025n

.meas tran vdout0_72ck130 FIND v(dout0_72) AT=70.025n

.meas tran vdout0_73ck130 FIND v(dout0_73) AT=70.025n

.meas tran vdout0_74ck130 FIND v(dout0_74) AT=70.025n

.meas tran vdout0_75ck130 FIND v(dout0_75) AT=70.025n

.meas tran vdout0_76ck130 FIND v(dout0_76) AT=70.025n

.meas tran vdout0_77ck130 FIND v(dout0_77) AT=70.025n

.meas tran vdout0_78ck130 FIND v(dout0_78) AT=70.025n

.meas tran vdout0_79ck130 FIND v(dout0_79) AT=70.025n

.meas tran vdout0_80ck130 FIND v(dout0_80) AT=70.025n

.meas tran vdout0_81ck130 FIND v(dout0_81) AT=70.025n

.meas tran vdout0_82ck130 FIND v(dout0_82) AT=70.025n

.meas tran vdout0_83ck130 FIND v(dout0_83) AT=70.025n

.meas tran vdout0_84ck130 FIND v(dout0_84) AT=70.025n

.meas tran vdout0_85ck130 FIND v(dout0_85) AT=70.025n

.meas tran vdout0_86ck130 FIND v(dout0_86) AT=70.025n

.meas tran vdout0_87ck130 FIND v(dout0_87) AT=70.025n

.meas tran vdout0_88ck130 FIND v(dout0_88) AT=70.025n

.meas tran vdout0_89ck130 FIND v(dout0_89) AT=70.025n

.meas tran vdout0_90ck130 FIND v(dout0_90) AT=70.025n

.meas tran vdout0_91ck130 FIND v(dout0_91) AT=70.025n

.meas tran vdout0_92ck130 FIND v(dout0_92) AT=70.025n

.meas tran vdout0_93ck130 FIND v(dout0_93) AT=70.025n

.meas tran vdout0_94ck130 FIND v(dout0_94) AT=70.025n

.meas tran vdout0_95ck130 FIND v(dout0_95) AT=70.025n

.meas tran vdout0_96ck130 FIND v(dout0_96) AT=70.025n

.meas tran vdout0_97ck130 FIND v(dout0_97) AT=70.025n

.meas tran vdout0_98ck130 FIND v(dout0_98) AT=70.025n

.meas tran vdout0_99ck130 FIND v(dout0_99) AT=70.025n

.meas tran vdout0_100ck130 FIND v(dout0_100) AT=70.025n

.meas tran vdout0_101ck130 FIND v(dout0_101) AT=70.025n

.meas tran vdout0_102ck130 FIND v(dout0_102) AT=70.025n

.meas tran vdout0_103ck130 FIND v(dout0_103) AT=70.025n

.meas tran vdout0_104ck130 FIND v(dout0_104) AT=70.025n

.meas tran vdout0_105ck130 FIND v(dout0_105) AT=70.025n

.meas tran vdout0_106ck130 FIND v(dout0_106) AT=70.025n

.meas tran vdout0_107ck130 FIND v(dout0_107) AT=70.025n

.meas tran vdout0_108ck130 FIND v(dout0_108) AT=70.025n

.meas tran vdout0_109ck130 FIND v(dout0_109) AT=70.025n

.meas tran vdout0_110ck130 FIND v(dout0_110) AT=70.025n

.meas tran vdout0_111ck130 FIND v(dout0_111) AT=70.025n

.meas tran vdout0_112ck130 FIND v(dout0_112) AT=70.025n

.meas tran vdout0_113ck130 FIND v(dout0_113) AT=70.025n

.meas tran vdout0_114ck130 FIND v(dout0_114) AT=70.025n

.meas tran vdout0_115ck130 FIND v(dout0_115) AT=70.025n

.meas tran vdout0_116ck130 FIND v(dout0_116) AT=70.025n

.meas tran vdout0_117ck130 FIND v(dout0_117) AT=70.025n

.meas tran vdout0_118ck130 FIND v(dout0_118) AT=70.025n

.meas tran vdout0_119ck130 FIND v(dout0_119) AT=70.025n

.meas tran vdout0_120ck130 FIND v(dout0_120) AT=70.025n

.meas tran vdout0_121ck130 FIND v(dout0_121) AT=70.025n

.meas tran vdout0_122ck130 FIND v(dout0_122) AT=70.025n

.meas tran vdout0_123ck130 FIND v(dout0_123) AT=70.025n

.meas tran vdout0_124ck130 FIND v(dout0_124) AT=70.025n

.meas tran vdout0_125ck130 FIND v(dout0_125) AT=70.025n

.meas tran vdout0_126ck130 FIND v(dout0_126) AT=70.025n

.meas tran vdout0_127ck130 FIND v(dout0_127) AT=70.025n

.meas tran vdout0_128ck130 FIND v(dout0_128) AT=70.025n

.meas tran vdout0_129ck130 FIND v(dout0_129) AT=70.025n

.meas tran vdout0_130ck130 FIND v(dout0_130) AT=70.025n

.meas tran vdout0_131ck130 FIND v(dout0_131) AT=70.025n

.meas tran vdout0_132ck130 FIND v(dout0_132) AT=70.025n

.meas tran vdout0_133ck130 FIND v(dout0_133) AT=70.025n

.meas tran vdout0_134ck130 FIND v(dout0_134) AT=70.025n

.meas tran vdout0_135ck130 FIND v(dout0_135) AT=70.025n

.meas tran vdout0_136ck130 FIND v(dout0_136) AT=70.025n

.meas tran vdout0_137ck130 FIND v(dout0_137) AT=70.025n

.meas tran vdout0_138ck130 FIND v(dout0_138) AT=70.025n

.meas tran vdout0_139ck130 FIND v(dout0_139) AT=70.025n

.meas tran vdout0_140ck130 FIND v(dout0_140) AT=70.025n

.meas tran vdout0_141ck130 FIND v(dout0_141) AT=70.025n

.meas tran vdout0_142ck130 FIND v(dout0_142) AT=70.025n

.meas tran vdout0_143ck130 FIND v(dout0_143) AT=70.025n

.meas tran vdout0_144ck130 FIND v(dout0_144) AT=70.025n

.meas tran vdout0_145ck130 FIND v(dout0_145) AT=70.025n

.meas tran vdout0_146ck130 FIND v(dout0_146) AT=70.025n

.meas tran vdout0_147ck130 FIND v(dout0_147) AT=70.025n

.meas tran vdout0_148ck130 FIND v(dout0_148) AT=70.025n

.meas tran vdout0_149ck130 FIND v(dout0_149) AT=70.025n

.meas tran vdout0_0ck140 FIND v(dout0_0) AT=75.025n

.meas tran vdout0_1ck140 FIND v(dout0_1) AT=75.025n

.meas tran vdout0_2ck140 FIND v(dout0_2) AT=75.025n

.meas tran vdout0_3ck140 FIND v(dout0_3) AT=75.025n

.meas tran vdout0_4ck140 FIND v(dout0_4) AT=75.025n

.meas tran vdout0_5ck140 FIND v(dout0_5) AT=75.025n

.meas tran vdout0_6ck140 FIND v(dout0_6) AT=75.025n

.meas tran vdout0_7ck140 FIND v(dout0_7) AT=75.025n

.meas tran vdout0_8ck140 FIND v(dout0_8) AT=75.025n

.meas tran vdout0_9ck140 FIND v(dout0_9) AT=75.025n

.meas tran vdout0_10ck140 FIND v(dout0_10) AT=75.025n

.meas tran vdout0_11ck140 FIND v(dout0_11) AT=75.025n

.meas tran vdout0_12ck140 FIND v(dout0_12) AT=75.025n

.meas tran vdout0_13ck140 FIND v(dout0_13) AT=75.025n

.meas tran vdout0_14ck140 FIND v(dout0_14) AT=75.025n

.meas tran vdout0_15ck140 FIND v(dout0_15) AT=75.025n

.meas tran vdout0_16ck140 FIND v(dout0_16) AT=75.025n

.meas tran vdout0_17ck140 FIND v(dout0_17) AT=75.025n

.meas tran vdout0_18ck140 FIND v(dout0_18) AT=75.025n

.meas tran vdout0_19ck140 FIND v(dout0_19) AT=75.025n

.meas tran vdout0_20ck140 FIND v(dout0_20) AT=75.025n

.meas tran vdout0_21ck140 FIND v(dout0_21) AT=75.025n

.meas tran vdout0_22ck140 FIND v(dout0_22) AT=75.025n

.meas tran vdout0_23ck140 FIND v(dout0_23) AT=75.025n

.meas tran vdout0_24ck140 FIND v(dout0_24) AT=75.025n

.meas tran vdout0_25ck140 FIND v(dout0_25) AT=75.025n

.meas tran vdout0_26ck140 FIND v(dout0_26) AT=75.025n

.meas tran vdout0_27ck140 FIND v(dout0_27) AT=75.025n

.meas tran vdout0_28ck140 FIND v(dout0_28) AT=75.025n

.meas tran vdout0_29ck140 FIND v(dout0_29) AT=75.025n

.meas tran vdout0_30ck140 FIND v(dout0_30) AT=75.025n

.meas tran vdout0_31ck140 FIND v(dout0_31) AT=75.025n

.meas tran vdout0_32ck140 FIND v(dout0_32) AT=75.025n

.meas tran vdout0_33ck140 FIND v(dout0_33) AT=75.025n

.meas tran vdout0_34ck140 FIND v(dout0_34) AT=75.025n

.meas tran vdout0_35ck140 FIND v(dout0_35) AT=75.025n

.meas tran vdout0_36ck140 FIND v(dout0_36) AT=75.025n

.meas tran vdout0_37ck140 FIND v(dout0_37) AT=75.025n

.meas tran vdout0_38ck140 FIND v(dout0_38) AT=75.025n

.meas tran vdout0_39ck140 FIND v(dout0_39) AT=75.025n

.meas tran vdout0_40ck140 FIND v(dout0_40) AT=75.025n

.meas tran vdout0_41ck140 FIND v(dout0_41) AT=75.025n

.meas tran vdout0_42ck140 FIND v(dout0_42) AT=75.025n

.meas tran vdout0_43ck140 FIND v(dout0_43) AT=75.025n

.meas tran vdout0_44ck140 FIND v(dout0_44) AT=75.025n

.meas tran vdout0_45ck140 FIND v(dout0_45) AT=75.025n

.meas tran vdout0_46ck140 FIND v(dout0_46) AT=75.025n

.meas tran vdout0_47ck140 FIND v(dout0_47) AT=75.025n

.meas tran vdout0_48ck140 FIND v(dout0_48) AT=75.025n

.meas tran vdout0_49ck140 FIND v(dout0_49) AT=75.025n

.meas tran vdout0_50ck140 FIND v(dout0_50) AT=75.025n

.meas tran vdout0_51ck140 FIND v(dout0_51) AT=75.025n

.meas tran vdout0_52ck140 FIND v(dout0_52) AT=75.025n

.meas tran vdout0_53ck140 FIND v(dout0_53) AT=75.025n

.meas tran vdout0_54ck140 FIND v(dout0_54) AT=75.025n

.meas tran vdout0_55ck140 FIND v(dout0_55) AT=75.025n

.meas tran vdout0_56ck140 FIND v(dout0_56) AT=75.025n

.meas tran vdout0_57ck140 FIND v(dout0_57) AT=75.025n

.meas tran vdout0_58ck140 FIND v(dout0_58) AT=75.025n

.meas tran vdout0_59ck140 FIND v(dout0_59) AT=75.025n

.meas tran vdout0_60ck140 FIND v(dout0_60) AT=75.025n

.meas tran vdout0_61ck140 FIND v(dout0_61) AT=75.025n

.meas tran vdout0_62ck140 FIND v(dout0_62) AT=75.025n

.meas tran vdout0_63ck140 FIND v(dout0_63) AT=75.025n

.meas tran vdout0_64ck140 FIND v(dout0_64) AT=75.025n

.meas tran vdout0_65ck140 FIND v(dout0_65) AT=75.025n

.meas tran vdout0_66ck140 FIND v(dout0_66) AT=75.025n

.meas tran vdout0_67ck140 FIND v(dout0_67) AT=75.025n

.meas tran vdout0_68ck140 FIND v(dout0_68) AT=75.025n

.meas tran vdout0_69ck140 FIND v(dout0_69) AT=75.025n

.meas tran vdout0_70ck140 FIND v(dout0_70) AT=75.025n

.meas tran vdout0_71ck140 FIND v(dout0_71) AT=75.025n

.meas tran vdout0_72ck140 FIND v(dout0_72) AT=75.025n

.meas tran vdout0_73ck140 FIND v(dout0_73) AT=75.025n

.meas tran vdout0_74ck140 FIND v(dout0_74) AT=75.025n

.meas tran vdout0_75ck140 FIND v(dout0_75) AT=75.025n

.meas tran vdout0_76ck140 FIND v(dout0_76) AT=75.025n

.meas tran vdout0_77ck140 FIND v(dout0_77) AT=75.025n

.meas tran vdout0_78ck140 FIND v(dout0_78) AT=75.025n

.meas tran vdout0_79ck140 FIND v(dout0_79) AT=75.025n

.meas tran vdout0_80ck140 FIND v(dout0_80) AT=75.025n

.meas tran vdout0_81ck140 FIND v(dout0_81) AT=75.025n

.meas tran vdout0_82ck140 FIND v(dout0_82) AT=75.025n

.meas tran vdout0_83ck140 FIND v(dout0_83) AT=75.025n

.meas tran vdout0_84ck140 FIND v(dout0_84) AT=75.025n

.meas tran vdout0_85ck140 FIND v(dout0_85) AT=75.025n

.meas tran vdout0_86ck140 FIND v(dout0_86) AT=75.025n

.meas tran vdout0_87ck140 FIND v(dout0_87) AT=75.025n

.meas tran vdout0_88ck140 FIND v(dout0_88) AT=75.025n

.meas tran vdout0_89ck140 FIND v(dout0_89) AT=75.025n

.meas tran vdout0_90ck140 FIND v(dout0_90) AT=75.025n

.meas tran vdout0_91ck140 FIND v(dout0_91) AT=75.025n

.meas tran vdout0_92ck140 FIND v(dout0_92) AT=75.025n

.meas tran vdout0_93ck140 FIND v(dout0_93) AT=75.025n

.meas tran vdout0_94ck140 FIND v(dout0_94) AT=75.025n

.meas tran vdout0_95ck140 FIND v(dout0_95) AT=75.025n

.meas tran vdout0_96ck140 FIND v(dout0_96) AT=75.025n

.meas tran vdout0_97ck140 FIND v(dout0_97) AT=75.025n

.meas tran vdout0_98ck140 FIND v(dout0_98) AT=75.025n

.meas tran vdout0_99ck140 FIND v(dout0_99) AT=75.025n

.meas tran vdout0_100ck140 FIND v(dout0_100) AT=75.025n

.meas tran vdout0_101ck140 FIND v(dout0_101) AT=75.025n

.meas tran vdout0_102ck140 FIND v(dout0_102) AT=75.025n

.meas tran vdout0_103ck140 FIND v(dout0_103) AT=75.025n

.meas tran vdout0_104ck140 FIND v(dout0_104) AT=75.025n

.meas tran vdout0_105ck140 FIND v(dout0_105) AT=75.025n

.meas tran vdout0_106ck140 FIND v(dout0_106) AT=75.025n

.meas tran vdout0_107ck140 FIND v(dout0_107) AT=75.025n

.meas tran vdout0_108ck140 FIND v(dout0_108) AT=75.025n

.meas tran vdout0_109ck140 FIND v(dout0_109) AT=75.025n

.meas tran vdout0_110ck140 FIND v(dout0_110) AT=75.025n

.meas tran vdout0_111ck140 FIND v(dout0_111) AT=75.025n

.meas tran vdout0_112ck140 FIND v(dout0_112) AT=75.025n

.meas tran vdout0_113ck140 FIND v(dout0_113) AT=75.025n

.meas tran vdout0_114ck140 FIND v(dout0_114) AT=75.025n

.meas tran vdout0_115ck140 FIND v(dout0_115) AT=75.025n

.meas tran vdout0_116ck140 FIND v(dout0_116) AT=75.025n

.meas tran vdout0_117ck140 FIND v(dout0_117) AT=75.025n

.meas tran vdout0_118ck140 FIND v(dout0_118) AT=75.025n

.meas tran vdout0_119ck140 FIND v(dout0_119) AT=75.025n

.meas tran vdout0_120ck140 FIND v(dout0_120) AT=75.025n

.meas tran vdout0_121ck140 FIND v(dout0_121) AT=75.025n

.meas tran vdout0_122ck140 FIND v(dout0_122) AT=75.025n

.meas tran vdout0_123ck140 FIND v(dout0_123) AT=75.025n

.meas tran vdout0_124ck140 FIND v(dout0_124) AT=75.025n

.meas tran vdout0_125ck140 FIND v(dout0_125) AT=75.025n

.meas tran vdout0_126ck140 FIND v(dout0_126) AT=75.025n

.meas tran vdout0_127ck140 FIND v(dout0_127) AT=75.025n

.meas tran vdout0_128ck140 FIND v(dout0_128) AT=75.025n

.meas tran vdout0_129ck140 FIND v(dout0_129) AT=75.025n

.meas tran vdout0_130ck140 FIND v(dout0_130) AT=75.025n

.meas tran vdout0_131ck140 FIND v(dout0_131) AT=75.025n

.meas tran vdout0_132ck140 FIND v(dout0_132) AT=75.025n

.meas tran vdout0_133ck140 FIND v(dout0_133) AT=75.025n

.meas tran vdout0_134ck140 FIND v(dout0_134) AT=75.025n

.meas tran vdout0_135ck140 FIND v(dout0_135) AT=75.025n

.meas tran vdout0_136ck140 FIND v(dout0_136) AT=75.025n

.meas tran vdout0_137ck140 FIND v(dout0_137) AT=75.025n

.meas tran vdout0_138ck140 FIND v(dout0_138) AT=75.025n

.meas tran vdout0_139ck140 FIND v(dout0_139) AT=75.025n

.meas tran vdout0_140ck140 FIND v(dout0_140) AT=75.025n

.meas tran vdout0_141ck140 FIND v(dout0_141) AT=75.025n

.meas tran vdout0_142ck140 FIND v(dout0_142) AT=75.025n

.meas tran vdout0_143ck140 FIND v(dout0_143) AT=75.025n

.meas tran vdout0_144ck140 FIND v(dout0_144) AT=75.025n

.meas tran vdout0_145ck140 FIND v(dout0_145) AT=75.025n

.meas tran vdout0_146ck140 FIND v(dout0_146) AT=75.025n

.meas tran vdout0_147ck140 FIND v(dout0_147) AT=75.025n

.meas tran vdout0_148ck140 FIND v(dout0_148) AT=75.025n

.meas tran vdout0_149ck140 FIND v(dout0_149) AT=75.025n

.meas tran vdout0_0ck170 FIND v(dout0_0) AT=90.025n

.meas tran vdout0_1ck170 FIND v(dout0_1) AT=90.025n

.meas tran vdout0_2ck170 FIND v(dout0_2) AT=90.025n

.meas tran vdout0_3ck170 FIND v(dout0_3) AT=90.025n

.meas tran vdout0_4ck170 FIND v(dout0_4) AT=90.025n

.meas tran vdout0_5ck170 FIND v(dout0_5) AT=90.025n

.meas tran vdout0_6ck170 FIND v(dout0_6) AT=90.025n

.meas tran vdout0_7ck170 FIND v(dout0_7) AT=90.025n

.meas tran vdout0_8ck170 FIND v(dout0_8) AT=90.025n

.meas tran vdout0_9ck170 FIND v(dout0_9) AT=90.025n

.meas tran vdout0_10ck170 FIND v(dout0_10) AT=90.025n

.meas tran vdout0_11ck170 FIND v(dout0_11) AT=90.025n

.meas tran vdout0_12ck170 FIND v(dout0_12) AT=90.025n

.meas tran vdout0_13ck170 FIND v(dout0_13) AT=90.025n

.meas tran vdout0_14ck170 FIND v(dout0_14) AT=90.025n

.meas tran vdout0_15ck170 FIND v(dout0_15) AT=90.025n

.meas tran vdout0_16ck170 FIND v(dout0_16) AT=90.025n

.meas tran vdout0_17ck170 FIND v(dout0_17) AT=90.025n

.meas tran vdout0_18ck170 FIND v(dout0_18) AT=90.025n

.meas tran vdout0_19ck170 FIND v(dout0_19) AT=90.025n

.meas tran vdout0_20ck170 FIND v(dout0_20) AT=90.025n

.meas tran vdout0_21ck170 FIND v(dout0_21) AT=90.025n

.meas tran vdout0_22ck170 FIND v(dout0_22) AT=90.025n

.meas tran vdout0_23ck170 FIND v(dout0_23) AT=90.025n

.meas tran vdout0_24ck170 FIND v(dout0_24) AT=90.025n

.meas tran vdout0_25ck170 FIND v(dout0_25) AT=90.025n

.meas tran vdout0_26ck170 FIND v(dout0_26) AT=90.025n

.meas tran vdout0_27ck170 FIND v(dout0_27) AT=90.025n

.meas tran vdout0_28ck170 FIND v(dout0_28) AT=90.025n

.meas tran vdout0_29ck170 FIND v(dout0_29) AT=90.025n

.meas tran vdout0_30ck170 FIND v(dout0_30) AT=90.025n

.meas tran vdout0_31ck170 FIND v(dout0_31) AT=90.025n

.meas tran vdout0_32ck170 FIND v(dout0_32) AT=90.025n

.meas tran vdout0_33ck170 FIND v(dout0_33) AT=90.025n

.meas tran vdout0_34ck170 FIND v(dout0_34) AT=90.025n

.meas tran vdout0_35ck170 FIND v(dout0_35) AT=90.025n

.meas tran vdout0_36ck170 FIND v(dout0_36) AT=90.025n

.meas tran vdout0_37ck170 FIND v(dout0_37) AT=90.025n

.meas tran vdout0_38ck170 FIND v(dout0_38) AT=90.025n

.meas tran vdout0_39ck170 FIND v(dout0_39) AT=90.025n

.meas tran vdout0_40ck170 FIND v(dout0_40) AT=90.025n

.meas tran vdout0_41ck170 FIND v(dout0_41) AT=90.025n

.meas tran vdout0_42ck170 FIND v(dout0_42) AT=90.025n

.meas tran vdout0_43ck170 FIND v(dout0_43) AT=90.025n

.meas tran vdout0_44ck170 FIND v(dout0_44) AT=90.025n

.meas tran vdout0_45ck170 FIND v(dout0_45) AT=90.025n

.meas tran vdout0_46ck170 FIND v(dout0_46) AT=90.025n

.meas tran vdout0_47ck170 FIND v(dout0_47) AT=90.025n

.meas tran vdout0_48ck170 FIND v(dout0_48) AT=90.025n

.meas tran vdout0_49ck170 FIND v(dout0_49) AT=90.025n

.meas tran vdout0_50ck170 FIND v(dout0_50) AT=90.025n

.meas tran vdout0_51ck170 FIND v(dout0_51) AT=90.025n

.meas tran vdout0_52ck170 FIND v(dout0_52) AT=90.025n

.meas tran vdout0_53ck170 FIND v(dout0_53) AT=90.025n

.meas tran vdout0_54ck170 FIND v(dout0_54) AT=90.025n

.meas tran vdout0_55ck170 FIND v(dout0_55) AT=90.025n

.meas tran vdout0_56ck170 FIND v(dout0_56) AT=90.025n

.meas tran vdout0_57ck170 FIND v(dout0_57) AT=90.025n

.meas tran vdout0_58ck170 FIND v(dout0_58) AT=90.025n

.meas tran vdout0_59ck170 FIND v(dout0_59) AT=90.025n

.meas tran vdout0_60ck170 FIND v(dout0_60) AT=90.025n

.meas tran vdout0_61ck170 FIND v(dout0_61) AT=90.025n

.meas tran vdout0_62ck170 FIND v(dout0_62) AT=90.025n

.meas tran vdout0_63ck170 FIND v(dout0_63) AT=90.025n

.meas tran vdout0_64ck170 FIND v(dout0_64) AT=90.025n

.meas tran vdout0_65ck170 FIND v(dout0_65) AT=90.025n

.meas tran vdout0_66ck170 FIND v(dout0_66) AT=90.025n

.meas tran vdout0_67ck170 FIND v(dout0_67) AT=90.025n

.meas tran vdout0_68ck170 FIND v(dout0_68) AT=90.025n

.meas tran vdout0_69ck170 FIND v(dout0_69) AT=90.025n

.meas tran vdout0_70ck170 FIND v(dout0_70) AT=90.025n

.meas tran vdout0_71ck170 FIND v(dout0_71) AT=90.025n

.meas tran vdout0_72ck170 FIND v(dout0_72) AT=90.025n

.meas tran vdout0_73ck170 FIND v(dout0_73) AT=90.025n

.meas tran vdout0_74ck170 FIND v(dout0_74) AT=90.025n

.meas tran vdout0_75ck170 FIND v(dout0_75) AT=90.025n

.meas tran vdout0_76ck170 FIND v(dout0_76) AT=90.025n

.meas tran vdout0_77ck170 FIND v(dout0_77) AT=90.025n

.meas tran vdout0_78ck170 FIND v(dout0_78) AT=90.025n

.meas tran vdout0_79ck170 FIND v(dout0_79) AT=90.025n

.meas tran vdout0_80ck170 FIND v(dout0_80) AT=90.025n

.meas tran vdout0_81ck170 FIND v(dout0_81) AT=90.025n

.meas tran vdout0_82ck170 FIND v(dout0_82) AT=90.025n

.meas tran vdout0_83ck170 FIND v(dout0_83) AT=90.025n

.meas tran vdout0_84ck170 FIND v(dout0_84) AT=90.025n

.meas tran vdout0_85ck170 FIND v(dout0_85) AT=90.025n

.meas tran vdout0_86ck170 FIND v(dout0_86) AT=90.025n

.meas tran vdout0_87ck170 FIND v(dout0_87) AT=90.025n

.meas tran vdout0_88ck170 FIND v(dout0_88) AT=90.025n

.meas tran vdout0_89ck170 FIND v(dout0_89) AT=90.025n

.meas tran vdout0_90ck170 FIND v(dout0_90) AT=90.025n

.meas tran vdout0_91ck170 FIND v(dout0_91) AT=90.025n

.meas tran vdout0_92ck170 FIND v(dout0_92) AT=90.025n

.meas tran vdout0_93ck170 FIND v(dout0_93) AT=90.025n

.meas tran vdout0_94ck170 FIND v(dout0_94) AT=90.025n

.meas tran vdout0_95ck170 FIND v(dout0_95) AT=90.025n

.meas tran vdout0_96ck170 FIND v(dout0_96) AT=90.025n

.meas tran vdout0_97ck170 FIND v(dout0_97) AT=90.025n

.meas tran vdout0_98ck170 FIND v(dout0_98) AT=90.025n

.meas tran vdout0_99ck170 FIND v(dout0_99) AT=90.025n

.meas tran vdout0_100ck170 FIND v(dout0_100) AT=90.025n

.meas tran vdout0_101ck170 FIND v(dout0_101) AT=90.025n

.meas tran vdout0_102ck170 FIND v(dout0_102) AT=90.025n

.meas tran vdout0_103ck170 FIND v(dout0_103) AT=90.025n

.meas tran vdout0_104ck170 FIND v(dout0_104) AT=90.025n

.meas tran vdout0_105ck170 FIND v(dout0_105) AT=90.025n

.meas tran vdout0_106ck170 FIND v(dout0_106) AT=90.025n

.meas tran vdout0_107ck170 FIND v(dout0_107) AT=90.025n

.meas tran vdout0_108ck170 FIND v(dout0_108) AT=90.025n

.meas tran vdout0_109ck170 FIND v(dout0_109) AT=90.025n

.meas tran vdout0_110ck170 FIND v(dout0_110) AT=90.025n

.meas tran vdout0_111ck170 FIND v(dout0_111) AT=90.025n

.meas tran vdout0_112ck170 FIND v(dout0_112) AT=90.025n

.meas tran vdout0_113ck170 FIND v(dout0_113) AT=90.025n

.meas tran vdout0_114ck170 FIND v(dout0_114) AT=90.025n

.meas tran vdout0_115ck170 FIND v(dout0_115) AT=90.025n

.meas tran vdout0_116ck170 FIND v(dout0_116) AT=90.025n

.meas tran vdout0_117ck170 FIND v(dout0_117) AT=90.025n

.meas tran vdout0_118ck170 FIND v(dout0_118) AT=90.025n

.meas tran vdout0_119ck170 FIND v(dout0_119) AT=90.025n

.meas tran vdout0_120ck170 FIND v(dout0_120) AT=90.025n

.meas tran vdout0_121ck170 FIND v(dout0_121) AT=90.025n

.meas tran vdout0_122ck170 FIND v(dout0_122) AT=90.025n

.meas tran vdout0_123ck170 FIND v(dout0_123) AT=90.025n

.meas tran vdout0_124ck170 FIND v(dout0_124) AT=90.025n

.meas tran vdout0_125ck170 FIND v(dout0_125) AT=90.025n

.meas tran vdout0_126ck170 FIND v(dout0_126) AT=90.025n

.meas tran vdout0_127ck170 FIND v(dout0_127) AT=90.025n

.meas tran vdout0_128ck170 FIND v(dout0_128) AT=90.025n

.meas tran vdout0_129ck170 FIND v(dout0_129) AT=90.025n

.meas tran vdout0_130ck170 FIND v(dout0_130) AT=90.025n

.meas tran vdout0_131ck170 FIND v(dout0_131) AT=90.025n

.meas tran vdout0_132ck170 FIND v(dout0_132) AT=90.025n

.meas tran vdout0_133ck170 FIND v(dout0_133) AT=90.025n

.meas tran vdout0_134ck170 FIND v(dout0_134) AT=90.025n

.meas tran vdout0_135ck170 FIND v(dout0_135) AT=90.025n

.meas tran vdout0_136ck170 FIND v(dout0_136) AT=90.025n

.meas tran vdout0_137ck170 FIND v(dout0_137) AT=90.025n

.meas tran vdout0_138ck170 FIND v(dout0_138) AT=90.025n

.meas tran vdout0_139ck170 FIND v(dout0_139) AT=90.025n

.meas tran vdout0_140ck170 FIND v(dout0_140) AT=90.025n

.meas tran vdout0_141ck170 FIND v(dout0_141) AT=90.025n

.meas tran vdout0_142ck170 FIND v(dout0_142) AT=90.025n

.meas tran vdout0_143ck170 FIND v(dout0_143) AT=90.025n

.meas tran vdout0_144ck170 FIND v(dout0_144) AT=90.025n

.meas tran vdout0_145ck170 FIND v(dout0_145) AT=90.025n

.meas tran vdout0_146ck170 FIND v(dout0_146) AT=90.025n

.meas tran vdout0_147ck170 FIND v(dout0_147) AT=90.025n

.meas tran vdout0_148ck170 FIND v(dout0_148) AT=90.025n

.meas tran vdout0_149ck170 FIND v(dout0_149) AT=90.025n

.meas tran vdout0_0ck200 FIND v(dout0_0) AT=105.025n

.meas tran vdout0_1ck200 FIND v(dout0_1) AT=105.025n

.meas tran vdout0_2ck200 FIND v(dout0_2) AT=105.025n

.meas tran vdout0_3ck200 FIND v(dout0_3) AT=105.025n

.meas tran vdout0_4ck200 FIND v(dout0_4) AT=105.025n

.meas tran vdout0_5ck200 FIND v(dout0_5) AT=105.025n

.meas tran vdout0_6ck200 FIND v(dout0_6) AT=105.025n

.meas tran vdout0_7ck200 FIND v(dout0_7) AT=105.025n

.meas tran vdout0_8ck200 FIND v(dout0_8) AT=105.025n

.meas tran vdout0_9ck200 FIND v(dout0_9) AT=105.025n

.meas tran vdout0_10ck200 FIND v(dout0_10) AT=105.025n

.meas tran vdout0_11ck200 FIND v(dout0_11) AT=105.025n

.meas tran vdout0_12ck200 FIND v(dout0_12) AT=105.025n

.meas tran vdout0_13ck200 FIND v(dout0_13) AT=105.025n

.meas tran vdout0_14ck200 FIND v(dout0_14) AT=105.025n

.meas tran vdout0_15ck200 FIND v(dout0_15) AT=105.025n

.meas tran vdout0_16ck200 FIND v(dout0_16) AT=105.025n

.meas tran vdout0_17ck200 FIND v(dout0_17) AT=105.025n

.meas tran vdout0_18ck200 FIND v(dout0_18) AT=105.025n

.meas tran vdout0_19ck200 FIND v(dout0_19) AT=105.025n

.meas tran vdout0_20ck200 FIND v(dout0_20) AT=105.025n

.meas tran vdout0_21ck200 FIND v(dout0_21) AT=105.025n

.meas tran vdout0_22ck200 FIND v(dout0_22) AT=105.025n

.meas tran vdout0_23ck200 FIND v(dout0_23) AT=105.025n

.meas tran vdout0_24ck200 FIND v(dout0_24) AT=105.025n

.meas tran vdout0_25ck200 FIND v(dout0_25) AT=105.025n

.meas tran vdout0_26ck200 FIND v(dout0_26) AT=105.025n

.meas tran vdout0_27ck200 FIND v(dout0_27) AT=105.025n

.meas tran vdout0_28ck200 FIND v(dout0_28) AT=105.025n

.meas tran vdout0_29ck200 FIND v(dout0_29) AT=105.025n

.meas tran vdout0_30ck200 FIND v(dout0_30) AT=105.025n

.meas tran vdout0_31ck200 FIND v(dout0_31) AT=105.025n

.meas tran vdout0_32ck200 FIND v(dout0_32) AT=105.025n

.meas tran vdout0_33ck200 FIND v(dout0_33) AT=105.025n

.meas tran vdout0_34ck200 FIND v(dout0_34) AT=105.025n

.meas tran vdout0_35ck200 FIND v(dout0_35) AT=105.025n

.meas tran vdout0_36ck200 FIND v(dout0_36) AT=105.025n

.meas tran vdout0_37ck200 FIND v(dout0_37) AT=105.025n

.meas tran vdout0_38ck200 FIND v(dout0_38) AT=105.025n

.meas tran vdout0_39ck200 FIND v(dout0_39) AT=105.025n

.meas tran vdout0_40ck200 FIND v(dout0_40) AT=105.025n

.meas tran vdout0_41ck200 FIND v(dout0_41) AT=105.025n

.meas tran vdout0_42ck200 FIND v(dout0_42) AT=105.025n

.meas tran vdout0_43ck200 FIND v(dout0_43) AT=105.025n

.meas tran vdout0_44ck200 FIND v(dout0_44) AT=105.025n

.meas tran vdout0_45ck200 FIND v(dout0_45) AT=105.025n

.meas tran vdout0_46ck200 FIND v(dout0_46) AT=105.025n

.meas tran vdout0_47ck200 FIND v(dout0_47) AT=105.025n

.meas tran vdout0_48ck200 FIND v(dout0_48) AT=105.025n

.meas tran vdout0_49ck200 FIND v(dout0_49) AT=105.025n

.meas tran vdout0_50ck200 FIND v(dout0_50) AT=105.025n

.meas tran vdout0_51ck200 FIND v(dout0_51) AT=105.025n

.meas tran vdout0_52ck200 FIND v(dout0_52) AT=105.025n

.meas tran vdout0_53ck200 FIND v(dout0_53) AT=105.025n

.meas tran vdout0_54ck200 FIND v(dout0_54) AT=105.025n

.meas tran vdout0_55ck200 FIND v(dout0_55) AT=105.025n

.meas tran vdout0_56ck200 FIND v(dout0_56) AT=105.025n

.meas tran vdout0_57ck200 FIND v(dout0_57) AT=105.025n

.meas tran vdout0_58ck200 FIND v(dout0_58) AT=105.025n

.meas tran vdout0_59ck200 FIND v(dout0_59) AT=105.025n

.meas tran vdout0_60ck200 FIND v(dout0_60) AT=105.025n

.meas tran vdout0_61ck200 FIND v(dout0_61) AT=105.025n

.meas tran vdout0_62ck200 FIND v(dout0_62) AT=105.025n

.meas tran vdout0_63ck200 FIND v(dout0_63) AT=105.025n

.meas tran vdout0_64ck200 FIND v(dout0_64) AT=105.025n

.meas tran vdout0_65ck200 FIND v(dout0_65) AT=105.025n

.meas tran vdout0_66ck200 FIND v(dout0_66) AT=105.025n

.meas tran vdout0_67ck200 FIND v(dout0_67) AT=105.025n

.meas tran vdout0_68ck200 FIND v(dout0_68) AT=105.025n

.meas tran vdout0_69ck200 FIND v(dout0_69) AT=105.025n

.meas tran vdout0_70ck200 FIND v(dout0_70) AT=105.025n

.meas tran vdout0_71ck200 FIND v(dout0_71) AT=105.025n

.meas tran vdout0_72ck200 FIND v(dout0_72) AT=105.025n

.meas tran vdout0_73ck200 FIND v(dout0_73) AT=105.025n

.meas tran vdout0_74ck200 FIND v(dout0_74) AT=105.025n

.meas tran vdout0_75ck200 FIND v(dout0_75) AT=105.025n

.meas tran vdout0_76ck200 FIND v(dout0_76) AT=105.025n

.meas tran vdout0_77ck200 FIND v(dout0_77) AT=105.025n

.meas tran vdout0_78ck200 FIND v(dout0_78) AT=105.025n

.meas tran vdout0_79ck200 FIND v(dout0_79) AT=105.025n

.meas tran vdout0_80ck200 FIND v(dout0_80) AT=105.025n

.meas tran vdout0_81ck200 FIND v(dout0_81) AT=105.025n

.meas tran vdout0_82ck200 FIND v(dout0_82) AT=105.025n

.meas tran vdout0_83ck200 FIND v(dout0_83) AT=105.025n

.meas tran vdout0_84ck200 FIND v(dout0_84) AT=105.025n

.meas tran vdout0_85ck200 FIND v(dout0_85) AT=105.025n

.meas tran vdout0_86ck200 FIND v(dout0_86) AT=105.025n

.meas tran vdout0_87ck200 FIND v(dout0_87) AT=105.025n

.meas tran vdout0_88ck200 FIND v(dout0_88) AT=105.025n

.meas tran vdout0_89ck200 FIND v(dout0_89) AT=105.025n

.meas tran vdout0_90ck200 FIND v(dout0_90) AT=105.025n

.meas tran vdout0_91ck200 FIND v(dout0_91) AT=105.025n

.meas tran vdout0_92ck200 FIND v(dout0_92) AT=105.025n

.meas tran vdout0_93ck200 FIND v(dout0_93) AT=105.025n

.meas tran vdout0_94ck200 FIND v(dout0_94) AT=105.025n

.meas tran vdout0_95ck200 FIND v(dout0_95) AT=105.025n

.meas tran vdout0_96ck200 FIND v(dout0_96) AT=105.025n

.meas tran vdout0_97ck200 FIND v(dout0_97) AT=105.025n

.meas tran vdout0_98ck200 FIND v(dout0_98) AT=105.025n

.meas tran vdout0_99ck200 FIND v(dout0_99) AT=105.025n

.meas tran vdout0_100ck200 FIND v(dout0_100) AT=105.025n

.meas tran vdout0_101ck200 FIND v(dout0_101) AT=105.025n

.meas tran vdout0_102ck200 FIND v(dout0_102) AT=105.025n

.meas tran vdout0_103ck200 FIND v(dout0_103) AT=105.025n

.meas tran vdout0_104ck200 FIND v(dout0_104) AT=105.025n

.meas tran vdout0_105ck200 FIND v(dout0_105) AT=105.025n

.meas tran vdout0_106ck200 FIND v(dout0_106) AT=105.025n

.meas tran vdout0_107ck200 FIND v(dout0_107) AT=105.025n

.meas tran vdout0_108ck200 FIND v(dout0_108) AT=105.025n

.meas tran vdout0_109ck200 FIND v(dout0_109) AT=105.025n

.meas tran vdout0_110ck200 FIND v(dout0_110) AT=105.025n

.meas tran vdout0_111ck200 FIND v(dout0_111) AT=105.025n

.meas tran vdout0_112ck200 FIND v(dout0_112) AT=105.025n

.meas tran vdout0_113ck200 FIND v(dout0_113) AT=105.025n

.meas tran vdout0_114ck200 FIND v(dout0_114) AT=105.025n

.meas tran vdout0_115ck200 FIND v(dout0_115) AT=105.025n

.meas tran vdout0_116ck200 FIND v(dout0_116) AT=105.025n

.meas tran vdout0_117ck200 FIND v(dout0_117) AT=105.025n

.meas tran vdout0_118ck200 FIND v(dout0_118) AT=105.025n

.meas tran vdout0_119ck200 FIND v(dout0_119) AT=105.025n

.meas tran vdout0_120ck200 FIND v(dout0_120) AT=105.025n

.meas tran vdout0_121ck200 FIND v(dout0_121) AT=105.025n

.meas tran vdout0_122ck200 FIND v(dout0_122) AT=105.025n

.meas tran vdout0_123ck200 FIND v(dout0_123) AT=105.025n

.meas tran vdout0_124ck200 FIND v(dout0_124) AT=105.025n

.meas tran vdout0_125ck200 FIND v(dout0_125) AT=105.025n

.meas tran vdout0_126ck200 FIND v(dout0_126) AT=105.025n

.meas tran vdout0_127ck200 FIND v(dout0_127) AT=105.025n

.meas tran vdout0_128ck200 FIND v(dout0_128) AT=105.025n

.meas tran vdout0_129ck200 FIND v(dout0_129) AT=105.025n

.meas tran vdout0_130ck200 FIND v(dout0_130) AT=105.025n

.meas tran vdout0_131ck200 FIND v(dout0_131) AT=105.025n

.meas tran vdout0_132ck200 FIND v(dout0_132) AT=105.025n

.meas tran vdout0_133ck200 FIND v(dout0_133) AT=105.025n

.meas tran vdout0_134ck200 FIND v(dout0_134) AT=105.025n

.meas tran vdout0_135ck200 FIND v(dout0_135) AT=105.025n

.meas tran vdout0_136ck200 FIND v(dout0_136) AT=105.025n

.meas tran vdout0_137ck200 FIND v(dout0_137) AT=105.025n

.meas tran vdout0_138ck200 FIND v(dout0_138) AT=105.025n

.meas tran vdout0_139ck200 FIND v(dout0_139) AT=105.025n

.meas tran vdout0_140ck200 FIND v(dout0_140) AT=105.025n

.meas tran vdout0_141ck200 FIND v(dout0_141) AT=105.025n

.meas tran vdout0_142ck200 FIND v(dout0_142) AT=105.025n

.meas tran vdout0_143ck200 FIND v(dout0_143) AT=105.025n

.meas tran vdout0_144ck200 FIND v(dout0_144) AT=105.025n

.meas tran vdout0_145ck200 FIND v(dout0_145) AT=105.025n

.meas tran vdout0_146ck200 FIND v(dout0_146) AT=105.025n

.meas tran vdout0_147ck200 FIND v(dout0_147) AT=105.025n

.meas tran vdout0_148ck200 FIND v(dout0_148) AT=105.025n

.meas tran vdout0_149ck200 FIND v(dout0_149) AT=105.025n

.meas tran vdout0_0ck210 FIND v(dout0_0) AT=110.025n

.meas tran vdout0_1ck210 FIND v(dout0_1) AT=110.025n

.meas tran vdout0_2ck210 FIND v(dout0_2) AT=110.025n

.meas tran vdout0_3ck210 FIND v(dout0_3) AT=110.025n

.meas tran vdout0_4ck210 FIND v(dout0_4) AT=110.025n

.meas tran vdout0_5ck210 FIND v(dout0_5) AT=110.025n

.meas tran vdout0_6ck210 FIND v(dout0_6) AT=110.025n

.meas tran vdout0_7ck210 FIND v(dout0_7) AT=110.025n

.meas tran vdout0_8ck210 FIND v(dout0_8) AT=110.025n

.meas tran vdout0_9ck210 FIND v(dout0_9) AT=110.025n

.meas tran vdout0_10ck210 FIND v(dout0_10) AT=110.025n

.meas tran vdout0_11ck210 FIND v(dout0_11) AT=110.025n

.meas tran vdout0_12ck210 FIND v(dout0_12) AT=110.025n

.meas tran vdout0_13ck210 FIND v(dout0_13) AT=110.025n

.meas tran vdout0_14ck210 FIND v(dout0_14) AT=110.025n

.meas tran vdout0_15ck210 FIND v(dout0_15) AT=110.025n

.meas tran vdout0_16ck210 FIND v(dout0_16) AT=110.025n

.meas tran vdout0_17ck210 FIND v(dout0_17) AT=110.025n

.meas tran vdout0_18ck210 FIND v(dout0_18) AT=110.025n

.meas tran vdout0_19ck210 FIND v(dout0_19) AT=110.025n

.meas tran vdout0_20ck210 FIND v(dout0_20) AT=110.025n

.meas tran vdout0_21ck210 FIND v(dout0_21) AT=110.025n

.meas tran vdout0_22ck210 FIND v(dout0_22) AT=110.025n

.meas tran vdout0_23ck210 FIND v(dout0_23) AT=110.025n

.meas tran vdout0_24ck210 FIND v(dout0_24) AT=110.025n

.meas tran vdout0_25ck210 FIND v(dout0_25) AT=110.025n

.meas tran vdout0_26ck210 FIND v(dout0_26) AT=110.025n

.meas tran vdout0_27ck210 FIND v(dout0_27) AT=110.025n

.meas tran vdout0_28ck210 FIND v(dout0_28) AT=110.025n

.meas tran vdout0_29ck210 FIND v(dout0_29) AT=110.025n

.meas tran vdout0_30ck210 FIND v(dout0_30) AT=110.025n

.meas tran vdout0_31ck210 FIND v(dout0_31) AT=110.025n

.meas tran vdout0_32ck210 FIND v(dout0_32) AT=110.025n

.meas tran vdout0_33ck210 FIND v(dout0_33) AT=110.025n

.meas tran vdout0_34ck210 FIND v(dout0_34) AT=110.025n

.meas tran vdout0_35ck210 FIND v(dout0_35) AT=110.025n

.meas tran vdout0_36ck210 FIND v(dout0_36) AT=110.025n

.meas tran vdout0_37ck210 FIND v(dout0_37) AT=110.025n

.meas tran vdout0_38ck210 FIND v(dout0_38) AT=110.025n

.meas tran vdout0_39ck210 FIND v(dout0_39) AT=110.025n

.meas tran vdout0_40ck210 FIND v(dout0_40) AT=110.025n

.meas tran vdout0_41ck210 FIND v(dout0_41) AT=110.025n

.meas tran vdout0_42ck210 FIND v(dout0_42) AT=110.025n

.meas tran vdout0_43ck210 FIND v(dout0_43) AT=110.025n

.meas tran vdout0_44ck210 FIND v(dout0_44) AT=110.025n

.meas tran vdout0_45ck210 FIND v(dout0_45) AT=110.025n

.meas tran vdout0_46ck210 FIND v(dout0_46) AT=110.025n

.meas tran vdout0_47ck210 FIND v(dout0_47) AT=110.025n

.meas tran vdout0_48ck210 FIND v(dout0_48) AT=110.025n

.meas tran vdout0_49ck210 FIND v(dout0_49) AT=110.025n

.meas tran vdout0_50ck210 FIND v(dout0_50) AT=110.025n

.meas tran vdout0_51ck210 FIND v(dout0_51) AT=110.025n

.meas tran vdout0_52ck210 FIND v(dout0_52) AT=110.025n

.meas tran vdout0_53ck210 FIND v(dout0_53) AT=110.025n

.meas tran vdout0_54ck210 FIND v(dout0_54) AT=110.025n

.meas tran vdout0_55ck210 FIND v(dout0_55) AT=110.025n

.meas tran vdout0_56ck210 FIND v(dout0_56) AT=110.025n

.meas tran vdout0_57ck210 FIND v(dout0_57) AT=110.025n

.meas tran vdout0_58ck210 FIND v(dout0_58) AT=110.025n

.meas tran vdout0_59ck210 FIND v(dout0_59) AT=110.025n

.meas tran vdout0_60ck210 FIND v(dout0_60) AT=110.025n

.meas tran vdout0_61ck210 FIND v(dout0_61) AT=110.025n

.meas tran vdout0_62ck210 FIND v(dout0_62) AT=110.025n

.meas tran vdout0_63ck210 FIND v(dout0_63) AT=110.025n

.meas tran vdout0_64ck210 FIND v(dout0_64) AT=110.025n

.meas tran vdout0_65ck210 FIND v(dout0_65) AT=110.025n

.meas tran vdout0_66ck210 FIND v(dout0_66) AT=110.025n

.meas tran vdout0_67ck210 FIND v(dout0_67) AT=110.025n

.meas tran vdout0_68ck210 FIND v(dout0_68) AT=110.025n

.meas tran vdout0_69ck210 FIND v(dout0_69) AT=110.025n

.meas tran vdout0_70ck210 FIND v(dout0_70) AT=110.025n

.meas tran vdout0_71ck210 FIND v(dout0_71) AT=110.025n

.meas tran vdout0_72ck210 FIND v(dout0_72) AT=110.025n

.meas tran vdout0_73ck210 FIND v(dout0_73) AT=110.025n

.meas tran vdout0_74ck210 FIND v(dout0_74) AT=110.025n

.meas tran vdout0_75ck210 FIND v(dout0_75) AT=110.025n

.meas tran vdout0_76ck210 FIND v(dout0_76) AT=110.025n

.meas tran vdout0_77ck210 FIND v(dout0_77) AT=110.025n

.meas tran vdout0_78ck210 FIND v(dout0_78) AT=110.025n

.meas tran vdout0_79ck210 FIND v(dout0_79) AT=110.025n

.meas tran vdout0_80ck210 FIND v(dout0_80) AT=110.025n

.meas tran vdout0_81ck210 FIND v(dout0_81) AT=110.025n

.meas tran vdout0_82ck210 FIND v(dout0_82) AT=110.025n

.meas tran vdout0_83ck210 FIND v(dout0_83) AT=110.025n

.meas tran vdout0_84ck210 FIND v(dout0_84) AT=110.025n

.meas tran vdout0_85ck210 FIND v(dout0_85) AT=110.025n

.meas tran vdout0_86ck210 FIND v(dout0_86) AT=110.025n

.meas tran vdout0_87ck210 FIND v(dout0_87) AT=110.025n

.meas tran vdout0_88ck210 FIND v(dout0_88) AT=110.025n

.meas tran vdout0_89ck210 FIND v(dout0_89) AT=110.025n

.meas tran vdout0_90ck210 FIND v(dout0_90) AT=110.025n

.meas tran vdout0_91ck210 FIND v(dout0_91) AT=110.025n

.meas tran vdout0_92ck210 FIND v(dout0_92) AT=110.025n

.meas tran vdout0_93ck210 FIND v(dout0_93) AT=110.025n

.meas tran vdout0_94ck210 FIND v(dout0_94) AT=110.025n

.meas tran vdout0_95ck210 FIND v(dout0_95) AT=110.025n

.meas tran vdout0_96ck210 FIND v(dout0_96) AT=110.025n

.meas tran vdout0_97ck210 FIND v(dout0_97) AT=110.025n

.meas tran vdout0_98ck210 FIND v(dout0_98) AT=110.025n

.meas tran vdout0_99ck210 FIND v(dout0_99) AT=110.025n

.meas tran vdout0_100ck210 FIND v(dout0_100) AT=110.025n

.meas tran vdout0_101ck210 FIND v(dout0_101) AT=110.025n

.meas tran vdout0_102ck210 FIND v(dout0_102) AT=110.025n

.meas tran vdout0_103ck210 FIND v(dout0_103) AT=110.025n

.meas tran vdout0_104ck210 FIND v(dout0_104) AT=110.025n

.meas tran vdout0_105ck210 FIND v(dout0_105) AT=110.025n

.meas tran vdout0_106ck210 FIND v(dout0_106) AT=110.025n

.meas tran vdout0_107ck210 FIND v(dout0_107) AT=110.025n

.meas tran vdout0_108ck210 FIND v(dout0_108) AT=110.025n

.meas tran vdout0_109ck210 FIND v(dout0_109) AT=110.025n

.meas tran vdout0_110ck210 FIND v(dout0_110) AT=110.025n

.meas tran vdout0_111ck210 FIND v(dout0_111) AT=110.025n

.meas tran vdout0_112ck210 FIND v(dout0_112) AT=110.025n

.meas tran vdout0_113ck210 FIND v(dout0_113) AT=110.025n

.meas tran vdout0_114ck210 FIND v(dout0_114) AT=110.025n

.meas tran vdout0_115ck210 FIND v(dout0_115) AT=110.025n

.meas tran vdout0_116ck210 FIND v(dout0_116) AT=110.025n

.meas tran vdout0_117ck210 FIND v(dout0_117) AT=110.025n

.meas tran vdout0_118ck210 FIND v(dout0_118) AT=110.025n

.meas tran vdout0_119ck210 FIND v(dout0_119) AT=110.025n

.meas tran vdout0_120ck210 FIND v(dout0_120) AT=110.025n

.meas tran vdout0_121ck210 FIND v(dout0_121) AT=110.025n

.meas tran vdout0_122ck210 FIND v(dout0_122) AT=110.025n

.meas tran vdout0_123ck210 FIND v(dout0_123) AT=110.025n

.meas tran vdout0_124ck210 FIND v(dout0_124) AT=110.025n

.meas tran vdout0_125ck210 FIND v(dout0_125) AT=110.025n

.meas tran vdout0_126ck210 FIND v(dout0_126) AT=110.025n

.meas tran vdout0_127ck210 FIND v(dout0_127) AT=110.025n

.meas tran vdout0_128ck210 FIND v(dout0_128) AT=110.025n

.meas tran vdout0_129ck210 FIND v(dout0_129) AT=110.025n

.meas tran vdout0_130ck210 FIND v(dout0_130) AT=110.025n

.meas tran vdout0_131ck210 FIND v(dout0_131) AT=110.025n

.meas tran vdout0_132ck210 FIND v(dout0_132) AT=110.025n

.meas tran vdout0_133ck210 FIND v(dout0_133) AT=110.025n

.meas tran vdout0_134ck210 FIND v(dout0_134) AT=110.025n

.meas tran vdout0_135ck210 FIND v(dout0_135) AT=110.025n

.meas tran vdout0_136ck210 FIND v(dout0_136) AT=110.025n

.meas tran vdout0_137ck210 FIND v(dout0_137) AT=110.025n

.meas tran vdout0_138ck210 FIND v(dout0_138) AT=110.025n

.meas tran vdout0_139ck210 FIND v(dout0_139) AT=110.025n

.meas tran vdout0_140ck210 FIND v(dout0_140) AT=110.025n

.meas tran vdout0_141ck210 FIND v(dout0_141) AT=110.025n

.meas tran vdout0_142ck210 FIND v(dout0_142) AT=110.025n

.meas tran vdout0_143ck210 FIND v(dout0_143) AT=110.025n

.meas tran vdout0_144ck210 FIND v(dout0_144) AT=110.025n

.meas tran vdout0_145ck210 FIND v(dout0_145) AT=110.025n

.meas tran vdout0_146ck210 FIND v(dout0_146) AT=110.025n

.meas tran vdout0_147ck210 FIND v(dout0_147) AT=110.025n

.meas tran vdout0_148ck210 FIND v(dout0_148) AT=110.025n

.meas tran vdout0_149ck210 FIND v(dout0_149) AT=110.025n

.meas tran vdout0_0ck220 FIND v(dout0_0) AT=115.025n

.meas tran vdout0_1ck220 FIND v(dout0_1) AT=115.025n

.meas tran vdout0_2ck220 FIND v(dout0_2) AT=115.025n

.meas tran vdout0_3ck220 FIND v(dout0_3) AT=115.025n

.meas tran vdout0_4ck220 FIND v(dout0_4) AT=115.025n

.meas tran vdout0_5ck220 FIND v(dout0_5) AT=115.025n

.meas tran vdout0_6ck220 FIND v(dout0_6) AT=115.025n

.meas tran vdout0_7ck220 FIND v(dout0_7) AT=115.025n

.meas tran vdout0_8ck220 FIND v(dout0_8) AT=115.025n

.meas tran vdout0_9ck220 FIND v(dout0_9) AT=115.025n

.meas tran vdout0_10ck220 FIND v(dout0_10) AT=115.025n

.meas tran vdout0_11ck220 FIND v(dout0_11) AT=115.025n

.meas tran vdout0_12ck220 FIND v(dout0_12) AT=115.025n

.meas tran vdout0_13ck220 FIND v(dout0_13) AT=115.025n

.meas tran vdout0_14ck220 FIND v(dout0_14) AT=115.025n

.meas tran vdout0_15ck220 FIND v(dout0_15) AT=115.025n

.meas tran vdout0_16ck220 FIND v(dout0_16) AT=115.025n

.meas tran vdout0_17ck220 FIND v(dout0_17) AT=115.025n

.meas tran vdout0_18ck220 FIND v(dout0_18) AT=115.025n

.meas tran vdout0_19ck220 FIND v(dout0_19) AT=115.025n

.meas tran vdout0_20ck220 FIND v(dout0_20) AT=115.025n

.meas tran vdout0_21ck220 FIND v(dout0_21) AT=115.025n

.meas tran vdout0_22ck220 FIND v(dout0_22) AT=115.025n

.meas tran vdout0_23ck220 FIND v(dout0_23) AT=115.025n

.meas tran vdout0_24ck220 FIND v(dout0_24) AT=115.025n

.meas tran vdout0_25ck220 FIND v(dout0_25) AT=115.025n

.meas tran vdout0_26ck220 FIND v(dout0_26) AT=115.025n

.meas tran vdout0_27ck220 FIND v(dout0_27) AT=115.025n

.meas tran vdout0_28ck220 FIND v(dout0_28) AT=115.025n

.meas tran vdout0_29ck220 FIND v(dout0_29) AT=115.025n

.meas tran vdout0_30ck220 FIND v(dout0_30) AT=115.025n

.meas tran vdout0_31ck220 FIND v(dout0_31) AT=115.025n

.meas tran vdout0_32ck220 FIND v(dout0_32) AT=115.025n

.meas tran vdout0_33ck220 FIND v(dout0_33) AT=115.025n

.meas tran vdout0_34ck220 FIND v(dout0_34) AT=115.025n

.meas tran vdout0_35ck220 FIND v(dout0_35) AT=115.025n

.meas tran vdout0_36ck220 FIND v(dout0_36) AT=115.025n

.meas tran vdout0_37ck220 FIND v(dout0_37) AT=115.025n

.meas tran vdout0_38ck220 FIND v(dout0_38) AT=115.025n

.meas tran vdout0_39ck220 FIND v(dout0_39) AT=115.025n

.meas tran vdout0_40ck220 FIND v(dout0_40) AT=115.025n

.meas tran vdout0_41ck220 FIND v(dout0_41) AT=115.025n

.meas tran vdout0_42ck220 FIND v(dout0_42) AT=115.025n

.meas tran vdout0_43ck220 FIND v(dout0_43) AT=115.025n

.meas tran vdout0_44ck220 FIND v(dout0_44) AT=115.025n

.meas tran vdout0_45ck220 FIND v(dout0_45) AT=115.025n

.meas tran vdout0_46ck220 FIND v(dout0_46) AT=115.025n

.meas tran vdout0_47ck220 FIND v(dout0_47) AT=115.025n

.meas tran vdout0_48ck220 FIND v(dout0_48) AT=115.025n

.meas tran vdout0_49ck220 FIND v(dout0_49) AT=115.025n

.meas tran vdout0_50ck220 FIND v(dout0_50) AT=115.025n

.meas tran vdout0_51ck220 FIND v(dout0_51) AT=115.025n

.meas tran vdout0_52ck220 FIND v(dout0_52) AT=115.025n

.meas tran vdout0_53ck220 FIND v(dout0_53) AT=115.025n

.meas tran vdout0_54ck220 FIND v(dout0_54) AT=115.025n

.meas tran vdout0_55ck220 FIND v(dout0_55) AT=115.025n

.meas tran vdout0_56ck220 FIND v(dout0_56) AT=115.025n

.meas tran vdout0_57ck220 FIND v(dout0_57) AT=115.025n

.meas tran vdout0_58ck220 FIND v(dout0_58) AT=115.025n

.meas tran vdout0_59ck220 FIND v(dout0_59) AT=115.025n

.meas tran vdout0_60ck220 FIND v(dout0_60) AT=115.025n

.meas tran vdout0_61ck220 FIND v(dout0_61) AT=115.025n

.meas tran vdout0_62ck220 FIND v(dout0_62) AT=115.025n

.meas tran vdout0_63ck220 FIND v(dout0_63) AT=115.025n

.meas tran vdout0_64ck220 FIND v(dout0_64) AT=115.025n

.meas tran vdout0_65ck220 FIND v(dout0_65) AT=115.025n

.meas tran vdout0_66ck220 FIND v(dout0_66) AT=115.025n

.meas tran vdout0_67ck220 FIND v(dout0_67) AT=115.025n

.meas tran vdout0_68ck220 FIND v(dout0_68) AT=115.025n

.meas tran vdout0_69ck220 FIND v(dout0_69) AT=115.025n

.meas tran vdout0_70ck220 FIND v(dout0_70) AT=115.025n

.meas tran vdout0_71ck220 FIND v(dout0_71) AT=115.025n

.meas tran vdout0_72ck220 FIND v(dout0_72) AT=115.025n

.meas tran vdout0_73ck220 FIND v(dout0_73) AT=115.025n

.meas tran vdout0_74ck220 FIND v(dout0_74) AT=115.025n

.meas tran vdout0_75ck220 FIND v(dout0_75) AT=115.025n

.meas tran vdout0_76ck220 FIND v(dout0_76) AT=115.025n

.meas tran vdout0_77ck220 FIND v(dout0_77) AT=115.025n

.meas tran vdout0_78ck220 FIND v(dout0_78) AT=115.025n

.meas tran vdout0_79ck220 FIND v(dout0_79) AT=115.025n

.meas tran vdout0_80ck220 FIND v(dout0_80) AT=115.025n

.meas tran vdout0_81ck220 FIND v(dout0_81) AT=115.025n

.meas tran vdout0_82ck220 FIND v(dout0_82) AT=115.025n

.meas tran vdout0_83ck220 FIND v(dout0_83) AT=115.025n

.meas tran vdout0_84ck220 FIND v(dout0_84) AT=115.025n

.meas tran vdout0_85ck220 FIND v(dout0_85) AT=115.025n

.meas tran vdout0_86ck220 FIND v(dout0_86) AT=115.025n

.meas tran vdout0_87ck220 FIND v(dout0_87) AT=115.025n

.meas tran vdout0_88ck220 FIND v(dout0_88) AT=115.025n

.meas tran vdout0_89ck220 FIND v(dout0_89) AT=115.025n

.meas tran vdout0_90ck220 FIND v(dout0_90) AT=115.025n

.meas tran vdout0_91ck220 FIND v(dout0_91) AT=115.025n

.meas tran vdout0_92ck220 FIND v(dout0_92) AT=115.025n

.meas tran vdout0_93ck220 FIND v(dout0_93) AT=115.025n

.meas tran vdout0_94ck220 FIND v(dout0_94) AT=115.025n

.meas tran vdout0_95ck220 FIND v(dout0_95) AT=115.025n

.meas tran vdout0_96ck220 FIND v(dout0_96) AT=115.025n

.meas tran vdout0_97ck220 FIND v(dout0_97) AT=115.025n

.meas tran vdout0_98ck220 FIND v(dout0_98) AT=115.025n

.meas tran vdout0_99ck220 FIND v(dout0_99) AT=115.025n

.meas tran vdout0_100ck220 FIND v(dout0_100) AT=115.025n

.meas tran vdout0_101ck220 FIND v(dout0_101) AT=115.025n

.meas tran vdout0_102ck220 FIND v(dout0_102) AT=115.025n

.meas tran vdout0_103ck220 FIND v(dout0_103) AT=115.025n

.meas tran vdout0_104ck220 FIND v(dout0_104) AT=115.025n

.meas tran vdout0_105ck220 FIND v(dout0_105) AT=115.025n

.meas tran vdout0_106ck220 FIND v(dout0_106) AT=115.025n

.meas tran vdout0_107ck220 FIND v(dout0_107) AT=115.025n

.meas tran vdout0_108ck220 FIND v(dout0_108) AT=115.025n

.meas tran vdout0_109ck220 FIND v(dout0_109) AT=115.025n

.meas tran vdout0_110ck220 FIND v(dout0_110) AT=115.025n

.meas tran vdout0_111ck220 FIND v(dout0_111) AT=115.025n

.meas tran vdout0_112ck220 FIND v(dout0_112) AT=115.025n

.meas tran vdout0_113ck220 FIND v(dout0_113) AT=115.025n

.meas tran vdout0_114ck220 FIND v(dout0_114) AT=115.025n

.meas tran vdout0_115ck220 FIND v(dout0_115) AT=115.025n

.meas tran vdout0_116ck220 FIND v(dout0_116) AT=115.025n

.meas tran vdout0_117ck220 FIND v(dout0_117) AT=115.025n

.meas tran vdout0_118ck220 FIND v(dout0_118) AT=115.025n

.meas tran vdout0_119ck220 FIND v(dout0_119) AT=115.025n

.meas tran vdout0_120ck220 FIND v(dout0_120) AT=115.025n

.meas tran vdout0_121ck220 FIND v(dout0_121) AT=115.025n

.meas tran vdout0_122ck220 FIND v(dout0_122) AT=115.025n

.meas tran vdout0_123ck220 FIND v(dout0_123) AT=115.025n

.meas tran vdout0_124ck220 FIND v(dout0_124) AT=115.025n

.meas tran vdout0_125ck220 FIND v(dout0_125) AT=115.025n

.meas tran vdout0_126ck220 FIND v(dout0_126) AT=115.025n

.meas tran vdout0_127ck220 FIND v(dout0_127) AT=115.025n

.meas tran vdout0_128ck220 FIND v(dout0_128) AT=115.025n

.meas tran vdout0_129ck220 FIND v(dout0_129) AT=115.025n

.meas tran vdout0_130ck220 FIND v(dout0_130) AT=115.025n

.meas tran vdout0_131ck220 FIND v(dout0_131) AT=115.025n

.meas tran vdout0_132ck220 FIND v(dout0_132) AT=115.025n

.meas tran vdout0_133ck220 FIND v(dout0_133) AT=115.025n

.meas tran vdout0_134ck220 FIND v(dout0_134) AT=115.025n

.meas tran vdout0_135ck220 FIND v(dout0_135) AT=115.025n

.meas tran vdout0_136ck220 FIND v(dout0_136) AT=115.025n

.meas tran vdout0_137ck220 FIND v(dout0_137) AT=115.025n

.meas tran vdout0_138ck220 FIND v(dout0_138) AT=115.025n

.meas tran vdout0_139ck220 FIND v(dout0_139) AT=115.025n

.meas tran vdout0_140ck220 FIND v(dout0_140) AT=115.025n

.meas tran vdout0_141ck220 FIND v(dout0_141) AT=115.025n

.meas tran vdout0_142ck220 FIND v(dout0_142) AT=115.025n

.meas tran vdout0_143ck220 FIND v(dout0_143) AT=115.025n

.meas tran vdout0_144ck220 FIND v(dout0_144) AT=115.025n

.meas tran vdout0_145ck220 FIND v(dout0_145) AT=115.025n

.meas tran vdout0_146ck220 FIND v(dout0_146) AT=115.025n

.meas tran vdout0_147ck220 FIND v(dout0_147) AT=115.025n

.meas tran vdout0_148ck220 FIND v(dout0_148) AT=115.025n

.meas tran vdout0_149ck220 FIND v(dout0_149) AT=115.025n

.meas tran vdout0_0ck240 FIND v(dout0_0) AT=125.025n

.meas tran vdout0_1ck240 FIND v(dout0_1) AT=125.025n

.meas tran vdout0_2ck240 FIND v(dout0_2) AT=125.025n

.meas tran vdout0_3ck240 FIND v(dout0_3) AT=125.025n

.meas tran vdout0_4ck240 FIND v(dout0_4) AT=125.025n

.meas tran vdout0_5ck240 FIND v(dout0_5) AT=125.025n

.meas tran vdout0_6ck240 FIND v(dout0_6) AT=125.025n

.meas tran vdout0_7ck240 FIND v(dout0_7) AT=125.025n

.meas tran vdout0_8ck240 FIND v(dout0_8) AT=125.025n

.meas tran vdout0_9ck240 FIND v(dout0_9) AT=125.025n

.meas tran vdout0_10ck240 FIND v(dout0_10) AT=125.025n

.meas tran vdout0_11ck240 FIND v(dout0_11) AT=125.025n

.meas tran vdout0_12ck240 FIND v(dout0_12) AT=125.025n

.meas tran vdout0_13ck240 FIND v(dout0_13) AT=125.025n

.meas tran vdout0_14ck240 FIND v(dout0_14) AT=125.025n

.meas tran vdout0_15ck240 FIND v(dout0_15) AT=125.025n

.meas tran vdout0_16ck240 FIND v(dout0_16) AT=125.025n

.meas tran vdout0_17ck240 FIND v(dout0_17) AT=125.025n

.meas tran vdout0_18ck240 FIND v(dout0_18) AT=125.025n

.meas tran vdout0_19ck240 FIND v(dout0_19) AT=125.025n

.meas tran vdout0_20ck240 FIND v(dout0_20) AT=125.025n

.meas tran vdout0_21ck240 FIND v(dout0_21) AT=125.025n

.meas tran vdout0_22ck240 FIND v(dout0_22) AT=125.025n

.meas tran vdout0_23ck240 FIND v(dout0_23) AT=125.025n

.meas tran vdout0_24ck240 FIND v(dout0_24) AT=125.025n

.meas tran vdout0_25ck240 FIND v(dout0_25) AT=125.025n

.meas tran vdout0_26ck240 FIND v(dout0_26) AT=125.025n

.meas tran vdout0_27ck240 FIND v(dout0_27) AT=125.025n

.meas tran vdout0_28ck240 FIND v(dout0_28) AT=125.025n

.meas tran vdout0_29ck240 FIND v(dout0_29) AT=125.025n

.meas tran vdout0_30ck240 FIND v(dout0_30) AT=125.025n

.meas tran vdout0_31ck240 FIND v(dout0_31) AT=125.025n

.meas tran vdout0_32ck240 FIND v(dout0_32) AT=125.025n

.meas tran vdout0_33ck240 FIND v(dout0_33) AT=125.025n

.meas tran vdout0_34ck240 FIND v(dout0_34) AT=125.025n

.meas tran vdout0_35ck240 FIND v(dout0_35) AT=125.025n

.meas tran vdout0_36ck240 FIND v(dout0_36) AT=125.025n

.meas tran vdout0_37ck240 FIND v(dout0_37) AT=125.025n

.meas tran vdout0_38ck240 FIND v(dout0_38) AT=125.025n

.meas tran vdout0_39ck240 FIND v(dout0_39) AT=125.025n

.meas tran vdout0_40ck240 FIND v(dout0_40) AT=125.025n

.meas tran vdout0_41ck240 FIND v(dout0_41) AT=125.025n

.meas tran vdout0_42ck240 FIND v(dout0_42) AT=125.025n

.meas tran vdout0_43ck240 FIND v(dout0_43) AT=125.025n

.meas tran vdout0_44ck240 FIND v(dout0_44) AT=125.025n

.meas tran vdout0_45ck240 FIND v(dout0_45) AT=125.025n

.meas tran vdout0_46ck240 FIND v(dout0_46) AT=125.025n

.meas tran vdout0_47ck240 FIND v(dout0_47) AT=125.025n

.meas tran vdout0_48ck240 FIND v(dout0_48) AT=125.025n

.meas tran vdout0_49ck240 FIND v(dout0_49) AT=125.025n

.meas tran vdout0_50ck240 FIND v(dout0_50) AT=125.025n

.meas tran vdout0_51ck240 FIND v(dout0_51) AT=125.025n

.meas tran vdout0_52ck240 FIND v(dout0_52) AT=125.025n

.meas tran vdout0_53ck240 FIND v(dout0_53) AT=125.025n

.meas tran vdout0_54ck240 FIND v(dout0_54) AT=125.025n

.meas tran vdout0_55ck240 FIND v(dout0_55) AT=125.025n

.meas tran vdout0_56ck240 FIND v(dout0_56) AT=125.025n

.meas tran vdout0_57ck240 FIND v(dout0_57) AT=125.025n

.meas tran vdout0_58ck240 FIND v(dout0_58) AT=125.025n

.meas tran vdout0_59ck240 FIND v(dout0_59) AT=125.025n

.meas tran vdout0_60ck240 FIND v(dout0_60) AT=125.025n

.meas tran vdout0_61ck240 FIND v(dout0_61) AT=125.025n

.meas tran vdout0_62ck240 FIND v(dout0_62) AT=125.025n

.meas tran vdout0_63ck240 FIND v(dout0_63) AT=125.025n

.meas tran vdout0_64ck240 FIND v(dout0_64) AT=125.025n

.meas tran vdout0_65ck240 FIND v(dout0_65) AT=125.025n

.meas tran vdout0_66ck240 FIND v(dout0_66) AT=125.025n

.meas tran vdout0_67ck240 FIND v(dout0_67) AT=125.025n

.meas tran vdout0_68ck240 FIND v(dout0_68) AT=125.025n

.meas tran vdout0_69ck240 FIND v(dout0_69) AT=125.025n

.meas tran vdout0_70ck240 FIND v(dout0_70) AT=125.025n

.meas tran vdout0_71ck240 FIND v(dout0_71) AT=125.025n

.meas tran vdout0_72ck240 FIND v(dout0_72) AT=125.025n

.meas tran vdout0_73ck240 FIND v(dout0_73) AT=125.025n

.meas tran vdout0_74ck240 FIND v(dout0_74) AT=125.025n

.meas tran vdout0_75ck240 FIND v(dout0_75) AT=125.025n

.meas tran vdout0_76ck240 FIND v(dout0_76) AT=125.025n

.meas tran vdout0_77ck240 FIND v(dout0_77) AT=125.025n

.meas tran vdout0_78ck240 FIND v(dout0_78) AT=125.025n

.meas tran vdout0_79ck240 FIND v(dout0_79) AT=125.025n

.meas tran vdout0_80ck240 FIND v(dout0_80) AT=125.025n

.meas tran vdout0_81ck240 FIND v(dout0_81) AT=125.025n

.meas tran vdout0_82ck240 FIND v(dout0_82) AT=125.025n

.meas tran vdout0_83ck240 FIND v(dout0_83) AT=125.025n

.meas tran vdout0_84ck240 FIND v(dout0_84) AT=125.025n

.meas tran vdout0_85ck240 FIND v(dout0_85) AT=125.025n

.meas tran vdout0_86ck240 FIND v(dout0_86) AT=125.025n

.meas tran vdout0_87ck240 FIND v(dout0_87) AT=125.025n

.meas tran vdout0_88ck240 FIND v(dout0_88) AT=125.025n

.meas tran vdout0_89ck240 FIND v(dout0_89) AT=125.025n

.meas tran vdout0_90ck240 FIND v(dout0_90) AT=125.025n

.meas tran vdout0_91ck240 FIND v(dout0_91) AT=125.025n

.meas tran vdout0_92ck240 FIND v(dout0_92) AT=125.025n

.meas tran vdout0_93ck240 FIND v(dout0_93) AT=125.025n

.meas tran vdout0_94ck240 FIND v(dout0_94) AT=125.025n

.meas tran vdout0_95ck240 FIND v(dout0_95) AT=125.025n

.meas tran vdout0_96ck240 FIND v(dout0_96) AT=125.025n

.meas tran vdout0_97ck240 FIND v(dout0_97) AT=125.025n

.meas tran vdout0_98ck240 FIND v(dout0_98) AT=125.025n

.meas tran vdout0_99ck240 FIND v(dout0_99) AT=125.025n

.meas tran vdout0_100ck240 FIND v(dout0_100) AT=125.025n

.meas tran vdout0_101ck240 FIND v(dout0_101) AT=125.025n

.meas tran vdout0_102ck240 FIND v(dout0_102) AT=125.025n

.meas tran vdout0_103ck240 FIND v(dout0_103) AT=125.025n

.meas tran vdout0_104ck240 FIND v(dout0_104) AT=125.025n

.meas tran vdout0_105ck240 FIND v(dout0_105) AT=125.025n

.meas tran vdout0_106ck240 FIND v(dout0_106) AT=125.025n

.meas tran vdout0_107ck240 FIND v(dout0_107) AT=125.025n

.meas tran vdout0_108ck240 FIND v(dout0_108) AT=125.025n

.meas tran vdout0_109ck240 FIND v(dout0_109) AT=125.025n

.meas tran vdout0_110ck240 FIND v(dout0_110) AT=125.025n

.meas tran vdout0_111ck240 FIND v(dout0_111) AT=125.025n

.meas tran vdout0_112ck240 FIND v(dout0_112) AT=125.025n

.meas tran vdout0_113ck240 FIND v(dout0_113) AT=125.025n

.meas tran vdout0_114ck240 FIND v(dout0_114) AT=125.025n

.meas tran vdout0_115ck240 FIND v(dout0_115) AT=125.025n

.meas tran vdout0_116ck240 FIND v(dout0_116) AT=125.025n

.meas tran vdout0_117ck240 FIND v(dout0_117) AT=125.025n

.meas tran vdout0_118ck240 FIND v(dout0_118) AT=125.025n

.meas tran vdout0_119ck240 FIND v(dout0_119) AT=125.025n

.meas tran vdout0_120ck240 FIND v(dout0_120) AT=125.025n

.meas tran vdout0_121ck240 FIND v(dout0_121) AT=125.025n

.meas tran vdout0_122ck240 FIND v(dout0_122) AT=125.025n

.meas tran vdout0_123ck240 FIND v(dout0_123) AT=125.025n

.meas tran vdout0_124ck240 FIND v(dout0_124) AT=125.025n

.meas tran vdout0_125ck240 FIND v(dout0_125) AT=125.025n

.meas tran vdout0_126ck240 FIND v(dout0_126) AT=125.025n

.meas tran vdout0_127ck240 FIND v(dout0_127) AT=125.025n

.meas tran vdout0_128ck240 FIND v(dout0_128) AT=125.025n

.meas tran vdout0_129ck240 FIND v(dout0_129) AT=125.025n

.meas tran vdout0_130ck240 FIND v(dout0_130) AT=125.025n

.meas tran vdout0_131ck240 FIND v(dout0_131) AT=125.025n

.meas tran vdout0_132ck240 FIND v(dout0_132) AT=125.025n

.meas tran vdout0_133ck240 FIND v(dout0_133) AT=125.025n

.meas tran vdout0_134ck240 FIND v(dout0_134) AT=125.025n

.meas tran vdout0_135ck240 FIND v(dout0_135) AT=125.025n

.meas tran vdout0_136ck240 FIND v(dout0_136) AT=125.025n

.meas tran vdout0_137ck240 FIND v(dout0_137) AT=125.025n

.meas tran vdout0_138ck240 FIND v(dout0_138) AT=125.025n

.meas tran vdout0_139ck240 FIND v(dout0_139) AT=125.025n

.meas tran vdout0_140ck240 FIND v(dout0_140) AT=125.025n

.meas tran vdout0_141ck240 FIND v(dout0_141) AT=125.025n

.meas tran vdout0_142ck240 FIND v(dout0_142) AT=125.025n

.meas tran vdout0_143ck240 FIND v(dout0_143) AT=125.025n

.meas tran vdout0_144ck240 FIND v(dout0_144) AT=125.025n

.meas tran vdout0_145ck240 FIND v(dout0_145) AT=125.025n

.meas tran vdout0_146ck240 FIND v(dout0_146) AT=125.025n

.meas tran vdout0_147ck240 FIND v(dout0_147) AT=125.025n

.meas tran vdout0_148ck240 FIND v(dout0_148) AT=125.025n

.meas tran vdout0_149ck240 FIND v(dout0_149) AT=125.025n

.meas tran vdout0_0ck250 FIND v(dout0_0) AT=130.025n

.meas tran vdout0_1ck250 FIND v(dout0_1) AT=130.025n

.meas tran vdout0_2ck250 FIND v(dout0_2) AT=130.025n

.meas tran vdout0_3ck250 FIND v(dout0_3) AT=130.025n

.meas tran vdout0_4ck250 FIND v(dout0_4) AT=130.025n

.meas tran vdout0_5ck250 FIND v(dout0_5) AT=130.025n

.meas tran vdout0_6ck250 FIND v(dout0_6) AT=130.025n

.meas tran vdout0_7ck250 FIND v(dout0_7) AT=130.025n

.meas tran vdout0_8ck250 FIND v(dout0_8) AT=130.025n

.meas tran vdout0_9ck250 FIND v(dout0_9) AT=130.025n

.meas tran vdout0_10ck250 FIND v(dout0_10) AT=130.025n

.meas tran vdout0_11ck250 FIND v(dout0_11) AT=130.025n

.meas tran vdout0_12ck250 FIND v(dout0_12) AT=130.025n

.meas tran vdout0_13ck250 FIND v(dout0_13) AT=130.025n

.meas tran vdout0_14ck250 FIND v(dout0_14) AT=130.025n

.meas tran vdout0_15ck250 FIND v(dout0_15) AT=130.025n

.meas tran vdout0_16ck250 FIND v(dout0_16) AT=130.025n

.meas tran vdout0_17ck250 FIND v(dout0_17) AT=130.025n

.meas tran vdout0_18ck250 FIND v(dout0_18) AT=130.025n

.meas tran vdout0_19ck250 FIND v(dout0_19) AT=130.025n

.meas tran vdout0_20ck250 FIND v(dout0_20) AT=130.025n

.meas tran vdout0_21ck250 FIND v(dout0_21) AT=130.025n

.meas tran vdout0_22ck250 FIND v(dout0_22) AT=130.025n

.meas tran vdout0_23ck250 FIND v(dout0_23) AT=130.025n

.meas tran vdout0_24ck250 FIND v(dout0_24) AT=130.025n

.meas tran vdout0_25ck250 FIND v(dout0_25) AT=130.025n

.meas tran vdout0_26ck250 FIND v(dout0_26) AT=130.025n

.meas tran vdout0_27ck250 FIND v(dout0_27) AT=130.025n

.meas tran vdout0_28ck250 FIND v(dout0_28) AT=130.025n

.meas tran vdout0_29ck250 FIND v(dout0_29) AT=130.025n

.meas tran vdout0_30ck250 FIND v(dout0_30) AT=130.025n

.meas tran vdout0_31ck250 FIND v(dout0_31) AT=130.025n

.meas tran vdout0_32ck250 FIND v(dout0_32) AT=130.025n

.meas tran vdout0_33ck250 FIND v(dout0_33) AT=130.025n

.meas tran vdout0_34ck250 FIND v(dout0_34) AT=130.025n

.meas tran vdout0_35ck250 FIND v(dout0_35) AT=130.025n

.meas tran vdout0_36ck250 FIND v(dout0_36) AT=130.025n

.meas tran vdout0_37ck250 FIND v(dout0_37) AT=130.025n

.meas tran vdout0_38ck250 FIND v(dout0_38) AT=130.025n

.meas tran vdout0_39ck250 FIND v(dout0_39) AT=130.025n

.meas tran vdout0_40ck250 FIND v(dout0_40) AT=130.025n

.meas tran vdout0_41ck250 FIND v(dout0_41) AT=130.025n

.meas tran vdout0_42ck250 FIND v(dout0_42) AT=130.025n

.meas tran vdout0_43ck250 FIND v(dout0_43) AT=130.025n

.meas tran vdout0_44ck250 FIND v(dout0_44) AT=130.025n

.meas tran vdout0_45ck250 FIND v(dout0_45) AT=130.025n

.meas tran vdout0_46ck250 FIND v(dout0_46) AT=130.025n

.meas tran vdout0_47ck250 FIND v(dout0_47) AT=130.025n

.meas tran vdout0_48ck250 FIND v(dout0_48) AT=130.025n

.meas tran vdout0_49ck250 FIND v(dout0_49) AT=130.025n

.meas tran vdout0_50ck250 FIND v(dout0_50) AT=130.025n

.meas tran vdout0_51ck250 FIND v(dout0_51) AT=130.025n

.meas tran vdout0_52ck250 FIND v(dout0_52) AT=130.025n

.meas tran vdout0_53ck250 FIND v(dout0_53) AT=130.025n

.meas tran vdout0_54ck250 FIND v(dout0_54) AT=130.025n

.meas tran vdout0_55ck250 FIND v(dout0_55) AT=130.025n

.meas tran vdout0_56ck250 FIND v(dout0_56) AT=130.025n

.meas tran vdout0_57ck250 FIND v(dout0_57) AT=130.025n

.meas tran vdout0_58ck250 FIND v(dout0_58) AT=130.025n

.meas tran vdout0_59ck250 FIND v(dout0_59) AT=130.025n

.meas tran vdout0_60ck250 FIND v(dout0_60) AT=130.025n

.meas tran vdout0_61ck250 FIND v(dout0_61) AT=130.025n

.meas tran vdout0_62ck250 FIND v(dout0_62) AT=130.025n

.meas tran vdout0_63ck250 FIND v(dout0_63) AT=130.025n

.meas tran vdout0_64ck250 FIND v(dout0_64) AT=130.025n

.meas tran vdout0_65ck250 FIND v(dout0_65) AT=130.025n

.meas tran vdout0_66ck250 FIND v(dout0_66) AT=130.025n

.meas tran vdout0_67ck250 FIND v(dout0_67) AT=130.025n

.meas tran vdout0_68ck250 FIND v(dout0_68) AT=130.025n

.meas tran vdout0_69ck250 FIND v(dout0_69) AT=130.025n

.meas tran vdout0_70ck250 FIND v(dout0_70) AT=130.025n

.meas tran vdout0_71ck250 FIND v(dout0_71) AT=130.025n

.meas tran vdout0_72ck250 FIND v(dout0_72) AT=130.025n

.meas tran vdout0_73ck250 FIND v(dout0_73) AT=130.025n

.meas tran vdout0_74ck250 FIND v(dout0_74) AT=130.025n

.meas tran vdout0_75ck250 FIND v(dout0_75) AT=130.025n

.meas tran vdout0_76ck250 FIND v(dout0_76) AT=130.025n

.meas tran vdout0_77ck250 FIND v(dout0_77) AT=130.025n

.meas tran vdout0_78ck250 FIND v(dout0_78) AT=130.025n

.meas tran vdout0_79ck250 FIND v(dout0_79) AT=130.025n

.meas tran vdout0_80ck250 FIND v(dout0_80) AT=130.025n

.meas tran vdout0_81ck250 FIND v(dout0_81) AT=130.025n

.meas tran vdout0_82ck250 FIND v(dout0_82) AT=130.025n

.meas tran vdout0_83ck250 FIND v(dout0_83) AT=130.025n

.meas tran vdout0_84ck250 FIND v(dout0_84) AT=130.025n

.meas tran vdout0_85ck250 FIND v(dout0_85) AT=130.025n

.meas tran vdout0_86ck250 FIND v(dout0_86) AT=130.025n

.meas tran vdout0_87ck250 FIND v(dout0_87) AT=130.025n

.meas tran vdout0_88ck250 FIND v(dout0_88) AT=130.025n

.meas tran vdout0_89ck250 FIND v(dout0_89) AT=130.025n

.meas tran vdout0_90ck250 FIND v(dout0_90) AT=130.025n

.meas tran vdout0_91ck250 FIND v(dout0_91) AT=130.025n

.meas tran vdout0_92ck250 FIND v(dout0_92) AT=130.025n

.meas tran vdout0_93ck250 FIND v(dout0_93) AT=130.025n

.meas tran vdout0_94ck250 FIND v(dout0_94) AT=130.025n

.meas tran vdout0_95ck250 FIND v(dout0_95) AT=130.025n

.meas tran vdout0_96ck250 FIND v(dout0_96) AT=130.025n

.meas tran vdout0_97ck250 FIND v(dout0_97) AT=130.025n

.meas tran vdout0_98ck250 FIND v(dout0_98) AT=130.025n

.meas tran vdout0_99ck250 FIND v(dout0_99) AT=130.025n

.meas tran vdout0_100ck250 FIND v(dout0_100) AT=130.025n

.meas tran vdout0_101ck250 FIND v(dout0_101) AT=130.025n

.meas tran vdout0_102ck250 FIND v(dout0_102) AT=130.025n

.meas tran vdout0_103ck250 FIND v(dout0_103) AT=130.025n

.meas tran vdout0_104ck250 FIND v(dout0_104) AT=130.025n

.meas tran vdout0_105ck250 FIND v(dout0_105) AT=130.025n

.meas tran vdout0_106ck250 FIND v(dout0_106) AT=130.025n

.meas tran vdout0_107ck250 FIND v(dout0_107) AT=130.025n

.meas tran vdout0_108ck250 FIND v(dout0_108) AT=130.025n

.meas tran vdout0_109ck250 FIND v(dout0_109) AT=130.025n

.meas tran vdout0_110ck250 FIND v(dout0_110) AT=130.025n

.meas tran vdout0_111ck250 FIND v(dout0_111) AT=130.025n

.meas tran vdout0_112ck250 FIND v(dout0_112) AT=130.025n

.meas tran vdout0_113ck250 FIND v(dout0_113) AT=130.025n

.meas tran vdout0_114ck250 FIND v(dout0_114) AT=130.025n

.meas tran vdout0_115ck250 FIND v(dout0_115) AT=130.025n

.meas tran vdout0_116ck250 FIND v(dout0_116) AT=130.025n

.meas tran vdout0_117ck250 FIND v(dout0_117) AT=130.025n

.meas tran vdout0_118ck250 FIND v(dout0_118) AT=130.025n

.meas tran vdout0_119ck250 FIND v(dout0_119) AT=130.025n

.meas tran vdout0_120ck250 FIND v(dout0_120) AT=130.025n

.meas tran vdout0_121ck250 FIND v(dout0_121) AT=130.025n

.meas tran vdout0_122ck250 FIND v(dout0_122) AT=130.025n

.meas tran vdout0_123ck250 FIND v(dout0_123) AT=130.025n

.meas tran vdout0_124ck250 FIND v(dout0_124) AT=130.025n

.meas tran vdout0_125ck250 FIND v(dout0_125) AT=130.025n

.meas tran vdout0_126ck250 FIND v(dout0_126) AT=130.025n

.meas tran vdout0_127ck250 FIND v(dout0_127) AT=130.025n

.meas tran vdout0_128ck250 FIND v(dout0_128) AT=130.025n

.meas tran vdout0_129ck250 FIND v(dout0_129) AT=130.025n

.meas tran vdout0_130ck250 FIND v(dout0_130) AT=130.025n

.meas tran vdout0_131ck250 FIND v(dout0_131) AT=130.025n

.meas tran vdout0_132ck250 FIND v(dout0_132) AT=130.025n

.meas tran vdout0_133ck250 FIND v(dout0_133) AT=130.025n

.meas tran vdout0_134ck250 FIND v(dout0_134) AT=130.025n

.meas tran vdout0_135ck250 FIND v(dout0_135) AT=130.025n

.meas tran vdout0_136ck250 FIND v(dout0_136) AT=130.025n

.meas tran vdout0_137ck250 FIND v(dout0_137) AT=130.025n

.meas tran vdout0_138ck250 FIND v(dout0_138) AT=130.025n

.meas tran vdout0_139ck250 FIND v(dout0_139) AT=130.025n

.meas tran vdout0_140ck250 FIND v(dout0_140) AT=130.025n

.meas tran vdout0_141ck250 FIND v(dout0_141) AT=130.025n

.meas tran vdout0_142ck250 FIND v(dout0_142) AT=130.025n

.meas tran vdout0_143ck250 FIND v(dout0_143) AT=130.025n

.meas tran vdout0_144ck250 FIND v(dout0_144) AT=130.025n

.meas tran vdout0_145ck250 FIND v(dout0_145) AT=130.025n

.meas tran vdout0_146ck250 FIND v(dout0_146) AT=130.025n

.meas tran vdout0_147ck250 FIND v(dout0_147) AT=130.025n

.meas tran vdout0_148ck250 FIND v(dout0_148) AT=130.025n

.meas tran vdout0_149ck250 FIND v(dout0_149) AT=130.025n

.meas tran vdout0_0ck260 FIND v(dout0_0) AT=135.025n

.meas tran vdout0_1ck260 FIND v(dout0_1) AT=135.025n

.meas tran vdout0_2ck260 FIND v(dout0_2) AT=135.025n

.meas tran vdout0_3ck260 FIND v(dout0_3) AT=135.025n

.meas tran vdout0_4ck260 FIND v(dout0_4) AT=135.025n

.meas tran vdout0_5ck260 FIND v(dout0_5) AT=135.025n

.meas tran vdout0_6ck260 FIND v(dout0_6) AT=135.025n

.meas tran vdout0_7ck260 FIND v(dout0_7) AT=135.025n

.meas tran vdout0_8ck260 FIND v(dout0_8) AT=135.025n

.meas tran vdout0_9ck260 FIND v(dout0_9) AT=135.025n

.meas tran vdout0_10ck260 FIND v(dout0_10) AT=135.025n

.meas tran vdout0_11ck260 FIND v(dout0_11) AT=135.025n

.meas tran vdout0_12ck260 FIND v(dout0_12) AT=135.025n

.meas tran vdout0_13ck260 FIND v(dout0_13) AT=135.025n

.meas tran vdout0_14ck260 FIND v(dout0_14) AT=135.025n

.meas tran vdout0_15ck260 FIND v(dout0_15) AT=135.025n

.meas tran vdout0_16ck260 FIND v(dout0_16) AT=135.025n

.meas tran vdout0_17ck260 FIND v(dout0_17) AT=135.025n

.meas tran vdout0_18ck260 FIND v(dout0_18) AT=135.025n

.meas tran vdout0_19ck260 FIND v(dout0_19) AT=135.025n

.meas tran vdout0_20ck260 FIND v(dout0_20) AT=135.025n

.meas tran vdout0_21ck260 FIND v(dout0_21) AT=135.025n

.meas tran vdout0_22ck260 FIND v(dout0_22) AT=135.025n

.meas tran vdout0_23ck260 FIND v(dout0_23) AT=135.025n

.meas tran vdout0_24ck260 FIND v(dout0_24) AT=135.025n

.meas tran vdout0_25ck260 FIND v(dout0_25) AT=135.025n

.meas tran vdout0_26ck260 FIND v(dout0_26) AT=135.025n

.meas tran vdout0_27ck260 FIND v(dout0_27) AT=135.025n

.meas tran vdout0_28ck260 FIND v(dout0_28) AT=135.025n

.meas tran vdout0_29ck260 FIND v(dout0_29) AT=135.025n

.meas tran vdout0_30ck260 FIND v(dout0_30) AT=135.025n

.meas tran vdout0_31ck260 FIND v(dout0_31) AT=135.025n

.meas tran vdout0_32ck260 FIND v(dout0_32) AT=135.025n

.meas tran vdout0_33ck260 FIND v(dout0_33) AT=135.025n

.meas tran vdout0_34ck260 FIND v(dout0_34) AT=135.025n

.meas tran vdout0_35ck260 FIND v(dout0_35) AT=135.025n

.meas tran vdout0_36ck260 FIND v(dout0_36) AT=135.025n

.meas tran vdout0_37ck260 FIND v(dout0_37) AT=135.025n

.meas tran vdout0_38ck260 FIND v(dout0_38) AT=135.025n

.meas tran vdout0_39ck260 FIND v(dout0_39) AT=135.025n

.meas tran vdout0_40ck260 FIND v(dout0_40) AT=135.025n

.meas tran vdout0_41ck260 FIND v(dout0_41) AT=135.025n

.meas tran vdout0_42ck260 FIND v(dout0_42) AT=135.025n

.meas tran vdout0_43ck260 FIND v(dout0_43) AT=135.025n

.meas tran vdout0_44ck260 FIND v(dout0_44) AT=135.025n

.meas tran vdout0_45ck260 FIND v(dout0_45) AT=135.025n

.meas tran vdout0_46ck260 FIND v(dout0_46) AT=135.025n

.meas tran vdout0_47ck260 FIND v(dout0_47) AT=135.025n

.meas tran vdout0_48ck260 FIND v(dout0_48) AT=135.025n

.meas tran vdout0_49ck260 FIND v(dout0_49) AT=135.025n

.meas tran vdout0_50ck260 FIND v(dout0_50) AT=135.025n

.meas tran vdout0_51ck260 FIND v(dout0_51) AT=135.025n

.meas tran vdout0_52ck260 FIND v(dout0_52) AT=135.025n

.meas tran vdout0_53ck260 FIND v(dout0_53) AT=135.025n

.meas tran vdout0_54ck260 FIND v(dout0_54) AT=135.025n

.meas tran vdout0_55ck260 FIND v(dout0_55) AT=135.025n

.meas tran vdout0_56ck260 FIND v(dout0_56) AT=135.025n

.meas tran vdout0_57ck260 FIND v(dout0_57) AT=135.025n

.meas tran vdout0_58ck260 FIND v(dout0_58) AT=135.025n

.meas tran vdout0_59ck260 FIND v(dout0_59) AT=135.025n

.meas tran vdout0_60ck260 FIND v(dout0_60) AT=135.025n

.meas tran vdout0_61ck260 FIND v(dout0_61) AT=135.025n

.meas tran vdout0_62ck260 FIND v(dout0_62) AT=135.025n

.meas tran vdout0_63ck260 FIND v(dout0_63) AT=135.025n

.meas tran vdout0_64ck260 FIND v(dout0_64) AT=135.025n

.meas tran vdout0_65ck260 FIND v(dout0_65) AT=135.025n

.meas tran vdout0_66ck260 FIND v(dout0_66) AT=135.025n

.meas tran vdout0_67ck260 FIND v(dout0_67) AT=135.025n

.meas tran vdout0_68ck260 FIND v(dout0_68) AT=135.025n

.meas tran vdout0_69ck260 FIND v(dout0_69) AT=135.025n

.meas tran vdout0_70ck260 FIND v(dout0_70) AT=135.025n

.meas tran vdout0_71ck260 FIND v(dout0_71) AT=135.025n

.meas tran vdout0_72ck260 FIND v(dout0_72) AT=135.025n

.meas tran vdout0_73ck260 FIND v(dout0_73) AT=135.025n

.meas tran vdout0_74ck260 FIND v(dout0_74) AT=135.025n

.meas tran vdout0_75ck260 FIND v(dout0_75) AT=135.025n

.meas tran vdout0_76ck260 FIND v(dout0_76) AT=135.025n

.meas tran vdout0_77ck260 FIND v(dout0_77) AT=135.025n

.meas tran vdout0_78ck260 FIND v(dout0_78) AT=135.025n

.meas tran vdout0_79ck260 FIND v(dout0_79) AT=135.025n

.meas tran vdout0_80ck260 FIND v(dout0_80) AT=135.025n

.meas tran vdout0_81ck260 FIND v(dout0_81) AT=135.025n

.meas tran vdout0_82ck260 FIND v(dout0_82) AT=135.025n

.meas tran vdout0_83ck260 FIND v(dout0_83) AT=135.025n

.meas tran vdout0_84ck260 FIND v(dout0_84) AT=135.025n

.meas tran vdout0_85ck260 FIND v(dout0_85) AT=135.025n

.meas tran vdout0_86ck260 FIND v(dout0_86) AT=135.025n

.meas tran vdout0_87ck260 FIND v(dout0_87) AT=135.025n

.meas tran vdout0_88ck260 FIND v(dout0_88) AT=135.025n

.meas tran vdout0_89ck260 FIND v(dout0_89) AT=135.025n

.meas tran vdout0_90ck260 FIND v(dout0_90) AT=135.025n

.meas tran vdout0_91ck260 FIND v(dout0_91) AT=135.025n

.meas tran vdout0_92ck260 FIND v(dout0_92) AT=135.025n

.meas tran vdout0_93ck260 FIND v(dout0_93) AT=135.025n

.meas tran vdout0_94ck260 FIND v(dout0_94) AT=135.025n

.meas tran vdout0_95ck260 FIND v(dout0_95) AT=135.025n

.meas tran vdout0_96ck260 FIND v(dout0_96) AT=135.025n

.meas tran vdout0_97ck260 FIND v(dout0_97) AT=135.025n

.meas tran vdout0_98ck260 FIND v(dout0_98) AT=135.025n

.meas tran vdout0_99ck260 FIND v(dout0_99) AT=135.025n

.meas tran vdout0_100ck260 FIND v(dout0_100) AT=135.025n

.meas tran vdout0_101ck260 FIND v(dout0_101) AT=135.025n

.meas tran vdout0_102ck260 FIND v(dout0_102) AT=135.025n

.meas tran vdout0_103ck260 FIND v(dout0_103) AT=135.025n

.meas tran vdout0_104ck260 FIND v(dout0_104) AT=135.025n

.meas tran vdout0_105ck260 FIND v(dout0_105) AT=135.025n

.meas tran vdout0_106ck260 FIND v(dout0_106) AT=135.025n

.meas tran vdout0_107ck260 FIND v(dout0_107) AT=135.025n

.meas tran vdout0_108ck260 FIND v(dout0_108) AT=135.025n

.meas tran vdout0_109ck260 FIND v(dout0_109) AT=135.025n

.meas tran vdout0_110ck260 FIND v(dout0_110) AT=135.025n

.meas tran vdout0_111ck260 FIND v(dout0_111) AT=135.025n

.meas tran vdout0_112ck260 FIND v(dout0_112) AT=135.025n

.meas tran vdout0_113ck260 FIND v(dout0_113) AT=135.025n

.meas tran vdout0_114ck260 FIND v(dout0_114) AT=135.025n

.meas tran vdout0_115ck260 FIND v(dout0_115) AT=135.025n

.meas tran vdout0_116ck260 FIND v(dout0_116) AT=135.025n

.meas tran vdout0_117ck260 FIND v(dout0_117) AT=135.025n

.meas tran vdout0_118ck260 FIND v(dout0_118) AT=135.025n

.meas tran vdout0_119ck260 FIND v(dout0_119) AT=135.025n

.meas tran vdout0_120ck260 FIND v(dout0_120) AT=135.025n

.meas tran vdout0_121ck260 FIND v(dout0_121) AT=135.025n

.meas tran vdout0_122ck260 FIND v(dout0_122) AT=135.025n

.meas tran vdout0_123ck260 FIND v(dout0_123) AT=135.025n

.meas tran vdout0_124ck260 FIND v(dout0_124) AT=135.025n

.meas tran vdout0_125ck260 FIND v(dout0_125) AT=135.025n

.meas tran vdout0_126ck260 FIND v(dout0_126) AT=135.025n

.meas tran vdout0_127ck260 FIND v(dout0_127) AT=135.025n

.meas tran vdout0_128ck260 FIND v(dout0_128) AT=135.025n

.meas tran vdout0_129ck260 FIND v(dout0_129) AT=135.025n

.meas tran vdout0_130ck260 FIND v(dout0_130) AT=135.025n

.meas tran vdout0_131ck260 FIND v(dout0_131) AT=135.025n

.meas tran vdout0_132ck260 FIND v(dout0_132) AT=135.025n

.meas tran vdout0_133ck260 FIND v(dout0_133) AT=135.025n

.meas tran vdout0_134ck260 FIND v(dout0_134) AT=135.025n

.meas tran vdout0_135ck260 FIND v(dout0_135) AT=135.025n

.meas tran vdout0_136ck260 FIND v(dout0_136) AT=135.025n

.meas tran vdout0_137ck260 FIND v(dout0_137) AT=135.025n

.meas tran vdout0_138ck260 FIND v(dout0_138) AT=135.025n

.meas tran vdout0_139ck260 FIND v(dout0_139) AT=135.025n

.meas tran vdout0_140ck260 FIND v(dout0_140) AT=135.025n

.meas tran vdout0_141ck260 FIND v(dout0_141) AT=135.025n

.meas tran vdout0_142ck260 FIND v(dout0_142) AT=135.025n

.meas tran vdout0_143ck260 FIND v(dout0_143) AT=135.025n

.meas tran vdout0_144ck260 FIND v(dout0_144) AT=135.025n

.meas tran vdout0_145ck260 FIND v(dout0_145) AT=135.025n

.meas tran vdout0_146ck260 FIND v(dout0_146) AT=135.025n

.meas tran vdout0_147ck260 FIND v(dout0_147) AT=135.025n

.meas tran vdout0_148ck260 FIND v(dout0_148) AT=135.025n

.meas tran vdout0_149ck260 FIND v(dout0_149) AT=135.025n

.meas tran vdout0_0ck280 FIND v(dout0_0) AT=145.025n

.meas tran vdout0_1ck280 FIND v(dout0_1) AT=145.025n

.meas tran vdout0_2ck280 FIND v(dout0_2) AT=145.025n

.meas tran vdout0_3ck280 FIND v(dout0_3) AT=145.025n

.meas tran vdout0_4ck280 FIND v(dout0_4) AT=145.025n

.meas tran vdout0_5ck280 FIND v(dout0_5) AT=145.025n

.meas tran vdout0_6ck280 FIND v(dout0_6) AT=145.025n

.meas tran vdout0_7ck280 FIND v(dout0_7) AT=145.025n

.meas tran vdout0_8ck280 FIND v(dout0_8) AT=145.025n

.meas tran vdout0_9ck280 FIND v(dout0_9) AT=145.025n

.meas tran vdout0_10ck280 FIND v(dout0_10) AT=145.025n

.meas tran vdout0_11ck280 FIND v(dout0_11) AT=145.025n

.meas tran vdout0_12ck280 FIND v(dout0_12) AT=145.025n

.meas tran vdout0_13ck280 FIND v(dout0_13) AT=145.025n

.meas tran vdout0_14ck280 FIND v(dout0_14) AT=145.025n

.meas tran vdout0_15ck280 FIND v(dout0_15) AT=145.025n

.meas tran vdout0_16ck280 FIND v(dout0_16) AT=145.025n

.meas tran vdout0_17ck280 FIND v(dout0_17) AT=145.025n

.meas tran vdout0_18ck280 FIND v(dout0_18) AT=145.025n

.meas tran vdout0_19ck280 FIND v(dout0_19) AT=145.025n

.meas tran vdout0_20ck280 FIND v(dout0_20) AT=145.025n

.meas tran vdout0_21ck280 FIND v(dout0_21) AT=145.025n

.meas tran vdout0_22ck280 FIND v(dout0_22) AT=145.025n

.meas tran vdout0_23ck280 FIND v(dout0_23) AT=145.025n

.meas tran vdout0_24ck280 FIND v(dout0_24) AT=145.025n

.meas tran vdout0_25ck280 FIND v(dout0_25) AT=145.025n

.meas tran vdout0_26ck280 FIND v(dout0_26) AT=145.025n

.meas tran vdout0_27ck280 FIND v(dout0_27) AT=145.025n

.meas tran vdout0_28ck280 FIND v(dout0_28) AT=145.025n

.meas tran vdout0_29ck280 FIND v(dout0_29) AT=145.025n

.meas tran vdout0_30ck280 FIND v(dout0_30) AT=145.025n

.meas tran vdout0_31ck280 FIND v(dout0_31) AT=145.025n

.meas tran vdout0_32ck280 FIND v(dout0_32) AT=145.025n

.meas tran vdout0_33ck280 FIND v(dout0_33) AT=145.025n

.meas tran vdout0_34ck280 FIND v(dout0_34) AT=145.025n

.meas tran vdout0_35ck280 FIND v(dout0_35) AT=145.025n

.meas tran vdout0_36ck280 FIND v(dout0_36) AT=145.025n

.meas tran vdout0_37ck280 FIND v(dout0_37) AT=145.025n

.meas tran vdout0_38ck280 FIND v(dout0_38) AT=145.025n

.meas tran vdout0_39ck280 FIND v(dout0_39) AT=145.025n

.meas tran vdout0_40ck280 FIND v(dout0_40) AT=145.025n

.meas tran vdout0_41ck280 FIND v(dout0_41) AT=145.025n

.meas tran vdout0_42ck280 FIND v(dout0_42) AT=145.025n

.meas tran vdout0_43ck280 FIND v(dout0_43) AT=145.025n

.meas tran vdout0_44ck280 FIND v(dout0_44) AT=145.025n

.meas tran vdout0_45ck280 FIND v(dout0_45) AT=145.025n

.meas tran vdout0_46ck280 FIND v(dout0_46) AT=145.025n

.meas tran vdout0_47ck280 FIND v(dout0_47) AT=145.025n

.meas tran vdout0_48ck280 FIND v(dout0_48) AT=145.025n

.meas tran vdout0_49ck280 FIND v(dout0_49) AT=145.025n

.meas tran vdout0_50ck280 FIND v(dout0_50) AT=145.025n

.meas tran vdout0_51ck280 FIND v(dout0_51) AT=145.025n

.meas tran vdout0_52ck280 FIND v(dout0_52) AT=145.025n

.meas tran vdout0_53ck280 FIND v(dout0_53) AT=145.025n

.meas tran vdout0_54ck280 FIND v(dout0_54) AT=145.025n

.meas tran vdout0_55ck280 FIND v(dout0_55) AT=145.025n

.meas tran vdout0_56ck280 FIND v(dout0_56) AT=145.025n

.meas tran vdout0_57ck280 FIND v(dout0_57) AT=145.025n

.meas tran vdout0_58ck280 FIND v(dout0_58) AT=145.025n

.meas tran vdout0_59ck280 FIND v(dout0_59) AT=145.025n

.meas tran vdout0_60ck280 FIND v(dout0_60) AT=145.025n

.meas tran vdout0_61ck280 FIND v(dout0_61) AT=145.025n

.meas tran vdout0_62ck280 FIND v(dout0_62) AT=145.025n

.meas tran vdout0_63ck280 FIND v(dout0_63) AT=145.025n

.meas tran vdout0_64ck280 FIND v(dout0_64) AT=145.025n

.meas tran vdout0_65ck280 FIND v(dout0_65) AT=145.025n

.meas tran vdout0_66ck280 FIND v(dout0_66) AT=145.025n

.meas tran vdout0_67ck280 FIND v(dout0_67) AT=145.025n

.meas tran vdout0_68ck280 FIND v(dout0_68) AT=145.025n

.meas tran vdout0_69ck280 FIND v(dout0_69) AT=145.025n

.meas tran vdout0_70ck280 FIND v(dout0_70) AT=145.025n

.meas tran vdout0_71ck280 FIND v(dout0_71) AT=145.025n

.meas tran vdout0_72ck280 FIND v(dout0_72) AT=145.025n

.meas tran vdout0_73ck280 FIND v(dout0_73) AT=145.025n

.meas tran vdout0_74ck280 FIND v(dout0_74) AT=145.025n

.meas tran vdout0_75ck280 FIND v(dout0_75) AT=145.025n

.meas tran vdout0_76ck280 FIND v(dout0_76) AT=145.025n

.meas tran vdout0_77ck280 FIND v(dout0_77) AT=145.025n

.meas tran vdout0_78ck280 FIND v(dout0_78) AT=145.025n

.meas tran vdout0_79ck280 FIND v(dout0_79) AT=145.025n

.meas tran vdout0_80ck280 FIND v(dout0_80) AT=145.025n

.meas tran vdout0_81ck280 FIND v(dout0_81) AT=145.025n

.meas tran vdout0_82ck280 FIND v(dout0_82) AT=145.025n

.meas tran vdout0_83ck280 FIND v(dout0_83) AT=145.025n

.meas tran vdout0_84ck280 FIND v(dout0_84) AT=145.025n

.meas tran vdout0_85ck280 FIND v(dout0_85) AT=145.025n

.meas tran vdout0_86ck280 FIND v(dout0_86) AT=145.025n

.meas tran vdout0_87ck280 FIND v(dout0_87) AT=145.025n

.meas tran vdout0_88ck280 FIND v(dout0_88) AT=145.025n

.meas tran vdout0_89ck280 FIND v(dout0_89) AT=145.025n

.meas tran vdout0_90ck280 FIND v(dout0_90) AT=145.025n

.meas tran vdout0_91ck280 FIND v(dout0_91) AT=145.025n

.meas tran vdout0_92ck280 FIND v(dout0_92) AT=145.025n

.meas tran vdout0_93ck280 FIND v(dout0_93) AT=145.025n

.meas tran vdout0_94ck280 FIND v(dout0_94) AT=145.025n

.meas tran vdout0_95ck280 FIND v(dout0_95) AT=145.025n

.meas tran vdout0_96ck280 FIND v(dout0_96) AT=145.025n

.meas tran vdout0_97ck280 FIND v(dout0_97) AT=145.025n

.meas tran vdout0_98ck280 FIND v(dout0_98) AT=145.025n

.meas tran vdout0_99ck280 FIND v(dout0_99) AT=145.025n

.meas tran vdout0_100ck280 FIND v(dout0_100) AT=145.025n

.meas tran vdout0_101ck280 FIND v(dout0_101) AT=145.025n

.meas tran vdout0_102ck280 FIND v(dout0_102) AT=145.025n

.meas tran vdout0_103ck280 FIND v(dout0_103) AT=145.025n

.meas tran vdout0_104ck280 FIND v(dout0_104) AT=145.025n

.meas tran vdout0_105ck280 FIND v(dout0_105) AT=145.025n

.meas tran vdout0_106ck280 FIND v(dout0_106) AT=145.025n

.meas tran vdout0_107ck280 FIND v(dout0_107) AT=145.025n

.meas tran vdout0_108ck280 FIND v(dout0_108) AT=145.025n

.meas tran vdout0_109ck280 FIND v(dout0_109) AT=145.025n

.meas tran vdout0_110ck280 FIND v(dout0_110) AT=145.025n

.meas tran vdout0_111ck280 FIND v(dout0_111) AT=145.025n

.meas tran vdout0_112ck280 FIND v(dout0_112) AT=145.025n

.meas tran vdout0_113ck280 FIND v(dout0_113) AT=145.025n

.meas tran vdout0_114ck280 FIND v(dout0_114) AT=145.025n

.meas tran vdout0_115ck280 FIND v(dout0_115) AT=145.025n

.meas tran vdout0_116ck280 FIND v(dout0_116) AT=145.025n

.meas tran vdout0_117ck280 FIND v(dout0_117) AT=145.025n

.meas tran vdout0_118ck280 FIND v(dout0_118) AT=145.025n

.meas tran vdout0_119ck280 FIND v(dout0_119) AT=145.025n

.meas tran vdout0_120ck280 FIND v(dout0_120) AT=145.025n

.meas tran vdout0_121ck280 FIND v(dout0_121) AT=145.025n

.meas tran vdout0_122ck280 FIND v(dout0_122) AT=145.025n

.meas tran vdout0_123ck280 FIND v(dout0_123) AT=145.025n

.meas tran vdout0_124ck280 FIND v(dout0_124) AT=145.025n

.meas tran vdout0_125ck280 FIND v(dout0_125) AT=145.025n

.meas tran vdout0_126ck280 FIND v(dout0_126) AT=145.025n

.meas tran vdout0_127ck280 FIND v(dout0_127) AT=145.025n

.meas tran vdout0_128ck280 FIND v(dout0_128) AT=145.025n

.meas tran vdout0_129ck280 FIND v(dout0_129) AT=145.025n

.meas tran vdout0_130ck280 FIND v(dout0_130) AT=145.025n

.meas tran vdout0_131ck280 FIND v(dout0_131) AT=145.025n

.meas tran vdout0_132ck280 FIND v(dout0_132) AT=145.025n

.meas tran vdout0_133ck280 FIND v(dout0_133) AT=145.025n

.meas tran vdout0_134ck280 FIND v(dout0_134) AT=145.025n

.meas tran vdout0_135ck280 FIND v(dout0_135) AT=145.025n

.meas tran vdout0_136ck280 FIND v(dout0_136) AT=145.025n

.meas tran vdout0_137ck280 FIND v(dout0_137) AT=145.025n

.meas tran vdout0_138ck280 FIND v(dout0_138) AT=145.025n

.meas tran vdout0_139ck280 FIND v(dout0_139) AT=145.025n

.meas tran vdout0_140ck280 FIND v(dout0_140) AT=145.025n

.meas tran vdout0_141ck280 FIND v(dout0_141) AT=145.025n

.meas tran vdout0_142ck280 FIND v(dout0_142) AT=145.025n

.meas tran vdout0_143ck280 FIND v(dout0_143) AT=145.025n

.meas tran vdout0_144ck280 FIND v(dout0_144) AT=145.025n

.meas tran vdout0_145ck280 FIND v(dout0_145) AT=145.025n

.meas tran vdout0_146ck280 FIND v(dout0_146) AT=145.025n

.meas tran vdout0_147ck280 FIND v(dout0_147) AT=145.025n

.meas tran vdout0_148ck280 FIND v(dout0_148) AT=145.025n

.meas tran vdout0_149ck280 FIND v(dout0_149) AT=145.025n

.meas tran vdout0_0ck300 FIND v(dout0_0) AT=155.025n

.meas tran vdout0_1ck300 FIND v(dout0_1) AT=155.025n

.meas tran vdout0_2ck300 FIND v(dout0_2) AT=155.025n

.meas tran vdout0_3ck300 FIND v(dout0_3) AT=155.025n

.meas tran vdout0_4ck300 FIND v(dout0_4) AT=155.025n

.meas tran vdout0_5ck300 FIND v(dout0_5) AT=155.025n

.meas tran vdout0_6ck300 FIND v(dout0_6) AT=155.025n

.meas tran vdout0_7ck300 FIND v(dout0_7) AT=155.025n

.meas tran vdout0_8ck300 FIND v(dout0_8) AT=155.025n

.meas tran vdout0_9ck300 FIND v(dout0_9) AT=155.025n

.meas tran vdout0_10ck300 FIND v(dout0_10) AT=155.025n

.meas tran vdout0_11ck300 FIND v(dout0_11) AT=155.025n

.meas tran vdout0_12ck300 FIND v(dout0_12) AT=155.025n

.meas tran vdout0_13ck300 FIND v(dout0_13) AT=155.025n

.meas tran vdout0_14ck300 FIND v(dout0_14) AT=155.025n

.meas tran vdout0_15ck300 FIND v(dout0_15) AT=155.025n

.meas tran vdout0_16ck300 FIND v(dout0_16) AT=155.025n

.meas tran vdout0_17ck300 FIND v(dout0_17) AT=155.025n

.meas tran vdout0_18ck300 FIND v(dout0_18) AT=155.025n

.meas tran vdout0_19ck300 FIND v(dout0_19) AT=155.025n

.meas tran vdout0_20ck300 FIND v(dout0_20) AT=155.025n

.meas tran vdout0_21ck300 FIND v(dout0_21) AT=155.025n

.meas tran vdout0_22ck300 FIND v(dout0_22) AT=155.025n

.meas tran vdout0_23ck300 FIND v(dout0_23) AT=155.025n

.meas tran vdout0_24ck300 FIND v(dout0_24) AT=155.025n

.meas tran vdout0_25ck300 FIND v(dout0_25) AT=155.025n

.meas tran vdout0_26ck300 FIND v(dout0_26) AT=155.025n

.meas tran vdout0_27ck300 FIND v(dout0_27) AT=155.025n

.meas tran vdout0_28ck300 FIND v(dout0_28) AT=155.025n

.meas tran vdout0_29ck300 FIND v(dout0_29) AT=155.025n

.meas tran vdout0_30ck300 FIND v(dout0_30) AT=155.025n

.meas tran vdout0_31ck300 FIND v(dout0_31) AT=155.025n

.meas tran vdout0_32ck300 FIND v(dout0_32) AT=155.025n

.meas tran vdout0_33ck300 FIND v(dout0_33) AT=155.025n

.meas tran vdout0_34ck300 FIND v(dout0_34) AT=155.025n

.meas tran vdout0_35ck300 FIND v(dout0_35) AT=155.025n

.meas tran vdout0_36ck300 FIND v(dout0_36) AT=155.025n

.meas tran vdout0_37ck300 FIND v(dout0_37) AT=155.025n

.meas tran vdout0_38ck300 FIND v(dout0_38) AT=155.025n

.meas tran vdout0_39ck300 FIND v(dout0_39) AT=155.025n

.meas tran vdout0_40ck300 FIND v(dout0_40) AT=155.025n

.meas tran vdout0_41ck300 FIND v(dout0_41) AT=155.025n

.meas tran vdout0_42ck300 FIND v(dout0_42) AT=155.025n

.meas tran vdout0_43ck300 FIND v(dout0_43) AT=155.025n

.meas tran vdout0_44ck300 FIND v(dout0_44) AT=155.025n

.meas tran vdout0_45ck300 FIND v(dout0_45) AT=155.025n

.meas tran vdout0_46ck300 FIND v(dout0_46) AT=155.025n

.meas tran vdout0_47ck300 FIND v(dout0_47) AT=155.025n

.meas tran vdout0_48ck300 FIND v(dout0_48) AT=155.025n

.meas tran vdout0_49ck300 FIND v(dout0_49) AT=155.025n

.meas tran vdout0_50ck300 FIND v(dout0_50) AT=155.025n

.meas tran vdout0_51ck300 FIND v(dout0_51) AT=155.025n

.meas tran vdout0_52ck300 FIND v(dout0_52) AT=155.025n

.meas tran vdout0_53ck300 FIND v(dout0_53) AT=155.025n

.meas tran vdout0_54ck300 FIND v(dout0_54) AT=155.025n

.meas tran vdout0_55ck300 FIND v(dout0_55) AT=155.025n

.meas tran vdout0_56ck300 FIND v(dout0_56) AT=155.025n

.meas tran vdout0_57ck300 FIND v(dout0_57) AT=155.025n

.meas tran vdout0_58ck300 FIND v(dout0_58) AT=155.025n

.meas tran vdout0_59ck300 FIND v(dout0_59) AT=155.025n

.meas tran vdout0_60ck300 FIND v(dout0_60) AT=155.025n

.meas tran vdout0_61ck300 FIND v(dout0_61) AT=155.025n

.meas tran vdout0_62ck300 FIND v(dout0_62) AT=155.025n

.meas tran vdout0_63ck300 FIND v(dout0_63) AT=155.025n

.meas tran vdout0_64ck300 FIND v(dout0_64) AT=155.025n

.meas tran vdout0_65ck300 FIND v(dout0_65) AT=155.025n

.meas tran vdout0_66ck300 FIND v(dout0_66) AT=155.025n

.meas tran vdout0_67ck300 FIND v(dout0_67) AT=155.025n

.meas tran vdout0_68ck300 FIND v(dout0_68) AT=155.025n

.meas tran vdout0_69ck300 FIND v(dout0_69) AT=155.025n

.meas tran vdout0_70ck300 FIND v(dout0_70) AT=155.025n

.meas tran vdout0_71ck300 FIND v(dout0_71) AT=155.025n

.meas tran vdout0_72ck300 FIND v(dout0_72) AT=155.025n

.meas tran vdout0_73ck300 FIND v(dout0_73) AT=155.025n

.meas tran vdout0_74ck300 FIND v(dout0_74) AT=155.025n

.meas tran vdout0_75ck300 FIND v(dout0_75) AT=155.025n

.meas tran vdout0_76ck300 FIND v(dout0_76) AT=155.025n

.meas tran vdout0_77ck300 FIND v(dout0_77) AT=155.025n

.meas tran vdout0_78ck300 FIND v(dout0_78) AT=155.025n

.meas tran vdout0_79ck300 FIND v(dout0_79) AT=155.025n

.meas tran vdout0_80ck300 FIND v(dout0_80) AT=155.025n

.meas tran vdout0_81ck300 FIND v(dout0_81) AT=155.025n

.meas tran vdout0_82ck300 FIND v(dout0_82) AT=155.025n

.meas tran vdout0_83ck300 FIND v(dout0_83) AT=155.025n

.meas tran vdout0_84ck300 FIND v(dout0_84) AT=155.025n

.meas tran vdout0_85ck300 FIND v(dout0_85) AT=155.025n

.meas tran vdout0_86ck300 FIND v(dout0_86) AT=155.025n

.meas tran vdout0_87ck300 FIND v(dout0_87) AT=155.025n

.meas tran vdout0_88ck300 FIND v(dout0_88) AT=155.025n

.meas tran vdout0_89ck300 FIND v(dout0_89) AT=155.025n

.meas tran vdout0_90ck300 FIND v(dout0_90) AT=155.025n

.meas tran vdout0_91ck300 FIND v(dout0_91) AT=155.025n

.meas tran vdout0_92ck300 FIND v(dout0_92) AT=155.025n

.meas tran vdout0_93ck300 FIND v(dout0_93) AT=155.025n

.meas tran vdout0_94ck300 FIND v(dout0_94) AT=155.025n

.meas tran vdout0_95ck300 FIND v(dout0_95) AT=155.025n

.meas tran vdout0_96ck300 FIND v(dout0_96) AT=155.025n

.meas tran vdout0_97ck300 FIND v(dout0_97) AT=155.025n

.meas tran vdout0_98ck300 FIND v(dout0_98) AT=155.025n

.meas tran vdout0_99ck300 FIND v(dout0_99) AT=155.025n

.meas tran vdout0_100ck300 FIND v(dout0_100) AT=155.025n

.meas tran vdout0_101ck300 FIND v(dout0_101) AT=155.025n

.meas tran vdout0_102ck300 FIND v(dout0_102) AT=155.025n

.meas tran vdout0_103ck300 FIND v(dout0_103) AT=155.025n

.meas tran vdout0_104ck300 FIND v(dout0_104) AT=155.025n

.meas tran vdout0_105ck300 FIND v(dout0_105) AT=155.025n

.meas tran vdout0_106ck300 FIND v(dout0_106) AT=155.025n

.meas tran vdout0_107ck300 FIND v(dout0_107) AT=155.025n

.meas tran vdout0_108ck300 FIND v(dout0_108) AT=155.025n

.meas tran vdout0_109ck300 FIND v(dout0_109) AT=155.025n

.meas tran vdout0_110ck300 FIND v(dout0_110) AT=155.025n

.meas tran vdout0_111ck300 FIND v(dout0_111) AT=155.025n

.meas tran vdout0_112ck300 FIND v(dout0_112) AT=155.025n

.meas tran vdout0_113ck300 FIND v(dout0_113) AT=155.025n

.meas tran vdout0_114ck300 FIND v(dout0_114) AT=155.025n

.meas tran vdout0_115ck300 FIND v(dout0_115) AT=155.025n

.meas tran vdout0_116ck300 FIND v(dout0_116) AT=155.025n

.meas tran vdout0_117ck300 FIND v(dout0_117) AT=155.025n

.meas tran vdout0_118ck300 FIND v(dout0_118) AT=155.025n

.meas tran vdout0_119ck300 FIND v(dout0_119) AT=155.025n

.meas tran vdout0_120ck300 FIND v(dout0_120) AT=155.025n

.meas tran vdout0_121ck300 FIND v(dout0_121) AT=155.025n

.meas tran vdout0_122ck300 FIND v(dout0_122) AT=155.025n

.meas tran vdout0_123ck300 FIND v(dout0_123) AT=155.025n

.meas tran vdout0_124ck300 FIND v(dout0_124) AT=155.025n

.meas tran vdout0_125ck300 FIND v(dout0_125) AT=155.025n

.meas tran vdout0_126ck300 FIND v(dout0_126) AT=155.025n

.meas tran vdout0_127ck300 FIND v(dout0_127) AT=155.025n

.meas tran vdout0_128ck300 FIND v(dout0_128) AT=155.025n

.meas tran vdout0_129ck300 FIND v(dout0_129) AT=155.025n

.meas tran vdout0_130ck300 FIND v(dout0_130) AT=155.025n

.meas tran vdout0_131ck300 FIND v(dout0_131) AT=155.025n

.meas tran vdout0_132ck300 FIND v(dout0_132) AT=155.025n

.meas tran vdout0_133ck300 FIND v(dout0_133) AT=155.025n

.meas tran vdout0_134ck300 FIND v(dout0_134) AT=155.025n

.meas tran vdout0_135ck300 FIND v(dout0_135) AT=155.025n

.meas tran vdout0_136ck300 FIND v(dout0_136) AT=155.025n

.meas tran vdout0_137ck300 FIND v(dout0_137) AT=155.025n

.meas tran vdout0_138ck300 FIND v(dout0_138) AT=155.025n

.meas tran vdout0_139ck300 FIND v(dout0_139) AT=155.025n

.meas tran vdout0_140ck300 FIND v(dout0_140) AT=155.025n

.meas tran vdout0_141ck300 FIND v(dout0_141) AT=155.025n

.meas tran vdout0_142ck300 FIND v(dout0_142) AT=155.025n

.meas tran vdout0_143ck300 FIND v(dout0_143) AT=155.025n

.meas tran vdout0_144ck300 FIND v(dout0_144) AT=155.025n

.meas tran vdout0_145ck300 FIND v(dout0_145) AT=155.025n

.meas tran vdout0_146ck300 FIND v(dout0_146) AT=155.025n

.meas tran vdout0_147ck300 FIND v(dout0_147) AT=155.025n

.meas tran vdout0_148ck300 FIND v(dout0_148) AT=155.025n

.meas tran vdout0_149ck300 FIND v(dout0_149) AT=155.025n

.meas tran vdout0_0ck310 FIND v(dout0_0) AT=160.025n

.meas tran vdout0_1ck310 FIND v(dout0_1) AT=160.025n

.meas tran vdout0_2ck310 FIND v(dout0_2) AT=160.025n

.meas tran vdout0_3ck310 FIND v(dout0_3) AT=160.025n

.meas tran vdout0_4ck310 FIND v(dout0_4) AT=160.025n

.meas tran vdout0_5ck310 FIND v(dout0_5) AT=160.025n

.meas tran vdout0_6ck310 FIND v(dout0_6) AT=160.025n

.meas tran vdout0_7ck310 FIND v(dout0_7) AT=160.025n

.meas tran vdout0_8ck310 FIND v(dout0_8) AT=160.025n

.meas tran vdout0_9ck310 FIND v(dout0_9) AT=160.025n

.meas tran vdout0_10ck310 FIND v(dout0_10) AT=160.025n

.meas tran vdout0_11ck310 FIND v(dout0_11) AT=160.025n

.meas tran vdout0_12ck310 FIND v(dout0_12) AT=160.025n

.meas tran vdout0_13ck310 FIND v(dout0_13) AT=160.025n

.meas tran vdout0_14ck310 FIND v(dout0_14) AT=160.025n

.meas tran vdout0_15ck310 FIND v(dout0_15) AT=160.025n

.meas tran vdout0_16ck310 FIND v(dout0_16) AT=160.025n

.meas tran vdout0_17ck310 FIND v(dout0_17) AT=160.025n

.meas tran vdout0_18ck310 FIND v(dout0_18) AT=160.025n

.meas tran vdout0_19ck310 FIND v(dout0_19) AT=160.025n

.meas tran vdout0_20ck310 FIND v(dout0_20) AT=160.025n

.meas tran vdout0_21ck310 FIND v(dout0_21) AT=160.025n

.meas tran vdout0_22ck310 FIND v(dout0_22) AT=160.025n

.meas tran vdout0_23ck310 FIND v(dout0_23) AT=160.025n

.meas tran vdout0_24ck310 FIND v(dout0_24) AT=160.025n

.meas tran vdout0_25ck310 FIND v(dout0_25) AT=160.025n

.meas tran vdout0_26ck310 FIND v(dout0_26) AT=160.025n

.meas tran vdout0_27ck310 FIND v(dout0_27) AT=160.025n

.meas tran vdout0_28ck310 FIND v(dout0_28) AT=160.025n

.meas tran vdout0_29ck310 FIND v(dout0_29) AT=160.025n

.meas tran vdout0_30ck310 FIND v(dout0_30) AT=160.025n

.meas tran vdout0_31ck310 FIND v(dout0_31) AT=160.025n

.meas tran vdout0_32ck310 FIND v(dout0_32) AT=160.025n

.meas tran vdout0_33ck310 FIND v(dout0_33) AT=160.025n

.meas tran vdout0_34ck310 FIND v(dout0_34) AT=160.025n

.meas tran vdout0_35ck310 FIND v(dout0_35) AT=160.025n

.meas tran vdout0_36ck310 FIND v(dout0_36) AT=160.025n

.meas tran vdout0_37ck310 FIND v(dout0_37) AT=160.025n

.meas tran vdout0_38ck310 FIND v(dout0_38) AT=160.025n

.meas tran vdout0_39ck310 FIND v(dout0_39) AT=160.025n

.meas tran vdout0_40ck310 FIND v(dout0_40) AT=160.025n

.meas tran vdout0_41ck310 FIND v(dout0_41) AT=160.025n

.meas tran vdout0_42ck310 FIND v(dout0_42) AT=160.025n

.meas tran vdout0_43ck310 FIND v(dout0_43) AT=160.025n

.meas tran vdout0_44ck310 FIND v(dout0_44) AT=160.025n

.meas tran vdout0_45ck310 FIND v(dout0_45) AT=160.025n

.meas tran vdout0_46ck310 FIND v(dout0_46) AT=160.025n

.meas tran vdout0_47ck310 FIND v(dout0_47) AT=160.025n

.meas tran vdout0_48ck310 FIND v(dout0_48) AT=160.025n

.meas tran vdout0_49ck310 FIND v(dout0_49) AT=160.025n

.meas tran vdout0_50ck310 FIND v(dout0_50) AT=160.025n

.meas tran vdout0_51ck310 FIND v(dout0_51) AT=160.025n

.meas tran vdout0_52ck310 FIND v(dout0_52) AT=160.025n

.meas tran vdout0_53ck310 FIND v(dout0_53) AT=160.025n

.meas tran vdout0_54ck310 FIND v(dout0_54) AT=160.025n

.meas tran vdout0_55ck310 FIND v(dout0_55) AT=160.025n

.meas tran vdout0_56ck310 FIND v(dout0_56) AT=160.025n

.meas tran vdout0_57ck310 FIND v(dout0_57) AT=160.025n

.meas tran vdout0_58ck310 FIND v(dout0_58) AT=160.025n

.meas tran vdout0_59ck310 FIND v(dout0_59) AT=160.025n

.meas tran vdout0_60ck310 FIND v(dout0_60) AT=160.025n

.meas tran vdout0_61ck310 FIND v(dout0_61) AT=160.025n

.meas tran vdout0_62ck310 FIND v(dout0_62) AT=160.025n

.meas tran vdout0_63ck310 FIND v(dout0_63) AT=160.025n

.meas tran vdout0_64ck310 FIND v(dout0_64) AT=160.025n

.meas tran vdout0_65ck310 FIND v(dout0_65) AT=160.025n

.meas tran vdout0_66ck310 FIND v(dout0_66) AT=160.025n

.meas tran vdout0_67ck310 FIND v(dout0_67) AT=160.025n

.meas tran vdout0_68ck310 FIND v(dout0_68) AT=160.025n

.meas tran vdout0_69ck310 FIND v(dout0_69) AT=160.025n

.meas tran vdout0_70ck310 FIND v(dout0_70) AT=160.025n

.meas tran vdout0_71ck310 FIND v(dout0_71) AT=160.025n

.meas tran vdout0_72ck310 FIND v(dout0_72) AT=160.025n

.meas tran vdout0_73ck310 FIND v(dout0_73) AT=160.025n

.meas tran vdout0_74ck310 FIND v(dout0_74) AT=160.025n

.meas tran vdout0_75ck310 FIND v(dout0_75) AT=160.025n

.meas tran vdout0_76ck310 FIND v(dout0_76) AT=160.025n

.meas tran vdout0_77ck310 FIND v(dout0_77) AT=160.025n

.meas tran vdout0_78ck310 FIND v(dout0_78) AT=160.025n

.meas tran vdout0_79ck310 FIND v(dout0_79) AT=160.025n

.meas tran vdout0_80ck310 FIND v(dout0_80) AT=160.025n

.meas tran vdout0_81ck310 FIND v(dout0_81) AT=160.025n

.meas tran vdout0_82ck310 FIND v(dout0_82) AT=160.025n

.meas tran vdout0_83ck310 FIND v(dout0_83) AT=160.025n

.meas tran vdout0_84ck310 FIND v(dout0_84) AT=160.025n

.meas tran vdout0_85ck310 FIND v(dout0_85) AT=160.025n

.meas tran vdout0_86ck310 FIND v(dout0_86) AT=160.025n

.meas tran vdout0_87ck310 FIND v(dout0_87) AT=160.025n

.meas tran vdout0_88ck310 FIND v(dout0_88) AT=160.025n

.meas tran vdout0_89ck310 FIND v(dout0_89) AT=160.025n

.meas tran vdout0_90ck310 FIND v(dout0_90) AT=160.025n

.meas tran vdout0_91ck310 FIND v(dout0_91) AT=160.025n

.meas tran vdout0_92ck310 FIND v(dout0_92) AT=160.025n

.meas tran vdout0_93ck310 FIND v(dout0_93) AT=160.025n

.meas tran vdout0_94ck310 FIND v(dout0_94) AT=160.025n

.meas tran vdout0_95ck310 FIND v(dout0_95) AT=160.025n

.meas tran vdout0_96ck310 FIND v(dout0_96) AT=160.025n

.meas tran vdout0_97ck310 FIND v(dout0_97) AT=160.025n

.meas tran vdout0_98ck310 FIND v(dout0_98) AT=160.025n

.meas tran vdout0_99ck310 FIND v(dout0_99) AT=160.025n

.meas tran vdout0_100ck310 FIND v(dout0_100) AT=160.025n

.meas tran vdout0_101ck310 FIND v(dout0_101) AT=160.025n

.meas tran vdout0_102ck310 FIND v(dout0_102) AT=160.025n

.meas tran vdout0_103ck310 FIND v(dout0_103) AT=160.025n

.meas tran vdout0_104ck310 FIND v(dout0_104) AT=160.025n

.meas tran vdout0_105ck310 FIND v(dout0_105) AT=160.025n

.meas tran vdout0_106ck310 FIND v(dout0_106) AT=160.025n

.meas tran vdout0_107ck310 FIND v(dout0_107) AT=160.025n

.meas tran vdout0_108ck310 FIND v(dout0_108) AT=160.025n

.meas tran vdout0_109ck310 FIND v(dout0_109) AT=160.025n

.meas tran vdout0_110ck310 FIND v(dout0_110) AT=160.025n

.meas tran vdout0_111ck310 FIND v(dout0_111) AT=160.025n

.meas tran vdout0_112ck310 FIND v(dout0_112) AT=160.025n

.meas tran vdout0_113ck310 FIND v(dout0_113) AT=160.025n

.meas tran vdout0_114ck310 FIND v(dout0_114) AT=160.025n

.meas tran vdout0_115ck310 FIND v(dout0_115) AT=160.025n

.meas tran vdout0_116ck310 FIND v(dout0_116) AT=160.025n

.meas tran vdout0_117ck310 FIND v(dout0_117) AT=160.025n

.meas tran vdout0_118ck310 FIND v(dout0_118) AT=160.025n

.meas tran vdout0_119ck310 FIND v(dout0_119) AT=160.025n

.meas tran vdout0_120ck310 FIND v(dout0_120) AT=160.025n

.meas tran vdout0_121ck310 FIND v(dout0_121) AT=160.025n

.meas tran vdout0_122ck310 FIND v(dout0_122) AT=160.025n

.meas tran vdout0_123ck310 FIND v(dout0_123) AT=160.025n

.meas tran vdout0_124ck310 FIND v(dout0_124) AT=160.025n

.meas tran vdout0_125ck310 FIND v(dout0_125) AT=160.025n

.meas tran vdout0_126ck310 FIND v(dout0_126) AT=160.025n

.meas tran vdout0_127ck310 FIND v(dout0_127) AT=160.025n

.meas tran vdout0_128ck310 FIND v(dout0_128) AT=160.025n

.meas tran vdout0_129ck310 FIND v(dout0_129) AT=160.025n

.meas tran vdout0_130ck310 FIND v(dout0_130) AT=160.025n

.meas tran vdout0_131ck310 FIND v(dout0_131) AT=160.025n

.meas tran vdout0_132ck310 FIND v(dout0_132) AT=160.025n

.meas tran vdout0_133ck310 FIND v(dout0_133) AT=160.025n

.meas tran vdout0_134ck310 FIND v(dout0_134) AT=160.025n

.meas tran vdout0_135ck310 FIND v(dout0_135) AT=160.025n

.meas tran vdout0_136ck310 FIND v(dout0_136) AT=160.025n

.meas tran vdout0_137ck310 FIND v(dout0_137) AT=160.025n

.meas tran vdout0_138ck310 FIND v(dout0_138) AT=160.025n

.meas tran vdout0_139ck310 FIND v(dout0_139) AT=160.025n

.meas tran vdout0_140ck310 FIND v(dout0_140) AT=160.025n

.meas tran vdout0_141ck310 FIND v(dout0_141) AT=160.025n

.meas tran vdout0_142ck310 FIND v(dout0_142) AT=160.025n

.meas tran vdout0_143ck310 FIND v(dout0_143) AT=160.025n

.meas tran vdout0_144ck310 FIND v(dout0_144) AT=160.025n

.meas tran vdout0_145ck310 FIND v(dout0_145) AT=160.025n

.meas tran vdout0_146ck310 FIND v(dout0_146) AT=160.025n

.meas tran vdout0_147ck310 FIND v(dout0_147) AT=160.025n

.meas tran vdout0_148ck310 FIND v(dout0_148) AT=160.025n

.meas tran vdout0_149ck310 FIND v(dout0_149) AT=160.025n

.meas tran vdout0_0ck320 FIND v(dout0_0) AT=165.025n

.meas tran vdout0_1ck320 FIND v(dout0_1) AT=165.025n

.meas tran vdout0_2ck320 FIND v(dout0_2) AT=165.025n

.meas tran vdout0_3ck320 FIND v(dout0_3) AT=165.025n

.meas tran vdout0_4ck320 FIND v(dout0_4) AT=165.025n

.meas tran vdout0_5ck320 FIND v(dout0_5) AT=165.025n

.meas tran vdout0_6ck320 FIND v(dout0_6) AT=165.025n

.meas tran vdout0_7ck320 FIND v(dout0_7) AT=165.025n

.meas tran vdout0_8ck320 FIND v(dout0_8) AT=165.025n

.meas tran vdout0_9ck320 FIND v(dout0_9) AT=165.025n

.meas tran vdout0_10ck320 FIND v(dout0_10) AT=165.025n

.meas tran vdout0_11ck320 FIND v(dout0_11) AT=165.025n

.meas tran vdout0_12ck320 FIND v(dout0_12) AT=165.025n

.meas tran vdout0_13ck320 FIND v(dout0_13) AT=165.025n

.meas tran vdout0_14ck320 FIND v(dout0_14) AT=165.025n

.meas tran vdout0_15ck320 FIND v(dout0_15) AT=165.025n

.meas tran vdout0_16ck320 FIND v(dout0_16) AT=165.025n

.meas tran vdout0_17ck320 FIND v(dout0_17) AT=165.025n

.meas tran vdout0_18ck320 FIND v(dout0_18) AT=165.025n

.meas tran vdout0_19ck320 FIND v(dout0_19) AT=165.025n

.meas tran vdout0_20ck320 FIND v(dout0_20) AT=165.025n

.meas tran vdout0_21ck320 FIND v(dout0_21) AT=165.025n

.meas tran vdout0_22ck320 FIND v(dout0_22) AT=165.025n

.meas tran vdout0_23ck320 FIND v(dout0_23) AT=165.025n

.meas tran vdout0_24ck320 FIND v(dout0_24) AT=165.025n

.meas tran vdout0_25ck320 FIND v(dout0_25) AT=165.025n

.meas tran vdout0_26ck320 FIND v(dout0_26) AT=165.025n

.meas tran vdout0_27ck320 FIND v(dout0_27) AT=165.025n

.meas tran vdout0_28ck320 FIND v(dout0_28) AT=165.025n

.meas tran vdout0_29ck320 FIND v(dout0_29) AT=165.025n

.meas tran vdout0_30ck320 FIND v(dout0_30) AT=165.025n

.meas tran vdout0_31ck320 FIND v(dout0_31) AT=165.025n

.meas tran vdout0_32ck320 FIND v(dout0_32) AT=165.025n

.meas tran vdout0_33ck320 FIND v(dout0_33) AT=165.025n

.meas tran vdout0_34ck320 FIND v(dout0_34) AT=165.025n

.meas tran vdout0_35ck320 FIND v(dout0_35) AT=165.025n

.meas tran vdout0_36ck320 FIND v(dout0_36) AT=165.025n

.meas tran vdout0_37ck320 FIND v(dout0_37) AT=165.025n

.meas tran vdout0_38ck320 FIND v(dout0_38) AT=165.025n

.meas tran vdout0_39ck320 FIND v(dout0_39) AT=165.025n

.meas tran vdout0_40ck320 FIND v(dout0_40) AT=165.025n

.meas tran vdout0_41ck320 FIND v(dout0_41) AT=165.025n

.meas tran vdout0_42ck320 FIND v(dout0_42) AT=165.025n

.meas tran vdout0_43ck320 FIND v(dout0_43) AT=165.025n

.meas tran vdout0_44ck320 FIND v(dout0_44) AT=165.025n

.meas tran vdout0_45ck320 FIND v(dout0_45) AT=165.025n

.meas tran vdout0_46ck320 FIND v(dout0_46) AT=165.025n

.meas tran vdout0_47ck320 FIND v(dout0_47) AT=165.025n

.meas tran vdout0_48ck320 FIND v(dout0_48) AT=165.025n

.meas tran vdout0_49ck320 FIND v(dout0_49) AT=165.025n

.meas tran vdout0_50ck320 FIND v(dout0_50) AT=165.025n

.meas tran vdout0_51ck320 FIND v(dout0_51) AT=165.025n

.meas tran vdout0_52ck320 FIND v(dout0_52) AT=165.025n

.meas tran vdout0_53ck320 FIND v(dout0_53) AT=165.025n

.meas tran vdout0_54ck320 FIND v(dout0_54) AT=165.025n

.meas tran vdout0_55ck320 FIND v(dout0_55) AT=165.025n

.meas tran vdout0_56ck320 FIND v(dout0_56) AT=165.025n

.meas tran vdout0_57ck320 FIND v(dout0_57) AT=165.025n

.meas tran vdout0_58ck320 FIND v(dout0_58) AT=165.025n

.meas tran vdout0_59ck320 FIND v(dout0_59) AT=165.025n

.meas tran vdout0_60ck320 FIND v(dout0_60) AT=165.025n

.meas tran vdout0_61ck320 FIND v(dout0_61) AT=165.025n

.meas tran vdout0_62ck320 FIND v(dout0_62) AT=165.025n

.meas tran vdout0_63ck320 FIND v(dout0_63) AT=165.025n

.meas tran vdout0_64ck320 FIND v(dout0_64) AT=165.025n

.meas tran vdout0_65ck320 FIND v(dout0_65) AT=165.025n

.meas tran vdout0_66ck320 FIND v(dout0_66) AT=165.025n

.meas tran vdout0_67ck320 FIND v(dout0_67) AT=165.025n

.meas tran vdout0_68ck320 FIND v(dout0_68) AT=165.025n

.meas tran vdout0_69ck320 FIND v(dout0_69) AT=165.025n

.meas tran vdout0_70ck320 FIND v(dout0_70) AT=165.025n

.meas tran vdout0_71ck320 FIND v(dout0_71) AT=165.025n

.meas tran vdout0_72ck320 FIND v(dout0_72) AT=165.025n

.meas tran vdout0_73ck320 FIND v(dout0_73) AT=165.025n

.meas tran vdout0_74ck320 FIND v(dout0_74) AT=165.025n

.meas tran vdout0_75ck320 FIND v(dout0_75) AT=165.025n

.meas tran vdout0_76ck320 FIND v(dout0_76) AT=165.025n

.meas tran vdout0_77ck320 FIND v(dout0_77) AT=165.025n

.meas tran vdout0_78ck320 FIND v(dout0_78) AT=165.025n

.meas tran vdout0_79ck320 FIND v(dout0_79) AT=165.025n

.meas tran vdout0_80ck320 FIND v(dout0_80) AT=165.025n

.meas tran vdout0_81ck320 FIND v(dout0_81) AT=165.025n

.meas tran vdout0_82ck320 FIND v(dout0_82) AT=165.025n

.meas tran vdout0_83ck320 FIND v(dout0_83) AT=165.025n

.meas tran vdout0_84ck320 FIND v(dout0_84) AT=165.025n

.meas tran vdout0_85ck320 FIND v(dout0_85) AT=165.025n

.meas tran vdout0_86ck320 FIND v(dout0_86) AT=165.025n

.meas tran vdout0_87ck320 FIND v(dout0_87) AT=165.025n

.meas tran vdout0_88ck320 FIND v(dout0_88) AT=165.025n

.meas tran vdout0_89ck320 FIND v(dout0_89) AT=165.025n

.meas tran vdout0_90ck320 FIND v(dout0_90) AT=165.025n

.meas tran vdout0_91ck320 FIND v(dout0_91) AT=165.025n

.meas tran vdout0_92ck320 FIND v(dout0_92) AT=165.025n

.meas tran vdout0_93ck320 FIND v(dout0_93) AT=165.025n

.meas tran vdout0_94ck320 FIND v(dout0_94) AT=165.025n

.meas tran vdout0_95ck320 FIND v(dout0_95) AT=165.025n

.meas tran vdout0_96ck320 FIND v(dout0_96) AT=165.025n

.meas tran vdout0_97ck320 FIND v(dout0_97) AT=165.025n

.meas tran vdout0_98ck320 FIND v(dout0_98) AT=165.025n

.meas tran vdout0_99ck320 FIND v(dout0_99) AT=165.025n

.meas tran vdout0_100ck320 FIND v(dout0_100) AT=165.025n

.meas tran vdout0_101ck320 FIND v(dout0_101) AT=165.025n

.meas tran vdout0_102ck320 FIND v(dout0_102) AT=165.025n

.meas tran vdout0_103ck320 FIND v(dout0_103) AT=165.025n

.meas tran vdout0_104ck320 FIND v(dout0_104) AT=165.025n

.meas tran vdout0_105ck320 FIND v(dout0_105) AT=165.025n

.meas tran vdout0_106ck320 FIND v(dout0_106) AT=165.025n

.meas tran vdout0_107ck320 FIND v(dout0_107) AT=165.025n

.meas tran vdout0_108ck320 FIND v(dout0_108) AT=165.025n

.meas tran vdout0_109ck320 FIND v(dout0_109) AT=165.025n

.meas tran vdout0_110ck320 FIND v(dout0_110) AT=165.025n

.meas tran vdout0_111ck320 FIND v(dout0_111) AT=165.025n

.meas tran vdout0_112ck320 FIND v(dout0_112) AT=165.025n

.meas tran vdout0_113ck320 FIND v(dout0_113) AT=165.025n

.meas tran vdout0_114ck320 FIND v(dout0_114) AT=165.025n

.meas tran vdout0_115ck320 FIND v(dout0_115) AT=165.025n

.meas tran vdout0_116ck320 FIND v(dout0_116) AT=165.025n

.meas tran vdout0_117ck320 FIND v(dout0_117) AT=165.025n

.meas tran vdout0_118ck320 FIND v(dout0_118) AT=165.025n

.meas tran vdout0_119ck320 FIND v(dout0_119) AT=165.025n

.meas tran vdout0_120ck320 FIND v(dout0_120) AT=165.025n

.meas tran vdout0_121ck320 FIND v(dout0_121) AT=165.025n

.meas tran vdout0_122ck320 FIND v(dout0_122) AT=165.025n

.meas tran vdout0_123ck320 FIND v(dout0_123) AT=165.025n

.meas tran vdout0_124ck320 FIND v(dout0_124) AT=165.025n

.meas tran vdout0_125ck320 FIND v(dout0_125) AT=165.025n

.meas tran vdout0_126ck320 FIND v(dout0_126) AT=165.025n

.meas tran vdout0_127ck320 FIND v(dout0_127) AT=165.025n

.meas tran vdout0_128ck320 FIND v(dout0_128) AT=165.025n

.meas tran vdout0_129ck320 FIND v(dout0_129) AT=165.025n

.meas tran vdout0_130ck320 FIND v(dout0_130) AT=165.025n

.meas tran vdout0_131ck320 FIND v(dout0_131) AT=165.025n

.meas tran vdout0_132ck320 FIND v(dout0_132) AT=165.025n

.meas tran vdout0_133ck320 FIND v(dout0_133) AT=165.025n

.meas tran vdout0_134ck320 FIND v(dout0_134) AT=165.025n

.meas tran vdout0_135ck320 FIND v(dout0_135) AT=165.025n

.meas tran vdout0_136ck320 FIND v(dout0_136) AT=165.025n

.meas tran vdout0_137ck320 FIND v(dout0_137) AT=165.025n

.meas tran vdout0_138ck320 FIND v(dout0_138) AT=165.025n

.meas tran vdout0_139ck320 FIND v(dout0_139) AT=165.025n

.meas tran vdout0_140ck320 FIND v(dout0_140) AT=165.025n

.meas tran vdout0_141ck320 FIND v(dout0_141) AT=165.025n

.meas tran vdout0_142ck320 FIND v(dout0_142) AT=165.025n

.meas tran vdout0_143ck320 FIND v(dout0_143) AT=165.025n

.meas tran vdout0_144ck320 FIND v(dout0_144) AT=165.025n

.meas tran vdout0_145ck320 FIND v(dout0_145) AT=165.025n

.meas tran vdout0_146ck320 FIND v(dout0_146) AT=165.025n

.meas tran vdout0_147ck320 FIND v(dout0_147) AT=165.025n

.meas tran vdout0_148ck320 FIND v(dout0_148) AT=165.025n

.meas tran vdout0_149ck320 FIND v(dout0_149) AT=165.025n

.meas tran vdout0_0ck330 FIND v(dout0_0) AT=170.025n

.meas tran vdout0_1ck330 FIND v(dout0_1) AT=170.025n

.meas tran vdout0_2ck330 FIND v(dout0_2) AT=170.025n

.meas tran vdout0_3ck330 FIND v(dout0_3) AT=170.025n

.meas tran vdout0_4ck330 FIND v(dout0_4) AT=170.025n

.meas tran vdout0_5ck330 FIND v(dout0_5) AT=170.025n

.meas tran vdout0_6ck330 FIND v(dout0_6) AT=170.025n

.meas tran vdout0_7ck330 FIND v(dout0_7) AT=170.025n

.meas tran vdout0_8ck330 FIND v(dout0_8) AT=170.025n

.meas tran vdout0_9ck330 FIND v(dout0_9) AT=170.025n

.meas tran vdout0_10ck330 FIND v(dout0_10) AT=170.025n

.meas tran vdout0_11ck330 FIND v(dout0_11) AT=170.025n

.meas tran vdout0_12ck330 FIND v(dout0_12) AT=170.025n

.meas tran vdout0_13ck330 FIND v(dout0_13) AT=170.025n

.meas tran vdout0_14ck330 FIND v(dout0_14) AT=170.025n

.meas tran vdout0_15ck330 FIND v(dout0_15) AT=170.025n

.meas tran vdout0_16ck330 FIND v(dout0_16) AT=170.025n

.meas tran vdout0_17ck330 FIND v(dout0_17) AT=170.025n

.meas tran vdout0_18ck330 FIND v(dout0_18) AT=170.025n

.meas tran vdout0_19ck330 FIND v(dout0_19) AT=170.025n

.meas tran vdout0_20ck330 FIND v(dout0_20) AT=170.025n

.meas tran vdout0_21ck330 FIND v(dout0_21) AT=170.025n

.meas tran vdout0_22ck330 FIND v(dout0_22) AT=170.025n

.meas tran vdout0_23ck330 FIND v(dout0_23) AT=170.025n

.meas tran vdout0_24ck330 FIND v(dout0_24) AT=170.025n

.meas tran vdout0_25ck330 FIND v(dout0_25) AT=170.025n

.meas tran vdout0_26ck330 FIND v(dout0_26) AT=170.025n

.meas tran vdout0_27ck330 FIND v(dout0_27) AT=170.025n

.meas tran vdout0_28ck330 FIND v(dout0_28) AT=170.025n

.meas tran vdout0_29ck330 FIND v(dout0_29) AT=170.025n

.meas tran vdout0_30ck330 FIND v(dout0_30) AT=170.025n

.meas tran vdout0_31ck330 FIND v(dout0_31) AT=170.025n

.meas tran vdout0_32ck330 FIND v(dout0_32) AT=170.025n

.meas tran vdout0_33ck330 FIND v(dout0_33) AT=170.025n

.meas tran vdout0_34ck330 FIND v(dout0_34) AT=170.025n

.meas tran vdout0_35ck330 FIND v(dout0_35) AT=170.025n

.meas tran vdout0_36ck330 FIND v(dout0_36) AT=170.025n

.meas tran vdout0_37ck330 FIND v(dout0_37) AT=170.025n

.meas tran vdout0_38ck330 FIND v(dout0_38) AT=170.025n

.meas tran vdout0_39ck330 FIND v(dout0_39) AT=170.025n

.meas tran vdout0_40ck330 FIND v(dout0_40) AT=170.025n

.meas tran vdout0_41ck330 FIND v(dout0_41) AT=170.025n

.meas tran vdout0_42ck330 FIND v(dout0_42) AT=170.025n

.meas tran vdout0_43ck330 FIND v(dout0_43) AT=170.025n

.meas tran vdout0_44ck330 FIND v(dout0_44) AT=170.025n

.meas tran vdout0_45ck330 FIND v(dout0_45) AT=170.025n

.meas tran vdout0_46ck330 FIND v(dout0_46) AT=170.025n

.meas tran vdout0_47ck330 FIND v(dout0_47) AT=170.025n

.meas tran vdout0_48ck330 FIND v(dout0_48) AT=170.025n

.meas tran vdout0_49ck330 FIND v(dout0_49) AT=170.025n

.meas tran vdout0_50ck330 FIND v(dout0_50) AT=170.025n

.meas tran vdout0_51ck330 FIND v(dout0_51) AT=170.025n

.meas tran vdout0_52ck330 FIND v(dout0_52) AT=170.025n

.meas tran vdout0_53ck330 FIND v(dout0_53) AT=170.025n

.meas tran vdout0_54ck330 FIND v(dout0_54) AT=170.025n

.meas tran vdout0_55ck330 FIND v(dout0_55) AT=170.025n

.meas tran vdout0_56ck330 FIND v(dout0_56) AT=170.025n

.meas tran vdout0_57ck330 FIND v(dout0_57) AT=170.025n

.meas tran vdout0_58ck330 FIND v(dout0_58) AT=170.025n

.meas tran vdout0_59ck330 FIND v(dout0_59) AT=170.025n

.meas tran vdout0_60ck330 FIND v(dout0_60) AT=170.025n

.meas tran vdout0_61ck330 FIND v(dout0_61) AT=170.025n

.meas tran vdout0_62ck330 FIND v(dout0_62) AT=170.025n

.meas tran vdout0_63ck330 FIND v(dout0_63) AT=170.025n

.meas tran vdout0_64ck330 FIND v(dout0_64) AT=170.025n

.meas tran vdout0_65ck330 FIND v(dout0_65) AT=170.025n

.meas tran vdout0_66ck330 FIND v(dout0_66) AT=170.025n

.meas tran vdout0_67ck330 FIND v(dout0_67) AT=170.025n

.meas tran vdout0_68ck330 FIND v(dout0_68) AT=170.025n

.meas tran vdout0_69ck330 FIND v(dout0_69) AT=170.025n

.meas tran vdout0_70ck330 FIND v(dout0_70) AT=170.025n

.meas tran vdout0_71ck330 FIND v(dout0_71) AT=170.025n

.meas tran vdout0_72ck330 FIND v(dout0_72) AT=170.025n

.meas tran vdout0_73ck330 FIND v(dout0_73) AT=170.025n

.meas tran vdout0_74ck330 FIND v(dout0_74) AT=170.025n

.meas tran vdout0_75ck330 FIND v(dout0_75) AT=170.025n

.meas tran vdout0_76ck330 FIND v(dout0_76) AT=170.025n

.meas tran vdout0_77ck330 FIND v(dout0_77) AT=170.025n

.meas tran vdout0_78ck330 FIND v(dout0_78) AT=170.025n

.meas tran vdout0_79ck330 FIND v(dout0_79) AT=170.025n

.meas tran vdout0_80ck330 FIND v(dout0_80) AT=170.025n

.meas tran vdout0_81ck330 FIND v(dout0_81) AT=170.025n

.meas tran vdout0_82ck330 FIND v(dout0_82) AT=170.025n

.meas tran vdout0_83ck330 FIND v(dout0_83) AT=170.025n

.meas tran vdout0_84ck330 FIND v(dout0_84) AT=170.025n

.meas tran vdout0_85ck330 FIND v(dout0_85) AT=170.025n

.meas tran vdout0_86ck330 FIND v(dout0_86) AT=170.025n

.meas tran vdout0_87ck330 FIND v(dout0_87) AT=170.025n

.meas tran vdout0_88ck330 FIND v(dout0_88) AT=170.025n

.meas tran vdout0_89ck330 FIND v(dout0_89) AT=170.025n

.meas tran vdout0_90ck330 FIND v(dout0_90) AT=170.025n

.meas tran vdout0_91ck330 FIND v(dout0_91) AT=170.025n

.meas tran vdout0_92ck330 FIND v(dout0_92) AT=170.025n

.meas tran vdout0_93ck330 FIND v(dout0_93) AT=170.025n

.meas tran vdout0_94ck330 FIND v(dout0_94) AT=170.025n

.meas tran vdout0_95ck330 FIND v(dout0_95) AT=170.025n

.meas tran vdout0_96ck330 FIND v(dout0_96) AT=170.025n

.meas tran vdout0_97ck330 FIND v(dout0_97) AT=170.025n

.meas tran vdout0_98ck330 FIND v(dout0_98) AT=170.025n

.meas tran vdout0_99ck330 FIND v(dout0_99) AT=170.025n

.meas tran vdout0_100ck330 FIND v(dout0_100) AT=170.025n

.meas tran vdout0_101ck330 FIND v(dout0_101) AT=170.025n

.meas tran vdout0_102ck330 FIND v(dout0_102) AT=170.025n

.meas tran vdout0_103ck330 FIND v(dout0_103) AT=170.025n

.meas tran vdout0_104ck330 FIND v(dout0_104) AT=170.025n

.meas tran vdout0_105ck330 FIND v(dout0_105) AT=170.025n

.meas tran vdout0_106ck330 FIND v(dout0_106) AT=170.025n

.meas tran vdout0_107ck330 FIND v(dout0_107) AT=170.025n

.meas tran vdout0_108ck330 FIND v(dout0_108) AT=170.025n

.meas tran vdout0_109ck330 FIND v(dout0_109) AT=170.025n

.meas tran vdout0_110ck330 FIND v(dout0_110) AT=170.025n

.meas tran vdout0_111ck330 FIND v(dout0_111) AT=170.025n

.meas tran vdout0_112ck330 FIND v(dout0_112) AT=170.025n

.meas tran vdout0_113ck330 FIND v(dout0_113) AT=170.025n

.meas tran vdout0_114ck330 FIND v(dout0_114) AT=170.025n

.meas tran vdout0_115ck330 FIND v(dout0_115) AT=170.025n

.meas tran vdout0_116ck330 FIND v(dout0_116) AT=170.025n

.meas tran vdout0_117ck330 FIND v(dout0_117) AT=170.025n

.meas tran vdout0_118ck330 FIND v(dout0_118) AT=170.025n

.meas tran vdout0_119ck330 FIND v(dout0_119) AT=170.025n

.meas tran vdout0_120ck330 FIND v(dout0_120) AT=170.025n

.meas tran vdout0_121ck330 FIND v(dout0_121) AT=170.025n

.meas tran vdout0_122ck330 FIND v(dout0_122) AT=170.025n

.meas tran vdout0_123ck330 FIND v(dout0_123) AT=170.025n

.meas tran vdout0_124ck330 FIND v(dout0_124) AT=170.025n

.meas tran vdout0_125ck330 FIND v(dout0_125) AT=170.025n

.meas tran vdout0_126ck330 FIND v(dout0_126) AT=170.025n

.meas tran vdout0_127ck330 FIND v(dout0_127) AT=170.025n

.meas tran vdout0_128ck330 FIND v(dout0_128) AT=170.025n

.meas tran vdout0_129ck330 FIND v(dout0_129) AT=170.025n

.meas tran vdout0_130ck330 FIND v(dout0_130) AT=170.025n

.meas tran vdout0_131ck330 FIND v(dout0_131) AT=170.025n

.meas tran vdout0_132ck330 FIND v(dout0_132) AT=170.025n

.meas tran vdout0_133ck330 FIND v(dout0_133) AT=170.025n

.meas tran vdout0_134ck330 FIND v(dout0_134) AT=170.025n

.meas tran vdout0_135ck330 FIND v(dout0_135) AT=170.025n

.meas tran vdout0_136ck330 FIND v(dout0_136) AT=170.025n

.meas tran vdout0_137ck330 FIND v(dout0_137) AT=170.025n

.meas tran vdout0_138ck330 FIND v(dout0_138) AT=170.025n

.meas tran vdout0_139ck330 FIND v(dout0_139) AT=170.025n

.meas tran vdout0_140ck330 FIND v(dout0_140) AT=170.025n

.meas tran vdout0_141ck330 FIND v(dout0_141) AT=170.025n

.meas tran vdout0_142ck330 FIND v(dout0_142) AT=170.025n

.meas tran vdout0_143ck330 FIND v(dout0_143) AT=170.025n

.meas tran vdout0_144ck330 FIND v(dout0_144) AT=170.025n

.meas tran vdout0_145ck330 FIND v(dout0_145) AT=170.025n

.meas tran vdout0_146ck330 FIND v(dout0_146) AT=170.025n

.meas tran vdout0_147ck330 FIND v(dout0_147) AT=170.025n

.meas tran vdout0_148ck330 FIND v(dout0_148) AT=170.025n

.meas tran vdout0_149ck330 FIND v(dout0_149) AT=170.025n

.meas tran vdout0_0ck390 FIND v(dout0_0) AT=200.025n

.meas tran vdout0_1ck390 FIND v(dout0_1) AT=200.025n

.meas tran vdout0_2ck390 FIND v(dout0_2) AT=200.025n

.meas tran vdout0_3ck390 FIND v(dout0_3) AT=200.025n

.meas tran vdout0_4ck390 FIND v(dout0_4) AT=200.025n

.meas tran vdout0_5ck390 FIND v(dout0_5) AT=200.025n

.meas tran vdout0_6ck390 FIND v(dout0_6) AT=200.025n

.meas tran vdout0_7ck390 FIND v(dout0_7) AT=200.025n

.meas tran vdout0_8ck390 FIND v(dout0_8) AT=200.025n

.meas tran vdout0_9ck390 FIND v(dout0_9) AT=200.025n

.meas tran vdout0_10ck390 FIND v(dout0_10) AT=200.025n

.meas tran vdout0_11ck390 FIND v(dout0_11) AT=200.025n

.meas tran vdout0_12ck390 FIND v(dout0_12) AT=200.025n

.meas tran vdout0_13ck390 FIND v(dout0_13) AT=200.025n

.meas tran vdout0_14ck390 FIND v(dout0_14) AT=200.025n

.meas tran vdout0_15ck390 FIND v(dout0_15) AT=200.025n

.meas tran vdout0_16ck390 FIND v(dout0_16) AT=200.025n

.meas tran vdout0_17ck390 FIND v(dout0_17) AT=200.025n

.meas tran vdout0_18ck390 FIND v(dout0_18) AT=200.025n

.meas tran vdout0_19ck390 FIND v(dout0_19) AT=200.025n

.meas tran vdout0_20ck390 FIND v(dout0_20) AT=200.025n

.meas tran vdout0_21ck390 FIND v(dout0_21) AT=200.025n

.meas tran vdout0_22ck390 FIND v(dout0_22) AT=200.025n

.meas tran vdout0_23ck390 FIND v(dout0_23) AT=200.025n

.meas tran vdout0_24ck390 FIND v(dout0_24) AT=200.025n

.meas tran vdout0_25ck390 FIND v(dout0_25) AT=200.025n

.meas tran vdout0_26ck390 FIND v(dout0_26) AT=200.025n

.meas tran vdout0_27ck390 FIND v(dout0_27) AT=200.025n

.meas tran vdout0_28ck390 FIND v(dout0_28) AT=200.025n

.meas tran vdout0_29ck390 FIND v(dout0_29) AT=200.025n

.meas tran vdout0_30ck390 FIND v(dout0_30) AT=200.025n

.meas tran vdout0_31ck390 FIND v(dout0_31) AT=200.025n

.meas tran vdout0_32ck390 FIND v(dout0_32) AT=200.025n

.meas tran vdout0_33ck390 FIND v(dout0_33) AT=200.025n

.meas tran vdout0_34ck390 FIND v(dout0_34) AT=200.025n

.meas tran vdout0_35ck390 FIND v(dout0_35) AT=200.025n

.meas tran vdout0_36ck390 FIND v(dout0_36) AT=200.025n

.meas tran vdout0_37ck390 FIND v(dout0_37) AT=200.025n

.meas tran vdout0_38ck390 FIND v(dout0_38) AT=200.025n

.meas tran vdout0_39ck390 FIND v(dout0_39) AT=200.025n

.meas tran vdout0_40ck390 FIND v(dout0_40) AT=200.025n

.meas tran vdout0_41ck390 FIND v(dout0_41) AT=200.025n

.meas tran vdout0_42ck390 FIND v(dout0_42) AT=200.025n

.meas tran vdout0_43ck390 FIND v(dout0_43) AT=200.025n

.meas tran vdout0_44ck390 FIND v(dout0_44) AT=200.025n

.meas tran vdout0_45ck390 FIND v(dout0_45) AT=200.025n

.meas tran vdout0_46ck390 FIND v(dout0_46) AT=200.025n

.meas tran vdout0_47ck390 FIND v(dout0_47) AT=200.025n

.meas tran vdout0_48ck390 FIND v(dout0_48) AT=200.025n

.meas tran vdout0_49ck390 FIND v(dout0_49) AT=200.025n

.meas tran vdout0_50ck390 FIND v(dout0_50) AT=200.025n

.meas tran vdout0_51ck390 FIND v(dout0_51) AT=200.025n

.meas tran vdout0_52ck390 FIND v(dout0_52) AT=200.025n

.meas tran vdout0_53ck390 FIND v(dout0_53) AT=200.025n

.meas tran vdout0_54ck390 FIND v(dout0_54) AT=200.025n

.meas tran vdout0_55ck390 FIND v(dout0_55) AT=200.025n

.meas tran vdout0_56ck390 FIND v(dout0_56) AT=200.025n

.meas tran vdout0_57ck390 FIND v(dout0_57) AT=200.025n

.meas tran vdout0_58ck390 FIND v(dout0_58) AT=200.025n

.meas tran vdout0_59ck390 FIND v(dout0_59) AT=200.025n

.meas tran vdout0_60ck390 FIND v(dout0_60) AT=200.025n

.meas tran vdout0_61ck390 FIND v(dout0_61) AT=200.025n

.meas tran vdout0_62ck390 FIND v(dout0_62) AT=200.025n

.meas tran vdout0_63ck390 FIND v(dout0_63) AT=200.025n

.meas tran vdout0_64ck390 FIND v(dout0_64) AT=200.025n

.meas tran vdout0_65ck390 FIND v(dout0_65) AT=200.025n

.meas tran vdout0_66ck390 FIND v(dout0_66) AT=200.025n

.meas tran vdout0_67ck390 FIND v(dout0_67) AT=200.025n

.meas tran vdout0_68ck390 FIND v(dout0_68) AT=200.025n

.meas tran vdout0_69ck390 FIND v(dout0_69) AT=200.025n

.meas tran vdout0_70ck390 FIND v(dout0_70) AT=200.025n

.meas tran vdout0_71ck390 FIND v(dout0_71) AT=200.025n

.meas tran vdout0_72ck390 FIND v(dout0_72) AT=200.025n

.meas tran vdout0_73ck390 FIND v(dout0_73) AT=200.025n

.meas tran vdout0_74ck390 FIND v(dout0_74) AT=200.025n

.meas tran vdout0_75ck390 FIND v(dout0_75) AT=200.025n

.meas tran vdout0_76ck390 FIND v(dout0_76) AT=200.025n

.meas tran vdout0_77ck390 FIND v(dout0_77) AT=200.025n

.meas tran vdout0_78ck390 FIND v(dout0_78) AT=200.025n

.meas tran vdout0_79ck390 FIND v(dout0_79) AT=200.025n

.meas tran vdout0_80ck390 FIND v(dout0_80) AT=200.025n

.meas tran vdout0_81ck390 FIND v(dout0_81) AT=200.025n

.meas tran vdout0_82ck390 FIND v(dout0_82) AT=200.025n

.meas tran vdout0_83ck390 FIND v(dout0_83) AT=200.025n

.meas tran vdout0_84ck390 FIND v(dout0_84) AT=200.025n

.meas tran vdout0_85ck390 FIND v(dout0_85) AT=200.025n

.meas tran vdout0_86ck390 FIND v(dout0_86) AT=200.025n

.meas tran vdout0_87ck390 FIND v(dout0_87) AT=200.025n

.meas tran vdout0_88ck390 FIND v(dout0_88) AT=200.025n

.meas tran vdout0_89ck390 FIND v(dout0_89) AT=200.025n

.meas tran vdout0_90ck390 FIND v(dout0_90) AT=200.025n

.meas tran vdout0_91ck390 FIND v(dout0_91) AT=200.025n

.meas tran vdout0_92ck390 FIND v(dout0_92) AT=200.025n

.meas tran vdout0_93ck390 FIND v(dout0_93) AT=200.025n

.meas tran vdout0_94ck390 FIND v(dout0_94) AT=200.025n

.meas tran vdout0_95ck390 FIND v(dout0_95) AT=200.025n

.meas tran vdout0_96ck390 FIND v(dout0_96) AT=200.025n

.meas tran vdout0_97ck390 FIND v(dout0_97) AT=200.025n

.meas tran vdout0_98ck390 FIND v(dout0_98) AT=200.025n

.meas tran vdout0_99ck390 FIND v(dout0_99) AT=200.025n

.meas tran vdout0_100ck390 FIND v(dout0_100) AT=200.025n

.meas tran vdout0_101ck390 FIND v(dout0_101) AT=200.025n

.meas tran vdout0_102ck390 FIND v(dout0_102) AT=200.025n

.meas tran vdout0_103ck390 FIND v(dout0_103) AT=200.025n

.meas tran vdout0_104ck390 FIND v(dout0_104) AT=200.025n

.meas tran vdout0_105ck390 FIND v(dout0_105) AT=200.025n

.meas tran vdout0_106ck390 FIND v(dout0_106) AT=200.025n

.meas tran vdout0_107ck390 FIND v(dout0_107) AT=200.025n

.meas tran vdout0_108ck390 FIND v(dout0_108) AT=200.025n

.meas tran vdout0_109ck390 FIND v(dout0_109) AT=200.025n

.meas tran vdout0_110ck390 FIND v(dout0_110) AT=200.025n

.meas tran vdout0_111ck390 FIND v(dout0_111) AT=200.025n

.meas tran vdout0_112ck390 FIND v(dout0_112) AT=200.025n

.meas tran vdout0_113ck390 FIND v(dout0_113) AT=200.025n

.meas tran vdout0_114ck390 FIND v(dout0_114) AT=200.025n

.meas tran vdout0_115ck390 FIND v(dout0_115) AT=200.025n

.meas tran vdout0_116ck390 FIND v(dout0_116) AT=200.025n

.meas tran vdout0_117ck390 FIND v(dout0_117) AT=200.025n

.meas tran vdout0_118ck390 FIND v(dout0_118) AT=200.025n

.meas tran vdout0_119ck390 FIND v(dout0_119) AT=200.025n

.meas tran vdout0_120ck390 FIND v(dout0_120) AT=200.025n

.meas tran vdout0_121ck390 FIND v(dout0_121) AT=200.025n

.meas tran vdout0_122ck390 FIND v(dout0_122) AT=200.025n

.meas tran vdout0_123ck390 FIND v(dout0_123) AT=200.025n

.meas tran vdout0_124ck390 FIND v(dout0_124) AT=200.025n

.meas tran vdout0_125ck390 FIND v(dout0_125) AT=200.025n

.meas tran vdout0_126ck390 FIND v(dout0_126) AT=200.025n

.meas tran vdout0_127ck390 FIND v(dout0_127) AT=200.025n

.meas tran vdout0_128ck390 FIND v(dout0_128) AT=200.025n

.meas tran vdout0_129ck390 FIND v(dout0_129) AT=200.025n

.meas tran vdout0_130ck390 FIND v(dout0_130) AT=200.025n

.meas tran vdout0_131ck390 FIND v(dout0_131) AT=200.025n

.meas tran vdout0_132ck390 FIND v(dout0_132) AT=200.025n

.meas tran vdout0_133ck390 FIND v(dout0_133) AT=200.025n

.meas tran vdout0_134ck390 FIND v(dout0_134) AT=200.025n

.meas tran vdout0_135ck390 FIND v(dout0_135) AT=200.025n

.meas tran vdout0_136ck390 FIND v(dout0_136) AT=200.025n

.meas tran vdout0_137ck390 FIND v(dout0_137) AT=200.025n

.meas tran vdout0_138ck390 FIND v(dout0_138) AT=200.025n

.meas tran vdout0_139ck390 FIND v(dout0_139) AT=200.025n

.meas tran vdout0_140ck390 FIND v(dout0_140) AT=200.025n

.meas tran vdout0_141ck390 FIND v(dout0_141) AT=200.025n

.meas tran vdout0_142ck390 FIND v(dout0_142) AT=200.025n

.meas tran vdout0_143ck390 FIND v(dout0_143) AT=200.025n

.meas tran vdout0_144ck390 FIND v(dout0_144) AT=200.025n

.meas tran vdout0_145ck390 FIND v(dout0_145) AT=200.025n

.meas tran vdout0_146ck390 FIND v(dout0_146) AT=200.025n

.meas tran vdout0_147ck390 FIND v(dout0_147) AT=200.025n

.meas tran vdout0_148ck390 FIND v(dout0_148) AT=200.025n

.meas tran vdout0_149ck390 FIND v(dout0_149) AT=200.025n

.meas tran vdout0_0ck400 FIND v(dout0_0) AT=205.025n

.meas tran vdout0_1ck400 FIND v(dout0_1) AT=205.025n

.meas tran vdout0_2ck400 FIND v(dout0_2) AT=205.025n

.meas tran vdout0_3ck400 FIND v(dout0_3) AT=205.025n

.meas tran vdout0_4ck400 FIND v(dout0_4) AT=205.025n

.meas tran vdout0_5ck400 FIND v(dout0_5) AT=205.025n

.meas tran vdout0_6ck400 FIND v(dout0_6) AT=205.025n

.meas tran vdout0_7ck400 FIND v(dout0_7) AT=205.025n

.meas tran vdout0_8ck400 FIND v(dout0_8) AT=205.025n

.meas tran vdout0_9ck400 FIND v(dout0_9) AT=205.025n

.meas tran vdout0_10ck400 FIND v(dout0_10) AT=205.025n

.meas tran vdout0_11ck400 FIND v(dout0_11) AT=205.025n

.meas tran vdout0_12ck400 FIND v(dout0_12) AT=205.025n

.meas tran vdout0_13ck400 FIND v(dout0_13) AT=205.025n

.meas tran vdout0_14ck400 FIND v(dout0_14) AT=205.025n

.meas tran vdout0_15ck400 FIND v(dout0_15) AT=205.025n

.meas tran vdout0_16ck400 FIND v(dout0_16) AT=205.025n

.meas tran vdout0_17ck400 FIND v(dout0_17) AT=205.025n

.meas tran vdout0_18ck400 FIND v(dout0_18) AT=205.025n

.meas tran vdout0_19ck400 FIND v(dout0_19) AT=205.025n

.meas tran vdout0_20ck400 FIND v(dout0_20) AT=205.025n

.meas tran vdout0_21ck400 FIND v(dout0_21) AT=205.025n

.meas tran vdout0_22ck400 FIND v(dout0_22) AT=205.025n

.meas tran vdout0_23ck400 FIND v(dout0_23) AT=205.025n

.meas tran vdout0_24ck400 FIND v(dout0_24) AT=205.025n

.meas tran vdout0_25ck400 FIND v(dout0_25) AT=205.025n

.meas tran vdout0_26ck400 FIND v(dout0_26) AT=205.025n

.meas tran vdout0_27ck400 FIND v(dout0_27) AT=205.025n

.meas tran vdout0_28ck400 FIND v(dout0_28) AT=205.025n

.meas tran vdout0_29ck400 FIND v(dout0_29) AT=205.025n

.meas tran vdout0_30ck400 FIND v(dout0_30) AT=205.025n

.meas tran vdout0_31ck400 FIND v(dout0_31) AT=205.025n

.meas tran vdout0_32ck400 FIND v(dout0_32) AT=205.025n

.meas tran vdout0_33ck400 FIND v(dout0_33) AT=205.025n

.meas tran vdout0_34ck400 FIND v(dout0_34) AT=205.025n

.meas tran vdout0_35ck400 FIND v(dout0_35) AT=205.025n

.meas tran vdout0_36ck400 FIND v(dout0_36) AT=205.025n

.meas tran vdout0_37ck400 FIND v(dout0_37) AT=205.025n

.meas tran vdout0_38ck400 FIND v(dout0_38) AT=205.025n

.meas tran vdout0_39ck400 FIND v(dout0_39) AT=205.025n

.meas tran vdout0_40ck400 FIND v(dout0_40) AT=205.025n

.meas tran vdout0_41ck400 FIND v(dout0_41) AT=205.025n

.meas tran vdout0_42ck400 FIND v(dout0_42) AT=205.025n

.meas tran vdout0_43ck400 FIND v(dout0_43) AT=205.025n

.meas tran vdout0_44ck400 FIND v(dout0_44) AT=205.025n

.meas tran vdout0_45ck400 FIND v(dout0_45) AT=205.025n

.meas tran vdout0_46ck400 FIND v(dout0_46) AT=205.025n

.meas tran vdout0_47ck400 FIND v(dout0_47) AT=205.025n

.meas tran vdout0_48ck400 FIND v(dout0_48) AT=205.025n

.meas tran vdout0_49ck400 FIND v(dout0_49) AT=205.025n

.meas tran vdout0_50ck400 FIND v(dout0_50) AT=205.025n

.meas tran vdout0_51ck400 FIND v(dout0_51) AT=205.025n

.meas tran vdout0_52ck400 FIND v(dout0_52) AT=205.025n

.meas tran vdout0_53ck400 FIND v(dout0_53) AT=205.025n

.meas tran vdout0_54ck400 FIND v(dout0_54) AT=205.025n

.meas tran vdout0_55ck400 FIND v(dout0_55) AT=205.025n

.meas tran vdout0_56ck400 FIND v(dout0_56) AT=205.025n

.meas tran vdout0_57ck400 FIND v(dout0_57) AT=205.025n

.meas tran vdout0_58ck400 FIND v(dout0_58) AT=205.025n

.meas tran vdout0_59ck400 FIND v(dout0_59) AT=205.025n

.meas tran vdout0_60ck400 FIND v(dout0_60) AT=205.025n

.meas tran vdout0_61ck400 FIND v(dout0_61) AT=205.025n

.meas tran vdout0_62ck400 FIND v(dout0_62) AT=205.025n

.meas tran vdout0_63ck400 FIND v(dout0_63) AT=205.025n

.meas tran vdout0_64ck400 FIND v(dout0_64) AT=205.025n

.meas tran vdout0_65ck400 FIND v(dout0_65) AT=205.025n

.meas tran vdout0_66ck400 FIND v(dout0_66) AT=205.025n

.meas tran vdout0_67ck400 FIND v(dout0_67) AT=205.025n

.meas tran vdout0_68ck400 FIND v(dout0_68) AT=205.025n

.meas tran vdout0_69ck400 FIND v(dout0_69) AT=205.025n

.meas tran vdout0_70ck400 FIND v(dout0_70) AT=205.025n

.meas tran vdout0_71ck400 FIND v(dout0_71) AT=205.025n

.meas tran vdout0_72ck400 FIND v(dout0_72) AT=205.025n

.meas tran vdout0_73ck400 FIND v(dout0_73) AT=205.025n

.meas tran vdout0_74ck400 FIND v(dout0_74) AT=205.025n

.meas tran vdout0_75ck400 FIND v(dout0_75) AT=205.025n

.meas tran vdout0_76ck400 FIND v(dout0_76) AT=205.025n

.meas tran vdout0_77ck400 FIND v(dout0_77) AT=205.025n

.meas tran vdout0_78ck400 FIND v(dout0_78) AT=205.025n

.meas tran vdout0_79ck400 FIND v(dout0_79) AT=205.025n

.meas tran vdout0_80ck400 FIND v(dout0_80) AT=205.025n

.meas tran vdout0_81ck400 FIND v(dout0_81) AT=205.025n

.meas tran vdout0_82ck400 FIND v(dout0_82) AT=205.025n

.meas tran vdout0_83ck400 FIND v(dout0_83) AT=205.025n

.meas tran vdout0_84ck400 FIND v(dout0_84) AT=205.025n

.meas tran vdout0_85ck400 FIND v(dout0_85) AT=205.025n

.meas tran vdout0_86ck400 FIND v(dout0_86) AT=205.025n

.meas tran vdout0_87ck400 FIND v(dout0_87) AT=205.025n

.meas tran vdout0_88ck400 FIND v(dout0_88) AT=205.025n

.meas tran vdout0_89ck400 FIND v(dout0_89) AT=205.025n

.meas tran vdout0_90ck400 FIND v(dout0_90) AT=205.025n

.meas tran vdout0_91ck400 FIND v(dout0_91) AT=205.025n

.meas tran vdout0_92ck400 FIND v(dout0_92) AT=205.025n

.meas tran vdout0_93ck400 FIND v(dout0_93) AT=205.025n

.meas tran vdout0_94ck400 FIND v(dout0_94) AT=205.025n

.meas tran vdout0_95ck400 FIND v(dout0_95) AT=205.025n

.meas tran vdout0_96ck400 FIND v(dout0_96) AT=205.025n

.meas tran vdout0_97ck400 FIND v(dout0_97) AT=205.025n

.meas tran vdout0_98ck400 FIND v(dout0_98) AT=205.025n

.meas tran vdout0_99ck400 FIND v(dout0_99) AT=205.025n

.meas tran vdout0_100ck400 FIND v(dout0_100) AT=205.025n

.meas tran vdout0_101ck400 FIND v(dout0_101) AT=205.025n

.meas tran vdout0_102ck400 FIND v(dout0_102) AT=205.025n

.meas tran vdout0_103ck400 FIND v(dout0_103) AT=205.025n

.meas tran vdout0_104ck400 FIND v(dout0_104) AT=205.025n

.meas tran vdout0_105ck400 FIND v(dout0_105) AT=205.025n

.meas tran vdout0_106ck400 FIND v(dout0_106) AT=205.025n

.meas tran vdout0_107ck400 FIND v(dout0_107) AT=205.025n

.meas tran vdout0_108ck400 FIND v(dout0_108) AT=205.025n

.meas tran vdout0_109ck400 FIND v(dout0_109) AT=205.025n

.meas tran vdout0_110ck400 FIND v(dout0_110) AT=205.025n

.meas tran vdout0_111ck400 FIND v(dout0_111) AT=205.025n

.meas tran vdout0_112ck400 FIND v(dout0_112) AT=205.025n

.meas tran vdout0_113ck400 FIND v(dout0_113) AT=205.025n

.meas tran vdout0_114ck400 FIND v(dout0_114) AT=205.025n

.meas tran vdout0_115ck400 FIND v(dout0_115) AT=205.025n

.meas tran vdout0_116ck400 FIND v(dout0_116) AT=205.025n

.meas tran vdout0_117ck400 FIND v(dout0_117) AT=205.025n

.meas tran vdout0_118ck400 FIND v(dout0_118) AT=205.025n

.meas tran vdout0_119ck400 FIND v(dout0_119) AT=205.025n

.meas tran vdout0_120ck400 FIND v(dout0_120) AT=205.025n

.meas tran vdout0_121ck400 FIND v(dout0_121) AT=205.025n

.meas tran vdout0_122ck400 FIND v(dout0_122) AT=205.025n

.meas tran vdout0_123ck400 FIND v(dout0_123) AT=205.025n

.meas tran vdout0_124ck400 FIND v(dout0_124) AT=205.025n

.meas tran vdout0_125ck400 FIND v(dout0_125) AT=205.025n

.meas tran vdout0_126ck400 FIND v(dout0_126) AT=205.025n

.meas tran vdout0_127ck400 FIND v(dout0_127) AT=205.025n

.meas tran vdout0_128ck400 FIND v(dout0_128) AT=205.025n

.meas tran vdout0_129ck400 FIND v(dout0_129) AT=205.025n

.meas tran vdout0_130ck400 FIND v(dout0_130) AT=205.025n

.meas tran vdout0_131ck400 FIND v(dout0_131) AT=205.025n

.meas tran vdout0_132ck400 FIND v(dout0_132) AT=205.025n

.meas tran vdout0_133ck400 FIND v(dout0_133) AT=205.025n

.meas tran vdout0_134ck400 FIND v(dout0_134) AT=205.025n

.meas tran vdout0_135ck400 FIND v(dout0_135) AT=205.025n

.meas tran vdout0_136ck400 FIND v(dout0_136) AT=205.025n

.meas tran vdout0_137ck400 FIND v(dout0_137) AT=205.025n

.meas tran vdout0_138ck400 FIND v(dout0_138) AT=205.025n

.meas tran vdout0_139ck400 FIND v(dout0_139) AT=205.025n

.meas tran vdout0_140ck400 FIND v(dout0_140) AT=205.025n

.meas tran vdout0_141ck400 FIND v(dout0_141) AT=205.025n

.meas tran vdout0_142ck400 FIND v(dout0_142) AT=205.025n

.meas tran vdout0_143ck400 FIND v(dout0_143) AT=205.025n

.meas tran vdout0_144ck400 FIND v(dout0_144) AT=205.025n

.meas tran vdout0_145ck400 FIND v(dout0_145) AT=205.025n

.meas tran vdout0_146ck400 FIND v(dout0_146) AT=205.025n

.meas tran vdout0_147ck400 FIND v(dout0_147) AT=205.025n

.meas tran vdout0_148ck400 FIND v(dout0_148) AT=205.025n

.meas tran vdout0_149ck400 FIND v(dout0_149) AT=205.025n

.meas tran vdout0_0ck410 FIND v(dout0_0) AT=210.025n

.meas tran vdout0_1ck410 FIND v(dout0_1) AT=210.025n

.meas tran vdout0_2ck410 FIND v(dout0_2) AT=210.025n

.meas tran vdout0_3ck410 FIND v(dout0_3) AT=210.025n

.meas tran vdout0_4ck410 FIND v(dout0_4) AT=210.025n

.meas tran vdout0_5ck410 FIND v(dout0_5) AT=210.025n

.meas tran vdout0_6ck410 FIND v(dout0_6) AT=210.025n

.meas tran vdout0_7ck410 FIND v(dout0_7) AT=210.025n

.meas tran vdout0_8ck410 FIND v(dout0_8) AT=210.025n

.meas tran vdout0_9ck410 FIND v(dout0_9) AT=210.025n

.meas tran vdout0_10ck410 FIND v(dout0_10) AT=210.025n

.meas tran vdout0_11ck410 FIND v(dout0_11) AT=210.025n

.meas tran vdout0_12ck410 FIND v(dout0_12) AT=210.025n

.meas tran vdout0_13ck410 FIND v(dout0_13) AT=210.025n

.meas tran vdout0_14ck410 FIND v(dout0_14) AT=210.025n

.meas tran vdout0_15ck410 FIND v(dout0_15) AT=210.025n

.meas tran vdout0_16ck410 FIND v(dout0_16) AT=210.025n

.meas tran vdout0_17ck410 FIND v(dout0_17) AT=210.025n

.meas tran vdout0_18ck410 FIND v(dout0_18) AT=210.025n

.meas tran vdout0_19ck410 FIND v(dout0_19) AT=210.025n

.meas tran vdout0_20ck410 FIND v(dout0_20) AT=210.025n

.meas tran vdout0_21ck410 FIND v(dout0_21) AT=210.025n

.meas tran vdout0_22ck410 FIND v(dout0_22) AT=210.025n

.meas tran vdout0_23ck410 FIND v(dout0_23) AT=210.025n

.meas tran vdout0_24ck410 FIND v(dout0_24) AT=210.025n

.meas tran vdout0_25ck410 FIND v(dout0_25) AT=210.025n

.meas tran vdout0_26ck410 FIND v(dout0_26) AT=210.025n

.meas tran vdout0_27ck410 FIND v(dout0_27) AT=210.025n

.meas tran vdout0_28ck410 FIND v(dout0_28) AT=210.025n

.meas tran vdout0_29ck410 FIND v(dout0_29) AT=210.025n

.meas tran vdout0_30ck410 FIND v(dout0_30) AT=210.025n

.meas tran vdout0_31ck410 FIND v(dout0_31) AT=210.025n

.meas tran vdout0_32ck410 FIND v(dout0_32) AT=210.025n

.meas tran vdout0_33ck410 FIND v(dout0_33) AT=210.025n

.meas tran vdout0_34ck410 FIND v(dout0_34) AT=210.025n

.meas tran vdout0_35ck410 FIND v(dout0_35) AT=210.025n

.meas tran vdout0_36ck410 FIND v(dout0_36) AT=210.025n

.meas tran vdout0_37ck410 FIND v(dout0_37) AT=210.025n

.meas tran vdout0_38ck410 FIND v(dout0_38) AT=210.025n

.meas tran vdout0_39ck410 FIND v(dout0_39) AT=210.025n

.meas tran vdout0_40ck410 FIND v(dout0_40) AT=210.025n

.meas tran vdout0_41ck410 FIND v(dout0_41) AT=210.025n

.meas tran vdout0_42ck410 FIND v(dout0_42) AT=210.025n

.meas tran vdout0_43ck410 FIND v(dout0_43) AT=210.025n

.meas tran vdout0_44ck410 FIND v(dout0_44) AT=210.025n

.meas tran vdout0_45ck410 FIND v(dout0_45) AT=210.025n

.meas tran vdout0_46ck410 FIND v(dout0_46) AT=210.025n

.meas tran vdout0_47ck410 FIND v(dout0_47) AT=210.025n

.meas tran vdout0_48ck410 FIND v(dout0_48) AT=210.025n

.meas tran vdout0_49ck410 FIND v(dout0_49) AT=210.025n

.meas tran vdout0_50ck410 FIND v(dout0_50) AT=210.025n

.meas tran vdout0_51ck410 FIND v(dout0_51) AT=210.025n

.meas tran vdout0_52ck410 FIND v(dout0_52) AT=210.025n

.meas tran vdout0_53ck410 FIND v(dout0_53) AT=210.025n

.meas tran vdout0_54ck410 FIND v(dout0_54) AT=210.025n

.meas tran vdout0_55ck410 FIND v(dout0_55) AT=210.025n

.meas tran vdout0_56ck410 FIND v(dout0_56) AT=210.025n

.meas tran vdout0_57ck410 FIND v(dout0_57) AT=210.025n

.meas tran vdout0_58ck410 FIND v(dout0_58) AT=210.025n

.meas tran vdout0_59ck410 FIND v(dout0_59) AT=210.025n

.meas tran vdout0_60ck410 FIND v(dout0_60) AT=210.025n

.meas tran vdout0_61ck410 FIND v(dout0_61) AT=210.025n

.meas tran vdout0_62ck410 FIND v(dout0_62) AT=210.025n

.meas tran vdout0_63ck410 FIND v(dout0_63) AT=210.025n

.meas tran vdout0_64ck410 FIND v(dout0_64) AT=210.025n

.meas tran vdout0_65ck410 FIND v(dout0_65) AT=210.025n

.meas tran vdout0_66ck410 FIND v(dout0_66) AT=210.025n

.meas tran vdout0_67ck410 FIND v(dout0_67) AT=210.025n

.meas tran vdout0_68ck410 FIND v(dout0_68) AT=210.025n

.meas tran vdout0_69ck410 FIND v(dout0_69) AT=210.025n

.meas tran vdout0_70ck410 FIND v(dout0_70) AT=210.025n

.meas tran vdout0_71ck410 FIND v(dout0_71) AT=210.025n

.meas tran vdout0_72ck410 FIND v(dout0_72) AT=210.025n

.meas tran vdout0_73ck410 FIND v(dout0_73) AT=210.025n

.meas tran vdout0_74ck410 FIND v(dout0_74) AT=210.025n

.meas tran vdout0_75ck410 FIND v(dout0_75) AT=210.025n

.meas tran vdout0_76ck410 FIND v(dout0_76) AT=210.025n

.meas tran vdout0_77ck410 FIND v(dout0_77) AT=210.025n

.meas tran vdout0_78ck410 FIND v(dout0_78) AT=210.025n

.meas tran vdout0_79ck410 FIND v(dout0_79) AT=210.025n

.meas tran vdout0_80ck410 FIND v(dout0_80) AT=210.025n

.meas tran vdout0_81ck410 FIND v(dout0_81) AT=210.025n

.meas tran vdout0_82ck410 FIND v(dout0_82) AT=210.025n

.meas tran vdout0_83ck410 FIND v(dout0_83) AT=210.025n

.meas tran vdout0_84ck410 FIND v(dout0_84) AT=210.025n

.meas tran vdout0_85ck410 FIND v(dout0_85) AT=210.025n

.meas tran vdout0_86ck410 FIND v(dout0_86) AT=210.025n

.meas tran vdout0_87ck410 FIND v(dout0_87) AT=210.025n

.meas tran vdout0_88ck410 FIND v(dout0_88) AT=210.025n

.meas tran vdout0_89ck410 FIND v(dout0_89) AT=210.025n

.meas tran vdout0_90ck410 FIND v(dout0_90) AT=210.025n

.meas tran vdout0_91ck410 FIND v(dout0_91) AT=210.025n

.meas tran vdout0_92ck410 FIND v(dout0_92) AT=210.025n

.meas tran vdout0_93ck410 FIND v(dout0_93) AT=210.025n

.meas tran vdout0_94ck410 FIND v(dout0_94) AT=210.025n

.meas tran vdout0_95ck410 FIND v(dout0_95) AT=210.025n

.meas tran vdout0_96ck410 FIND v(dout0_96) AT=210.025n

.meas tran vdout0_97ck410 FIND v(dout0_97) AT=210.025n

.meas tran vdout0_98ck410 FIND v(dout0_98) AT=210.025n

.meas tran vdout0_99ck410 FIND v(dout0_99) AT=210.025n

.meas tran vdout0_100ck410 FIND v(dout0_100) AT=210.025n

.meas tran vdout0_101ck410 FIND v(dout0_101) AT=210.025n

.meas tran vdout0_102ck410 FIND v(dout0_102) AT=210.025n

.meas tran vdout0_103ck410 FIND v(dout0_103) AT=210.025n

.meas tran vdout0_104ck410 FIND v(dout0_104) AT=210.025n

.meas tran vdout0_105ck410 FIND v(dout0_105) AT=210.025n

.meas tran vdout0_106ck410 FIND v(dout0_106) AT=210.025n

.meas tran vdout0_107ck410 FIND v(dout0_107) AT=210.025n

.meas tran vdout0_108ck410 FIND v(dout0_108) AT=210.025n

.meas tran vdout0_109ck410 FIND v(dout0_109) AT=210.025n

.meas tran vdout0_110ck410 FIND v(dout0_110) AT=210.025n

.meas tran vdout0_111ck410 FIND v(dout0_111) AT=210.025n

.meas tran vdout0_112ck410 FIND v(dout0_112) AT=210.025n

.meas tran vdout0_113ck410 FIND v(dout0_113) AT=210.025n

.meas tran vdout0_114ck410 FIND v(dout0_114) AT=210.025n

.meas tran vdout0_115ck410 FIND v(dout0_115) AT=210.025n

.meas tran vdout0_116ck410 FIND v(dout0_116) AT=210.025n

.meas tran vdout0_117ck410 FIND v(dout0_117) AT=210.025n

.meas tran vdout0_118ck410 FIND v(dout0_118) AT=210.025n

.meas tran vdout0_119ck410 FIND v(dout0_119) AT=210.025n

.meas tran vdout0_120ck410 FIND v(dout0_120) AT=210.025n

.meas tran vdout0_121ck410 FIND v(dout0_121) AT=210.025n

.meas tran vdout0_122ck410 FIND v(dout0_122) AT=210.025n

.meas tran vdout0_123ck410 FIND v(dout0_123) AT=210.025n

.meas tran vdout0_124ck410 FIND v(dout0_124) AT=210.025n

.meas tran vdout0_125ck410 FIND v(dout0_125) AT=210.025n

.meas tran vdout0_126ck410 FIND v(dout0_126) AT=210.025n

.meas tran vdout0_127ck410 FIND v(dout0_127) AT=210.025n

.meas tran vdout0_128ck410 FIND v(dout0_128) AT=210.025n

.meas tran vdout0_129ck410 FIND v(dout0_129) AT=210.025n

.meas tran vdout0_130ck410 FIND v(dout0_130) AT=210.025n

.meas tran vdout0_131ck410 FIND v(dout0_131) AT=210.025n

.meas tran vdout0_132ck410 FIND v(dout0_132) AT=210.025n

.meas tran vdout0_133ck410 FIND v(dout0_133) AT=210.025n

.meas tran vdout0_134ck410 FIND v(dout0_134) AT=210.025n

.meas tran vdout0_135ck410 FIND v(dout0_135) AT=210.025n

.meas tran vdout0_136ck410 FIND v(dout0_136) AT=210.025n

.meas tran vdout0_137ck410 FIND v(dout0_137) AT=210.025n

.meas tran vdout0_138ck410 FIND v(dout0_138) AT=210.025n

.meas tran vdout0_139ck410 FIND v(dout0_139) AT=210.025n

.meas tran vdout0_140ck410 FIND v(dout0_140) AT=210.025n

.meas tran vdout0_141ck410 FIND v(dout0_141) AT=210.025n

.meas tran vdout0_142ck410 FIND v(dout0_142) AT=210.025n

.meas tran vdout0_143ck410 FIND v(dout0_143) AT=210.025n

.meas tran vdout0_144ck410 FIND v(dout0_144) AT=210.025n

.meas tran vdout0_145ck410 FIND v(dout0_145) AT=210.025n

.meas tran vdout0_146ck410 FIND v(dout0_146) AT=210.025n

.meas tran vdout0_147ck410 FIND v(dout0_147) AT=210.025n

.meas tran vdout0_148ck410 FIND v(dout0_148) AT=210.025n

.meas tran vdout0_149ck410 FIND v(dout0_149) AT=210.025n

.meas tran vdout0_0ck420 FIND v(dout0_0) AT=215.025n

.meas tran vdout0_1ck420 FIND v(dout0_1) AT=215.025n

.meas tran vdout0_2ck420 FIND v(dout0_2) AT=215.025n

.meas tran vdout0_3ck420 FIND v(dout0_3) AT=215.025n

.meas tran vdout0_4ck420 FIND v(dout0_4) AT=215.025n

.meas tran vdout0_5ck420 FIND v(dout0_5) AT=215.025n

.meas tran vdout0_6ck420 FIND v(dout0_6) AT=215.025n

.meas tran vdout0_7ck420 FIND v(dout0_7) AT=215.025n

.meas tran vdout0_8ck420 FIND v(dout0_8) AT=215.025n

.meas tran vdout0_9ck420 FIND v(dout0_9) AT=215.025n

.meas tran vdout0_10ck420 FIND v(dout0_10) AT=215.025n

.meas tran vdout0_11ck420 FIND v(dout0_11) AT=215.025n

.meas tran vdout0_12ck420 FIND v(dout0_12) AT=215.025n

.meas tran vdout0_13ck420 FIND v(dout0_13) AT=215.025n

.meas tran vdout0_14ck420 FIND v(dout0_14) AT=215.025n

.meas tran vdout0_15ck420 FIND v(dout0_15) AT=215.025n

.meas tran vdout0_16ck420 FIND v(dout0_16) AT=215.025n

.meas tran vdout0_17ck420 FIND v(dout0_17) AT=215.025n

.meas tran vdout0_18ck420 FIND v(dout0_18) AT=215.025n

.meas tran vdout0_19ck420 FIND v(dout0_19) AT=215.025n

.meas tran vdout0_20ck420 FIND v(dout0_20) AT=215.025n

.meas tran vdout0_21ck420 FIND v(dout0_21) AT=215.025n

.meas tran vdout0_22ck420 FIND v(dout0_22) AT=215.025n

.meas tran vdout0_23ck420 FIND v(dout0_23) AT=215.025n

.meas tran vdout0_24ck420 FIND v(dout0_24) AT=215.025n

.meas tran vdout0_25ck420 FIND v(dout0_25) AT=215.025n

.meas tran vdout0_26ck420 FIND v(dout0_26) AT=215.025n

.meas tran vdout0_27ck420 FIND v(dout0_27) AT=215.025n

.meas tran vdout0_28ck420 FIND v(dout0_28) AT=215.025n

.meas tran vdout0_29ck420 FIND v(dout0_29) AT=215.025n

.meas tran vdout0_30ck420 FIND v(dout0_30) AT=215.025n

.meas tran vdout0_31ck420 FIND v(dout0_31) AT=215.025n

.meas tran vdout0_32ck420 FIND v(dout0_32) AT=215.025n

.meas tran vdout0_33ck420 FIND v(dout0_33) AT=215.025n

.meas tran vdout0_34ck420 FIND v(dout0_34) AT=215.025n

.meas tran vdout0_35ck420 FIND v(dout0_35) AT=215.025n

.meas tran vdout0_36ck420 FIND v(dout0_36) AT=215.025n

.meas tran vdout0_37ck420 FIND v(dout0_37) AT=215.025n

.meas tran vdout0_38ck420 FIND v(dout0_38) AT=215.025n

.meas tran vdout0_39ck420 FIND v(dout0_39) AT=215.025n

.meas tran vdout0_40ck420 FIND v(dout0_40) AT=215.025n

.meas tran vdout0_41ck420 FIND v(dout0_41) AT=215.025n

.meas tran vdout0_42ck420 FIND v(dout0_42) AT=215.025n

.meas tran vdout0_43ck420 FIND v(dout0_43) AT=215.025n

.meas tran vdout0_44ck420 FIND v(dout0_44) AT=215.025n

.meas tran vdout0_45ck420 FIND v(dout0_45) AT=215.025n

.meas tran vdout0_46ck420 FIND v(dout0_46) AT=215.025n

.meas tran vdout0_47ck420 FIND v(dout0_47) AT=215.025n

.meas tran vdout0_48ck420 FIND v(dout0_48) AT=215.025n

.meas tran vdout0_49ck420 FIND v(dout0_49) AT=215.025n

.meas tran vdout0_50ck420 FIND v(dout0_50) AT=215.025n

.meas tran vdout0_51ck420 FIND v(dout0_51) AT=215.025n

.meas tran vdout0_52ck420 FIND v(dout0_52) AT=215.025n

.meas tran vdout0_53ck420 FIND v(dout0_53) AT=215.025n

.meas tran vdout0_54ck420 FIND v(dout0_54) AT=215.025n

.meas tran vdout0_55ck420 FIND v(dout0_55) AT=215.025n

.meas tran vdout0_56ck420 FIND v(dout0_56) AT=215.025n

.meas tran vdout0_57ck420 FIND v(dout0_57) AT=215.025n

.meas tran vdout0_58ck420 FIND v(dout0_58) AT=215.025n

.meas tran vdout0_59ck420 FIND v(dout0_59) AT=215.025n

.meas tran vdout0_60ck420 FIND v(dout0_60) AT=215.025n

.meas tran vdout0_61ck420 FIND v(dout0_61) AT=215.025n

.meas tran vdout0_62ck420 FIND v(dout0_62) AT=215.025n

.meas tran vdout0_63ck420 FIND v(dout0_63) AT=215.025n

.meas tran vdout0_64ck420 FIND v(dout0_64) AT=215.025n

.meas tran vdout0_65ck420 FIND v(dout0_65) AT=215.025n

.meas tran vdout0_66ck420 FIND v(dout0_66) AT=215.025n

.meas tran vdout0_67ck420 FIND v(dout0_67) AT=215.025n

.meas tran vdout0_68ck420 FIND v(dout0_68) AT=215.025n

.meas tran vdout0_69ck420 FIND v(dout0_69) AT=215.025n

.meas tran vdout0_70ck420 FIND v(dout0_70) AT=215.025n

.meas tran vdout0_71ck420 FIND v(dout0_71) AT=215.025n

.meas tran vdout0_72ck420 FIND v(dout0_72) AT=215.025n

.meas tran vdout0_73ck420 FIND v(dout0_73) AT=215.025n

.meas tran vdout0_74ck420 FIND v(dout0_74) AT=215.025n

.meas tran vdout0_75ck420 FIND v(dout0_75) AT=215.025n

.meas tran vdout0_76ck420 FIND v(dout0_76) AT=215.025n

.meas tran vdout0_77ck420 FIND v(dout0_77) AT=215.025n

.meas tran vdout0_78ck420 FIND v(dout0_78) AT=215.025n

.meas tran vdout0_79ck420 FIND v(dout0_79) AT=215.025n

.meas tran vdout0_80ck420 FIND v(dout0_80) AT=215.025n

.meas tran vdout0_81ck420 FIND v(dout0_81) AT=215.025n

.meas tran vdout0_82ck420 FIND v(dout0_82) AT=215.025n

.meas tran vdout0_83ck420 FIND v(dout0_83) AT=215.025n

.meas tran vdout0_84ck420 FIND v(dout0_84) AT=215.025n

.meas tran vdout0_85ck420 FIND v(dout0_85) AT=215.025n

.meas tran vdout0_86ck420 FIND v(dout0_86) AT=215.025n

.meas tran vdout0_87ck420 FIND v(dout0_87) AT=215.025n

.meas tran vdout0_88ck420 FIND v(dout0_88) AT=215.025n

.meas tran vdout0_89ck420 FIND v(dout0_89) AT=215.025n

.meas tran vdout0_90ck420 FIND v(dout0_90) AT=215.025n

.meas tran vdout0_91ck420 FIND v(dout0_91) AT=215.025n

.meas tran vdout0_92ck420 FIND v(dout0_92) AT=215.025n

.meas tran vdout0_93ck420 FIND v(dout0_93) AT=215.025n

.meas tran vdout0_94ck420 FIND v(dout0_94) AT=215.025n

.meas tran vdout0_95ck420 FIND v(dout0_95) AT=215.025n

.meas tran vdout0_96ck420 FIND v(dout0_96) AT=215.025n

.meas tran vdout0_97ck420 FIND v(dout0_97) AT=215.025n

.meas tran vdout0_98ck420 FIND v(dout0_98) AT=215.025n

.meas tran vdout0_99ck420 FIND v(dout0_99) AT=215.025n

.meas tran vdout0_100ck420 FIND v(dout0_100) AT=215.025n

.meas tran vdout0_101ck420 FIND v(dout0_101) AT=215.025n

.meas tran vdout0_102ck420 FIND v(dout0_102) AT=215.025n

.meas tran vdout0_103ck420 FIND v(dout0_103) AT=215.025n

.meas tran vdout0_104ck420 FIND v(dout0_104) AT=215.025n

.meas tran vdout0_105ck420 FIND v(dout0_105) AT=215.025n

.meas tran vdout0_106ck420 FIND v(dout0_106) AT=215.025n

.meas tran vdout0_107ck420 FIND v(dout0_107) AT=215.025n

.meas tran vdout0_108ck420 FIND v(dout0_108) AT=215.025n

.meas tran vdout0_109ck420 FIND v(dout0_109) AT=215.025n

.meas tran vdout0_110ck420 FIND v(dout0_110) AT=215.025n

.meas tran vdout0_111ck420 FIND v(dout0_111) AT=215.025n

.meas tran vdout0_112ck420 FIND v(dout0_112) AT=215.025n

.meas tran vdout0_113ck420 FIND v(dout0_113) AT=215.025n

.meas tran vdout0_114ck420 FIND v(dout0_114) AT=215.025n

.meas tran vdout0_115ck420 FIND v(dout0_115) AT=215.025n

.meas tran vdout0_116ck420 FIND v(dout0_116) AT=215.025n

.meas tran vdout0_117ck420 FIND v(dout0_117) AT=215.025n

.meas tran vdout0_118ck420 FIND v(dout0_118) AT=215.025n

.meas tran vdout0_119ck420 FIND v(dout0_119) AT=215.025n

.meas tran vdout0_120ck420 FIND v(dout0_120) AT=215.025n

.meas tran vdout0_121ck420 FIND v(dout0_121) AT=215.025n

.meas tran vdout0_122ck420 FIND v(dout0_122) AT=215.025n

.meas tran vdout0_123ck420 FIND v(dout0_123) AT=215.025n

.meas tran vdout0_124ck420 FIND v(dout0_124) AT=215.025n

.meas tran vdout0_125ck420 FIND v(dout0_125) AT=215.025n

.meas tran vdout0_126ck420 FIND v(dout0_126) AT=215.025n

.meas tran vdout0_127ck420 FIND v(dout0_127) AT=215.025n

.meas tran vdout0_128ck420 FIND v(dout0_128) AT=215.025n

.meas tran vdout0_129ck420 FIND v(dout0_129) AT=215.025n

.meas tran vdout0_130ck420 FIND v(dout0_130) AT=215.025n

.meas tran vdout0_131ck420 FIND v(dout0_131) AT=215.025n

.meas tran vdout0_132ck420 FIND v(dout0_132) AT=215.025n

.meas tran vdout0_133ck420 FIND v(dout0_133) AT=215.025n

.meas tran vdout0_134ck420 FIND v(dout0_134) AT=215.025n

.meas tran vdout0_135ck420 FIND v(dout0_135) AT=215.025n

.meas tran vdout0_136ck420 FIND v(dout0_136) AT=215.025n

.meas tran vdout0_137ck420 FIND v(dout0_137) AT=215.025n

.meas tran vdout0_138ck420 FIND v(dout0_138) AT=215.025n

.meas tran vdout0_139ck420 FIND v(dout0_139) AT=215.025n

.meas tran vdout0_140ck420 FIND v(dout0_140) AT=215.025n

.meas tran vdout0_141ck420 FIND v(dout0_141) AT=215.025n

.meas tran vdout0_142ck420 FIND v(dout0_142) AT=215.025n

.meas tran vdout0_143ck420 FIND v(dout0_143) AT=215.025n

.meas tran vdout0_144ck420 FIND v(dout0_144) AT=215.025n

.meas tran vdout0_145ck420 FIND v(dout0_145) AT=215.025n

.meas tran vdout0_146ck420 FIND v(dout0_146) AT=215.025n

.meas tran vdout0_147ck420 FIND v(dout0_147) AT=215.025n

.meas tran vdout0_148ck420 FIND v(dout0_148) AT=215.025n

.meas tran vdout0_149ck420 FIND v(dout0_149) AT=215.025n

.meas tran vdout0_0ck450 FIND v(dout0_0) AT=230.025n

.meas tran vdout0_1ck450 FIND v(dout0_1) AT=230.025n

.meas tran vdout0_2ck450 FIND v(dout0_2) AT=230.025n

.meas tran vdout0_3ck450 FIND v(dout0_3) AT=230.025n

.meas tran vdout0_4ck450 FIND v(dout0_4) AT=230.025n

.meas tran vdout0_5ck450 FIND v(dout0_5) AT=230.025n

.meas tran vdout0_6ck450 FIND v(dout0_6) AT=230.025n

.meas tran vdout0_7ck450 FIND v(dout0_7) AT=230.025n

.meas tran vdout0_8ck450 FIND v(dout0_8) AT=230.025n

.meas tran vdout0_9ck450 FIND v(dout0_9) AT=230.025n

.meas tran vdout0_10ck450 FIND v(dout0_10) AT=230.025n

.meas tran vdout0_11ck450 FIND v(dout0_11) AT=230.025n

.meas tran vdout0_12ck450 FIND v(dout0_12) AT=230.025n

.meas tran vdout0_13ck450 FIND v(dout0_13) AT=230.025n

.meas tran vdout0_14ck450 FIND v(dout0_14) AT=230.025n

.meas tran vdout0_15ck450 FIND v(dout0_15) AT=230.025n

.meas tran vdout0_16ck450 FIND v(dout0_16) AT=230.025n

.meas tran vdout0_17ck450 FIND v(dout0_17) AT=230.025n

.meas tran vdout0_18ck450 FIND v(dout0_18) AT=230.025n

.meas tran vdout0_19ck450 FIND v(dout0_19) AT=230.025n

.meas tran vdout0_20ck450 FIND v(dout0_20) AT=230.025n

.meas tran vdout0_21ck450 FIND v(dout0_21) AT=230.025n

.meas tran vdout0_22ck450 FIND v(dout0_22) AT=230.025n

.meas tran vdout0_23ck450 FIND v(dout0_23) AT=230.025n

.meas tran vdout0_24ck450 FIND v(dout0_24) AT=230.025n

.meas tran vdout0_25ck450 FIND v(dout0_25) AT=230.025n

.meas tran vdout0_26ck450 FIND v(dout0_26) AT=230.025n

.meas tran vdout0_27ck450 FIND v(dout0_27) AT=230.025n

.meas tran vdout0_28ck450 FIND v(dout0_28) AT=230.025n

.meas tran vdout0_29ck450 FIND v(dout0_29) AT=230.025n

.meas tran vdout0_30ck450 FIND v(dout0_30) AT=230.025n

.meas tran vdout0_31ck450 FIND v(dout0_31) AT=230.025n

.meas tran vdout0_32ck450 FIND v(dout0_32) AT=230.025n

.meas tran vdout0_33ck450 FIND v(dout0_33) AT=230.025n

.meas tran vdout0_34ck450 FIND v(dout0_34) AT=230.025n

.meas tran vdout0_35ck450 FIND v(dout0_35) AT=230.025n

.meas tran vdout0_36ck450 FIND v(dout0_36) AT=230.025n

.meas tran vdout0_37ck450 FIND v(dout0_37) AT=230.025n

.meas tran vdout0_38ck450 FIND v(dout0_38) AT=230.025n

.meas tran vdout0_39ck450 FIND v(dout0_39) AT=230.025n

.meas tran vdout0_40ck450 FIND v(dout0_40) AT=230.025n

.meas tran vdout0_41ck450 FIND v(dout0_41) AT=230.025n

.meas tran vdout0_42ck450 FIND v(dout0_42) AT=230.025n

.meas tran vdout0_43ck450 FIND v(dout0_43) AT=230.025n

.meas tran vdout0_44ck450 FIND v(dout0_44) AT=230.025n

.meas tran vdout0_45ck450 FIND v(dout0_45) AT=230.025n

.meas tran vdout0_46ck450 FIND v(dout0_46) AT=230.025n

.meas tran vdout0_47ck450 FIND v(dout0_47) AT=230.025n

.meas tran vdout0_48ck450 FIND v(dout0_48) AT=230.025n

.meas tran vdout0_49ck450 FIND v(dout0_49) AT=230.025n

.meas tran vdout0_50ck450 FIND v(dout0_50) AT=230.025n

.meas tran vdout0_51ck450 FIND v(dout0_51) AT=230.025n

.meas tran vdout0_52ck450 FIND v(dout0_52) AT=230.025n

.meas tran vdout0_53ck450 FIND v(dout0_53) AT=230.025n

.meas tran vdout0_54ck450 FIND v(dout0_54) AT=230.025n

.meas tran vdout0_55ck450 FIND v(dout0_55) AT=230.025n

.meas tran vdout0_56ck450 FIND v(dout0_56) AT=230.025n

.meas tran vdout0_57ck450 FIND v(dout0_57) AT=230.025n

.meas tran vdout0_58ck450 FIND v(dout0_58) AT=230.025n

.meas tran vdout0_59ck450 FIND v(dout0_59) AT=230.025n

.meas tran vdout0_60ck450 FIND v(dout0_60) AT=230.025n

.meas tran vdout0_61ck450 FIND v(dout0_61) AT=230.025n

.meas tran vdout0_62ck450 FIND v(dout0_62) AT=230.025n

.meas tran vdout0_63ck450 FIND v(dout0_63) AT=230.025n

.meas tran vdout0_64ck450 FIND v(dout0_64) AT=230.025n

.meas tran vdout0_65ck450 FIND v(dout0_65) AT=230.025n

.meas tran vdout0_66ck450 FIND v(dout0_66) AT=230.025n

.meas tran vdout0_67ck450 FIND v(dout0_67) AT=230.025n

.meas tran vdout0_68ck450 FIND v(dout0_68) AT=230.025n

.meas tran vdout0_69ck450 FIND v(dout0_69) AT=230.025n

.meas tran vdout0_70ck450 FIND v(dout0_70) AT=230.025n

.meas tran vdout0_71ck450 FIND v(dout0_71) AT=230.025n

.meas tran vdout0_72ck450 FIND v(dout0_72) AT=230.025n

.meas tran vdout0_73ck450 FIND v(dout0_73) AT=230.025n

.meas tran vdout0_74ck450 FIND v(dout0_74) AT=230.025n

.meas tran vdout0_75ck450 FIND v(dout0_75) AT=230.025n

.meas tran vdout0_76ck450 FIND v(dout0_76) AT=230.025n

.meas tran vdout0_77ck450 FIND v(dout0_77) AT=230.025n

.meas tran vdout0_78ck450 FIND v(dout0_78) AT=230.025n

.meas tran vdout0_79ck450 FIND v(dout0_79) AT=230.025n

.meas tran vdout0_80ck450 FIND v(dout0_80) AT=230.025n

.meas tran vdout0_81ck450 FIND v(dout0_81) AT=230.025n

.meas tran vdout0_82ck450 FIND v(dout0_82) AT=230.025n

.meas tran vdout0_83ck450 FIND v(dout0_83) AT=230.025n

.meas tran vdout0_84ck450 FIND v(dout0_84) AT=230.025n

.meas tran vdout0_85ck450 FIND v(dout0_85) AT=230.025n

.meas tran vdout0_86ck450 FIND v(dout0_86) AT=230.025n

.meas tran vdout0_87ck450 FIND v(dout0_87) AT=230.025n

.meas tran vdout0_88ck450 FIND v(dout0_88) AT=230.025n

.meas tran vdout0_89ck450 FIND v(dout0_89) AT=230.025n

.meas tran vdout0_90ck450 FIND v(dout0_90) AT=230.025n

.meas tran vdout0_91ck450 FIND v(dout0_91) AT=230.025n

.meas tran vdout0_92ck450 FIND v(dout0_92) AT=230.025n

.meas tran vdout0_93ck450 FIND v(dout0_93) AT=230.025n

.meas tran vdout0_94ck450 FIND v(dout0_94) AT=230.025n

.meas tran vdout0_95ck450 FIND v(dout0_95) AT=230.025n

.meas tran vdout0_96ck450 FIND v(dout0_96) AT=230.025n

.meas tran vdout0_97ck450 FIND v(dout0_97) AT=230.025n

.meas tran vdout0_98ck450 FIND v(dout0_98) AT=230.025n

.meas tran vdout0_99ck450 FIND v(dout0_99) AT=230.025n

.meas tran vdout0_100ck450 FIND v(dout0_100) AT=230.025n

.meas tran vdout0_101ck450 FIND v(dout0_101) AT=230.025n

.meas tran vdout0_102ck450 FIND v(dout0_102) AT=230.025n

.meas tran vdout0_103ck450 FIND v(dout0_103) AT=230.025n

.meas tran vdout0_104ck450 FIND v(dout0_104) AT=230.025n

.meas tran vdout0_105ck450 FIND v(dout0_105) AT=230.025n

.meas tran vdout0_106ck450 FIND v(dout0_106) AT=230.025n

.meas tran vdout0_107ck450 FIND v(dout0_107) AT=230.025n

.meas tran vdout0_108ck450 FIND v(dout0_108) AT=230.025n

.meas tran vdout0_109ck450 FIND v(dout0_109) AT=230.025n

.meas tran vdout0_110ck450 FIND v(dout0_110) AT=230.025n

.meas tran vdout0_111ck450 FIND v(dout0_111) AT=230.025n

.meas tran vdout0_112ck450 FIND v(dout0_112) AT=230.025n

.meas tran vdout0_113ck450 FIND v(dout0_113) AT=230.025n

.meas tran vdout0_114ck450 FIND v(dout0_114) AT=230.025n

.meas tran vdout0_115ck450 FIND v(dout0_115) AT=230.025n

.meas tran vdout0_116ck450 FIND v(dout0_116) AT=230.025n

.meas tran vdout0_117ck450 FIND v(dout0_117) AT=230.025n

.meas tran vdout0_118ck450 FIND v(dout0_118) AT=230.025n

.meas tran vdout0_119ck450 FIND v(dout0_119) AT=230.025n

.meas tran vdout0_120ck450 FIND v(dout0_120) AT=230.025n

.meas tran vdout0_121ck450 FIND v(dout0_121) AT=230.025n

.meas tran vdout0_122ck450 FIND v(dout0_122) AT=230.025n

.meas tran vdout0_123ck450 FIND v(dout0_123) AT=230.025n

.meas tran vdout0_124ck450 FIND v(dout0_124) AT=230.025n

.meas tran vdout0_125ck450 FIND v(dout0_125) AT=230.025n

.meas tran vdout0_126ck450 FIND v(dout0_126) AT=230.025n

.meas tran vdout0_127ck450 FIND v(dout0_127) AT=230.025n

.meas tran vdout0_128ck450 FIND v(dout0_128) AT=230.025n

.meas tran vdout0_129ck450 FIND v(dout0_129) AT=230.025n

.meas tran vdout0_130ck450 FIND v(dout0_130) AT=230.025n

.meas tran vdout0_131ck450 FIND v(dout0_131) AT=230.025n

.meas tran vdout0_132ck450 FIND v(dout0_132) AT=230.025n

.meas tran vdout0_133ck450 FIND v(dout0_133) AT=230.025n

.meas tran vdout0_134ck450 FIND v(dout0_134) AT=230.025n

.meas tran vdout0_135ck450 FIND v(dout0_135) AT=230.025n

.meas tran vdout0_136ck450 FIND v(dout0_136) AT=230.025n

.meas tran vdout0_137ck450 FIND v(dout0_137) AT=230.025n

.meas tran vdout0_138ck450 FIND v(dout0_138) AT=230.025n

.meas tran vdout0_139ck450 FIND v(dout0_139) AT=230.025n

.meas tran vdout0_140ck450 FIND v(dout0_140) AT=230.025n

.meas tran vdout0_141ck450 FIND v(dout0_141) AT=230.025n

.meas tran vdout0_142ck450 FIND v(dout0_142) AT=230.025n

.meas tran vdout0_143ck450 FIND v(dout0_143) AT=230.025n

.meas tran vdout0_144ck450 FIND v(dout0_144) AT=230.025n

.meas tran vdout0_145ck450 FIND v(dout0_145) AT=230.025n

.meas tran vdout0_146ck450 FIND v(dout0_146) AT=230.025n

.meas tran vdout0_147ck450 FIND v(dout0_147) AT=230.025n

.meas tran vdout0_148ck450 FIND v(dout0_148) AT=230.025n

.meas tran vdout0_149ck450 FIND v(dout0_149) AT=230.025n

.meas tran vdout0_0ck480 FIND v(dout0_0) AT=245.025n

.meas tran vdout0_1ck480 FIND v(dout0_1) AT=245.025n

.meas tran vdout0_2ck480 FIND v(dout0_2) AT=245.025n

.meas tran vdout0_3ck480 FIND v(dout0_3) AT=245.025n

.meas tran vdout0_4ck480 FIND v(dout0_4) AT=245.025n

.meas tran vdout0_5ck480 FIND v(dout0_5) AT=245.025n

.meas tran vdout0_6ck480 FIND v(dout0_6) AT=245.025n

.meas tran vdout0_7ck480 FIND v(dout0_7) AT=245.025n

.meas tran vdout0_8ck480 FIND v(dout0_8) AT=245.025n

.meas tran vdout0_9ck480 FIND v(dout0_9) AT=245.025n

.meas tran vdout0_10ck480 FIND v(dout0_10) AT=245.025n

.meas tran vdout0_11ck480 FIND v(dout0_11) AT=245.025n

.meas tran vdout0_12ck480 FIND v(dout0_12) AT=245.025n

.meas tran vdout0_13ck480 FIND v(dout0_13) AT=245.025n

.meas tran vdout0_14ck480 FIND v(dout0_14) AT=245.025n

.meas tran vdout0_15ck480 FIND v(dout0_15) AT=245.025n

.meas tran vdout0_16ck480 FIND v(dout0_16) AT=245.025n

.meas tran vdout0_17ck480 FIND v(dout0_17) AT=245.025n

.meas tran vdout0_18ck480 FIND v(dout0_18) AT=245.025n

.meas tran vdout0_19ck480 FIND v(dout0_19) AT=245.025n

.meas tran vdout0_20ck480 FIND v(dout0_20) AT=245.025n

.meas tran vdout0_21ck480 FIND v(dout0_21) AT=245.025n

.meas tran vdout0_22ck480 FIND v(dout0_22) AT=245.025n

.meas tran vdout0_23ck480 FIND v(dout0_23) AT=245.025n

.meas tran vdout0_24ck480 FIND v(dout0_24) AT=245.025n

.meas tran vdout0_25ck480 FIND v(dout0_25) AT=245.025n

.meas tran vdout0_26ck480 FIND v(dout0_26) AT=245.025n

.meas tran vdout0_27ck480 FIND v(dout0_27) AT=245.025n

.meas tran vdout0_28ck480 FIND v(dout0_28) AT=245.025n

.meas tran vdout0_29ck480 FIND v(dout0_29) AT=245.025n

.meas tran vdout0_30ck480 FIND v(dout0_30) AT=245.025n

.meas tran vdout0_31ck480 FIND v(dout0_31) AT=245.025n

.meas tran vdout0_32ck480 FIND v(dout0_32) AT=245.025n

.meas tran vdout0_33ck480 FIND v(dout0_33) AT=245.025n

.meas tran vdout0_34ck480 FIND v(dout0_34) AT=245.025n

.meas tran vdout0_35ck480 FIND v(dout0_35) AT=245.025n

.meas tran vdout0_36ck480 FIND v(dout0_36) AT=245.025n

.meas tran vdout0_37ck480 FIND v(dout0_37) AT=245.025n

.meas tran vdout0_38ck480 FIND v(dout0_38) AT=245.025n

.meas tran vdout0_39ck480 FIND v(dout0_39) AT=245.025n

.meas tran vdout0_40ck480 FIND v(dout0_40) AT=245.025n

.meas tran vdout0_41ck480 FIND v(dout0_41) AT=245.025n

.meas tran vdout0_42ck480 FIND v(dout0_42) AT=245.025n

.meas tran vdout0_43ck480 FIND v(dout0_43) AT=245.025n

.meas tran vdout0_44ck480 FIND v(dout0_44) AT=245.025n

.meas tran vdout0_45ck480 FIND v(dout0_45) AT=245.025n

.meas tran vdout0_46ck480 FIND v(dout0_46) AT=245.025n

.meas tran vdout0_47ck480 FIND v(dout0_47) AT=245.025n

.meas tran vdout0_48ck480 FIND v(dout0_48) AT=245.025n

.meas tran vdout0_49ck480 FIND v(dout0_49) AT=245.025n

.meas tran vdout0_50ck480 FIND v(dout0_50) AT=245.025n

.meas tran vdout0_51ck480 FIND v(dout0_51) AT=245.025n

.meas tran vdout0_52ck480 FIND v(dout0_52) AT=245.025n

.meas tran vdout0_53ck480 FIND v(dout0_53) AT=245.025n

.meas tran vdout0_54ck480 FIND v(dout0_54) AT=245.025n

.meas tran vdout0_55ck480 FIND v(dout0_55) AT=245.025n

.meas tran vdout0_56ck480 FIND v(dout0_56) AT=245.025n

.meas tran vdout0_57ck480 FIND v(dout0_57) AT=245.025n

.meas tran vdout0_58ck480 FIND v(dout0_58) AT=245.025n

.meas tran vdout0_59ck480 FIND v(dout0_59) AT=245.025n

.meas tran vdout0_60ck480 FIND v(dout0_60) AT=245.025n

.meas tran vdout0_61ck480 FIND v(dout0_61) AT=245.025n

.meas tran vdout0_62ck480 FIND v(dout0_62) AT=245.025n

.meas tran vdout0_63ck480 FIND v(dout0_63) AT=245.025n

.meas tran vdout0_64ck480 FIND v(dout0_64) AT=245.025n

.meas tran vdout0_65ck480 FIND v(dout0_65) AT=245.025n

.meas tran vdout0_66ck480 FIND v(dout0_66) AT=245.025n

.meas tran vdout0_67ck480 FIND v(dout0_67) AT=245.025n

.meas tran vdout0_68ck480 FIND v(dout0_68) AT=245.025n

.meas tran vdout0_69ck480 FIND v(dout0_69) AT=245.025n

.meas tran vdout0_70ck480 FIND v(dout0_70) AT=245.025n

.meas tran vdout0_71ck480 FIND v(dout0_71) AT=245.025n

.meas tran vdout0_72ck480 FIND v(dout0_72) AT=245.025n

.meas tran vdout0_73ck480 FIND v(dout0_73) AT=245.025n

.meas tran vdout0_74ck480 FIND v(dout0_74) AT=245.025n

.meas tran vdout0_75ck480 FIND v(dout0_75) AT=245.025n

.meas tran vdout0_76ck480 FIND v(dout0_76) AT=245.025n

.meas tran vdout0_77ck480 FIND v(dout0_77) AT=245.025n

.meas tran vdout0_78ck480 FIND v(dout0_78) AT=245.025n

.meas tran vdout0_79ck480 FIND v(dout0_79) AT=245.025n

.meas tran vdout0_80ck480 FIND v(dout0_80) AT=245.025n

.meas tran vdout0_81ck480 FIND v(dout0_81) AT=245.025n

.meas tran vdout0_82ck480 FIND v(dout0_82) AT=245.025n

.meas tran vdout0_83ck480 FIND v(dout0_83) AT=245.025n

.meas tran vdout0_84ck480 FIND v(dout0_84) AT=245.025n

.meas tran vdout0_85ck480 FIND v(dout0_85) AT=245.025n

.meas tran vdout0_86ck480 FIND v(dout0_86) AT=245.025n

.meas tran vdout0_87ck480 FIND v(dout0_87) AT=245.025n

.meas tran vdout0_88ck480 FIND v(dout0_88) AT=245.025n

.meas tran vdout0_89ck480 FIND v(dout0_89) AT=245.025n

.meas tran vdout0_90ck480 FIND v(dout0_90) AT=245.025n

.meas tran vdout0_91ck480 FIND v(dout0_91) AT=245.025n

.meas tran vdout0_92ck480 FIND v(dout0_92) AT=245.025n

.meas tran vdout0_93ck480 FIND v(dout0_93) AT=245.025n

.meas tran vdout0_94ck480 FIND v(dout0_94) AT=245.025n

.meas tran vdout0_95ck480 FIND v(dout0_95) AT=245.025n

.meas tran vdout0_96ck480 FIND v(dout0_96) AT=245.025n

.meas tran vdout0_97ck480 FIND v(dout0_97) AT=245.025n

.meas tran vdout0_98ck480 FIND v(dout0_98) AT=245.025n

.meas tran vdout0_99ck480 FIND v(dout0_99) AT=245.025n

.meas tran vdout0_100ck480 FIND v(dout0_100) AT=245.025n

.meas tran vdout0_101ck480 FIND v(dout0_101) AT=245.025n

.meas tran vdout0_102ck480 FIND v(dout0_102) AT=245.025n

.meas tran vdout0_103ck480 FIND v(dout0_103) AT=245.025n

.meas tran vdout0_104ck480 FIND v(dout0_104) AT=245.025n

.meas tran vdout0_105ck480 FIND v(dout0_105) AT=245.025n

.meas tran vdout0_106ck480 FIND v(dout0_106) AT=245.025n

.meas tran vdout0_107ck480 FIND v(dout0_107) AT=245.025n

.meas tran vdout0_108ck480 FIND v(dout0_108) AT=245.025n

.meas tran vdout0_109ck480 FIND v(dout0_109) AT=245.025n

.meas tran vdout0_110ck480 FIND v(dout0_110) AT=245.025n

.meas tran vdout0_111ck480 FIND v(dout0_111) AT=245.025n

.meas tran vdout0_112ck480 FIND v(dout0_112) AT=245.025n

.meas tran vdout0_113ck480 FIND v(dout0_113) AT=245.025n

.meas tran vdout0_114ck480 FIND v(dout0_114) AT=245.025n

.meas tran vdout0_115ck480 FIND v(dout0_115) AT=245.025n

.meas tran vdout0_116ck480 FIND v(dout0_116) AT=245.025n

.meas tran vdout0_117ck480 FIND v(dout0_117) AT=245.025n

.meas tran vdout0_118ck480 FIND v(dout0_118) AT=245.025n

.meas tran vdout0_119ck480 FIND v(dout0_119) AT=245.025n

.meas tran vdout0_120ck480 FIND v(dout0_120) AT=245.025n

.meas tran vdout0_121ck480 FIND v(dout0_121) AT=245.025n

.meas tran vdout0_122ck480 FIND v(dout0_122) AT=245.025n

.meas tran vdout0_123ck480 FIND v(dout0_123) AT=245.025n

.meas tran vdout0_124ck480 FIND v(dout0_124) AT=245.025n

.meas tran vdout0_125ck480 FIND v(dout0_125) AT=245.025n

.meas tran vdout0_126ck480 FIND v(dout0_126) AT=245.025n

.meas tran vdout0_127ck480 FIND v(dout0_127) AT=245.025n

.meas tran vdout0_128ck480 FIND v(dout0_128) AT=245.025n

.meas tran vdout0_129ck480 FIND v(dout0_129) AT=245.025n

.meas tran vdout0_130ck480 FIND v(dout0_130) AT=245.025n

.meas tran vdout0_131ck480 FIND v(dout0_131) AT=245.025n

.meas tran vdout0_132ck480 FIND v(dout0_132) AT=245.025n

.meas tran vdout0_133ck480 FIND v(dout0_133) AT=245.025n

.meas tran vdout0_134ck480 FIND v(dout0_134) AT=245.025n

.meas tran vdout0_135ck480 FIND v(dout0_135) AT=245.025n

.meas tran vdout0_136ck480 FIND v(dout0_136) AT=245.025n

.meas tran vdout0_137ck480 FIND v(dout0_137) AT=245.025n

.meas tran vdout0_138ck480 FIND v(dout0_138) AT=245.025n

.meas tran vdout0_139ck480 FIND v(dout0_139) AT=245.025n

.meas tran vdout0_140ck480 FIND v(dout0_140) AT=245.025n

.meas tran vdout0_141ck480 FIND v(dout0_141) AT=245.025n

.meas tran vdout0_142ck480 FIND v(dout0_142) AT=245.025n

.meas tran vdout0_143ck480 FIND v(dout0_143) AT=245.025n

.meas tran vdout0_144ck480 FIND v(dout0_144) AT=245.025n

.meas tran vdout0_145ck480 FIND v(dout0_145) AT=245.025n

.meas tran vdout0_146ck480 FIND v(dout0_146) AT=245.025n

.meas tran vdout0_147ck480 FIND v(dout0_147) AT=245.025n

.meas tran vdout0_148ck480 FIND v(dout0_148) AT=245.025n

.meas tran vdout0_149ck480 FIND v(dout0_149) AT=245.025n

.meas tran vdout0_0ck490 FIND v(dout0_0) AT=250.025n

.meas tran vdout0_1ck490 FIND v(dout0_1) AT=250.025n

.meas tran vdout0_2ck490 FIND v(dout0_2) AT=250.025n

.meas tran vdout0_3ck490 FIND v(dout0_3) AT=250.025n

.meas tran vdout0_4ck490 FIND v(dout0_4) AT=250.025n

.meas tran vdout0_5ck490 FIND v(dout0_5) AT=250.025n

.meas tran vdout0_6ck490 FIND v(dout0_6) AT=250.025n

.meas tran vdout0_7ck490 FIND v(dout0_7) AT=250.025n

.meas tran vdout0_8ck490 FIND v(dout0_8) AT=250.025n

.meas tran vdout0_9ck490 FIND v(dout0_9) AT=250.025n

.meas tran vdout0_10ck490 FIND v(dout0_10) AT=250.025n

.meas tran vdout0_11ck490 FIND v(dout0_11) AT=250.025n

.meas tran vdout0_12ck490 FIND v(dout0_12) AT=250.025n

.meas tran vdout0_13ck490 FIND v(dout0_13) AT=250.025n

.meas tran vdout0_14ck490 FIND v(dout0_14) AT=250.025n

.meas tran vdout0_15ck490 FIND v(dout0_15) AT=250.025n

.meas tran vdout0_16ck490 FIND v(dout0_16) AT=250.025n

.meas tran vdout0_17ck490 FIND v(dout0_17) AT=250.025n

.meas tran vdout0_18ck490 FIND v(dout0_18) AT=250.025n

.meas tran vdout0_19ck490 FIND v(dout0_19) AT=250.025n

.meas tran vdout0_20ck490 FIND v(dout0_20) AT=250.025n

.meas tran vdout0_21ck490 FIND v(dout0_21) AT=250.025n

.meas tran vdout0_22ck490 FIND v(dout0_22) AT=250.025n

.meas tran vdout0_23ck490 FIND v(dout0_23) AT=250.025n

.meas tran vdout0_24ck490 FIND v(dout0_24) AT=250.025n

.meas tran vdout0_25ck490 FIND v(dout0_25) AT=250.025n

.meas tran vdout0_26ck490 FIND v(dout0_26) AT=250.025n

.meas tran vdout0_27ck490 FIND v(dout0_27) AT=250.025n

.meas tran vdout0_28ck490 FIND v(dout0_28) AT=250.025n

.meas tran vdout0_29ck490 FIND v(dout0_29) AT=250.025n

.meas tran vdout0_30ck490 FIND v(dout0_30) AT=250.025n

.meas tran vdout0_31ck490 FIND v(dout0_31) AT=250.025n

.meas tran vdout0_32ck490 FIND v(dout0_32) AT=250.025n

.meas tran vdout0_33ck490 FIND v(dout0_33) AT=250.025n

.meas tran vdout0_34ck490 FIND v(dout0_34) AT=250.025n

.meas tran vdout0_35ck490 FIND v(dout0_35) AT=250.025n

.meas tran vdout0_36ck490 FIND v(dout0_36) AT=250.025n

.meas tran vdout0_37ck490 FIND v(dout0_37) AT=250.025n

.meas tran vdout0_38ck490 FIND v(dout0_38) AT=250.025n

.meas tran vdout0_39ck490 FIND v(dout0_39) AT=250.025n

.meas tran vdout0_40ck490 FIND v(dout0_40) AT=250.025n

.meas tran vdout0_41ck490 FIND v(dout0_41) AT=250.025n

.meas tran vdout0_42ck490 FIND v(dout0_42) AT=250.025n

.meas tran vdout0_43ck490 FIND v(dout0_43) AT=250.025n

.meas tran vdout0_44ck490 FIND v(dout0_44) AT=250.025n

.meas tran vdout0_45ck490 FIND v(dout0_45) AT=250.025n

.meas tran vdout0_46ck490 FIND v(dout0_46) AT=250.025n

.meas tran vdout0_47ck490 FIND v(dout0_47) AT=250.025n

.meas tran vdout0_48ck490 FIND v(dout0_48) AT=250.025n

.meas tran vdout0_49ck490 FIND v(dout0_49) AT=250.025n

.meas tran vdout0_50ck490 FIND v(dout0_50) AT=250.025n

.meas tran vdout0_51ck490 FIND v(dout0_51) AT=250.025n

.meas tran vdout0_52ck490 FIND v(dout0_52) AT=250.025n

.meas tran vdout0_53ck490 FIND v(dout0_53) AT=250.025n

.meas tran vdout0_54ck490 FIND v(dout0_54) AT=250.025n

.meas tran vdout0_55ck490 FIND v(dout0_55) AT=250.025n

.meas tran vdout0_56ck490 FIND v(dout0_56) AT=250.025n

.meas tran vdout0_57ck490 FIND v(dout0_57) AT=250.025n

.meas tran vdout0_58ck490 FIND v(dout0_58) AT=250.025n

.meas tran vdout0_59ck490 FIND v(dout0_59) AT=250.025n

.meas tran vdout0_60ck490 FIND v(dout0_60) AT=250.025n

.meas tran vdout0_61ck490 FIND v(dout0_61) AT=250.025n

.meas tran vdout0_62ck490 FIND v(dout0_62) AT=250.025n

.meas tran vdout0_63ck490 FIND v(dout0_63) AT=250.025n

.meas tran vdout0_64ck490 FIND v(dout0_64) AT=250.025n

.meas tran vdout0_65ck490 FIND v(dout0_65) AT=250.025n

.meas tran vdout0_66ck490 FIND v(dout0_66) AT=250.025n

.meas tran vdout0_67ck490 FIND v(dout0_67) AT=250.025n

.meas tran vdout0_68ck490 FIND v(dout0_68) AT=250.025n

.meas tran vdout0_69ck490 FIND v(dout0_69) AT=250.025n

.meas tran vdout0_70ck490 FIND v(dout0_70) AT=250.025n

.meas tran vdout0_71ck490 FIND v(dout0_71) AT=250.025n

.meas tran vdout0_72ck490 FIND v(dout0_72) AT=250.025n

.meas tran vdout0_73ck490 FIND v(dout0_73) AT=250.025n

.meas tran vdout0_74ck490 FIND v(dout0_74) AT=250.025n

.meas tran vdout0_75ck490 FIND v(dout0_75) AT=250.025n

.meas tran vdout0_76ck490 FIND v(dout0_76) AT=250.025n

.meas tran vdout0_77ck490 FIND v(dout0_77) AT=250.025n

.meas tran vdout0_78ck490 FIND v(dout0_78) AT=250.025n

.meas tran vdout0_79ck490 FIND v(dout0_79) AT=250.025n

.meas tran vdout0_80ck490 FIND v(dout0_80) AT=250.025n

.meas tran vdout0_81ck490 FIND v(dout0_81) AT=250.025n

.meas tran vdout0_82ck490 FIND v(dout0_82) AT=250.025n

.meas tran vdout0_83ck490 FIND v(dout0_83) AT=250.025n

.meas tran vdout0_84ck490 FIND v(dout0_84) AT=250.025n

.meas tran vdout0_85ck490 FIND v(dout0_85) AT=250.025n

.meas tran vdout0_86ck490 FIND v(dout0_86) AT=250.025n

.meas tran vdout0_87ck490 FIND v(dout0_87) AT=250.025n

.meas tran vdout0_88ck490 FIND v(dout0_88) AT=250.025n

.meas tran vdout0_89ck490 FIND v(dout0_89) AT=250.025n

.meas tran vdout0_90ck490 FIND v(dout0_90) AT=250.025n

.meas tran vdout0_91ck490 FIND v(dout0_91) AT=250.025n

.meas tran vdout0_92ck490 FIND v(dout0_92) AT=250.025n

.meas tran vdout0_93ck490 FIND v(dout0_93) AT=250.025n

.meas tran vdout0_94ck490 FIND v(dout0_94) AT=250.025n

.meas tran vdout0_95ck490 FIND v(dout0_95) AT=250.025n

.meas tran vdout0_96ck490 FIND v(dout0_96) AT=250.025n

.meas tran vdout0_97ck490 FIND v(dout0_97) AT=250.025n

.meas tran vdout0_98ck490 FIND v(dout0_98) AT=250.025n

.meas tran vdout0_99ck490 FIND v(dout0_99) AT=250.025n

.meas tran vdout0_100ck490 FIND v(dout0_100) AT=250.025n

.meas tran vdout0_101ck490 FIND v(dout0_101) AT=250.025n

.meas tran vdout0_102ck490 FIND v(dout0_102) AT=250.025n

.meas tran vdout0_103ck490 FIND v(dout0_103) AT=250.025n

.meas tran vdout0_104ck490 FIND v(dout0_104) AT=250.025n

.meas tran vdout0_105ck490 FIND v(dout0_105) AT=250.025n

.meas tran vdout0_106ck490 FIND v(dout0_106) AT=250.025n

.meas tran vdout0_107ck490 FIND v(dout0_107) AT=250.025n

.meas tran vdout0_108ck490 FIND v(dout0_108) AT=250.025n

.meas tran vdout0_109ck490 FIND v(dout0_109) AT=250.025n

.meas tran vdout0_110ck490 FIND v(dout0_110) AT=250.025n

.meas tran vdout0_111ck490 FIND v(dout0_111) AT=250.025n

.meas tran vdout0_112ck490 FIND v(dout0_112) AT=250.025n

.meas tran vdout0_113ck490 FIND v(dout0_113) AT=250.025n

.meas tran vdout0_114ck490 FIND v(dout0_114) AT=250.025n

.meas tran vdout0_115ck490 FIND v(dout0_115) AT=250.025n

.meas tran vdout0_116ck490 FIND v(dout0_116) AT=250.025n

.meas tran vdout0_117ck490 FIND v(dout0_117) AT=250.025n

.meas tran vdout0_118ck490 FIND v(dout0_118) AT=250.025n

.meas tran vdout0_119ck490 FIND v(dout0_119) AT=250.025n

.meas tran vdout0_120ck490 FIND v(dout0_120) AT=250.025n

.meas tran vdout0_121ck490 FIND v(dout0_121) AT=250.025n

.meas tran vdout0_122ck490 FIND v(dout0_122) AT=250.025n

.meas tran vdout0_123ck490 FIND v(dout0_123) AT=250.025n

.meas tran vdout0_124ck490 FIND v(dout0_124) AT=250.025n

.meas tran vdout0_125ck490 FIND v(dout0_125) AT=250.025n

.meas tran vdout0_126ck490 FIND v(dout0_126) AT=250.025n

.meas tran vdout0_127ck490 FIND v(dout0_127) AT=250.025n

.meas tran vdout0_128ck490 FIND v(dout0_128) AT=250.025n

.meas tran vdout0_129ck490 FIND v(dout0_129) AT=250.025n

.meas tran vdout0_130ck490 FIND v(dout0_130) AT=250.025n

.meas tran vdout0_131ck490 FIND v(dout0_131) AT=250.025n

.meas tran vdout0_132ck490 FIND v(dout0_132) AT=250.025n

.meas tran vdout0_133ck490 FIND v(dout0_133) AT=250.025n

.meas tran vdout0_134ck490 FIND v(dout0_134) AT=250.025n

.meas tran vdout0_135ck490 FIND v(dout0_135) AT=250.025n

.meas tran vdout0_136ck490 FIND v(dout0_136) AT=250.025n

.meas tran vdout0_137ck490 FIND v(dout0_137) AT=250.025n

.meas tran vdout0_138ck490 FIND v(dout0_138) AT=250.025n

.meas tran vdout0_139ck490 FIND v(dout0_139) AT=250.025n

.meas tran vdout0_140ck490 FIND v(dout0_140) AT=250.025n

.meas tran vdout0_141ck490 FIND v(dout0_141) AT=250.025n

.meas tran vdout0_142ck490 FIND v(dout0_142) AT=250.025n

.meas tran vdout0_143ck490 FIND v(dout0_143) AT=250.025n

.meas tran vdout0_144ck490 FIND v(dout0_144) AT=250.025n

.meas tran vdout0_145ck490 FIND v(dout0_145) AT=250.025n

.meas tran vdout0_146ck490 FIND v(dout0_146) AT=250.025n

.meas tran vdout0_147ck490 FIND v(dout0_147) AT=250.025n

.meas tran vdout0_148ck490 FIND v(dout0_148) AT=250.025n

.meas tran vdout0_149ck490 FIND v(dout0_149) AT=250.025n

.meas tran vdout0_0ck500 FIND v(dout0_0) AT=255.025n

.meas tran vdout0_1ck500 FIND v(dout0_1) AT=255.025n

.meas tran vdout0_2ck500 FIND v(dout0_2) AT=255.025n

.meas tran vdout0_3ck500 FIND v(dout0_3) AT=255.025n

.meas tran vdout0_4ck500 FIND v(dout0_4) AT=255.025n

.meas tran vdout0_5ck500 FIND v(dout0_5) AT=255.025n

.meas tran vdout0_6ck500 FIND v(dout0_6) AT=255.025n

.meas tran vdout0_7ck500 FIND v(dout0_7) AT=255.025n

.meas tran vdout0_8ck500 FIND v(dout0_8) AT=255.025n

.meas tran vdout0_9ck500 FIND v(dout0_9) AT=255.025n

.meas tran vdout0_10ck500 FIND v(dout0_10) AT=255.025n

.meas tran vdout0_11ck500 FIND v(dout0_11) AT=255.025n

.meas tran vdout0_12ck500 FIND v(dout0_12) AT=255.025n

.meas tran vdout0_13ck500 FIND v(dout0_13) AT=255.025n

.meas tran vdout0_14ck500 FIND v(dout0_14) AT=255.025n

.meas tran vdout0_15ck500 FIND v(dout0_15) AT=255.025n

.meas tran vdout0_16ck500 FIND v(dout0_16) AT=255.025n

.meas tran vdout0_17ck500 FIND v(dout0_17) AT=255.025n

.meas tran vdout0_18ck500 FIND v(dout0_18) AT=255.025n

.meas tran vdout0_19ck500 FIND v(dout0_19) AT=255.025n

.meas tran vdout0_20ck500 FIND v(dout0_20) AT=255.025n

.meas tran vdout0_21ck500 FIND v(dout0_21) AT=255.025n

.meas tran vdout0_22ck500 FIND v(dout0_22) AT=255.025n

.meas tran vdout0_23ck500 FIND v(dout0_23) AT=255.025n

.meas tran vdout0_24ck500 FIND v(dout0_24) AT=255.025n

.meas tran vdout0_25ck500 FIND v(dout0_25) AT=255.025n

.meas tran vdout0_26ck500 FIND v(dout0_26) AT=255.025n

.meas tran vdout0_27ck500 FIND v(dout0_27) AT=255.025n

.meas tran vdout0_28ck500 FIND v(dout0_28) AT=255.025n

.meas tran vdout0_29ck500 FIND v(dout0_29) AT=255.025n

.meas tran vdout0_30ck500 FIND v(dout0_30) AT=255.025n

.meas tran vdout0_31ck500 FIND v(dout0_31) AT=255.025n

.meas tran vdout0_32ck500 FIND v(dout0_32) AT=255.025n

.meas tran vdout0_33ck500 FIND v(dout0_33) AT=255.025n

.meas tran vdout0_34ck500 FIND v(dout0_34) AT=255.025n

.meas tran vdout0_35ck500 FIND v(dout0_35) AT=255.025n

.meas tran vdout0_36ck500 FIND v(dout0_36) AT=255.025n

.meas tran vdout0_37ck500 FIND v(dout0_37) AT=255.025n

.meas tran vdout0_38ck500 FIND v(dout0_38) AT=255.025n

.meas tran vdout0_39ck500 FIND v(dout0_39) AT=255.025n

.meas tran vdout0_40ck500 FIND v(dout0_40) AT=255.025n

.meas tran vdout0_41ck500 FIND v(dout0_41) AT=255.025n

.meas tran vdout0_42ck500 FIND v(dout0_42) AT=255.025n

.meas tran vdout0_43ck500 FIND v(dout0_43) AT=255.025n

.meas tran vdout0_44ck500 FIND v(dout0_44) AT=255.025n

.meas tran vdout0_45ck500 FIND v(dout0_45) AT=255.025n

.meas tran vdout0_46ck500 FIND v(dout0_46) AT=255.025n

.meas tran vdout0_47ck500 FIND v(dout0_47) AT=255.025n

.meas tran vdout0_48ck500 FIND v(dout0_48) AT=255.025n

.meas tran vdout0_49ck500 FIND v(dout0_49) AT=255.025n

.meas tran vdout0_50ck500 FIND v(dout0_50) AT=255.025n

.meas tran vdout0_51ck500 FIND v(dout0_51) AT=255.025n

.meas tran vdout0_52ck500 FIND v(dout0_52) AT=255.025n

.meas tran vdout0_53ck500 FIND v(dout0_53) AT=255.025n

.meas tran vdout0_54ck500 FIND v(dout0_54) AT=255.025n

.meas tran vdout0_55ck500 FIND v(dout0_55) AT=255.025n

.meas tran vdout0_56ck500 FIND v(dout0_56) AT=255.025n

.meas tran vdout0_57ck500 FIND v(dout0_57) AT=255.025n

.meas tran vdout0_58ck500 FIND v(dout0_58) AT=255.025n

.meas tran vdout0_59ck500 FIND v(dout0_59) AT=255.025n

.meas tran vdout0_60ck500 FIND v(dout0_60) AT=255.025n

.meas tran vdout0_61ck500 FIND v(dout0_61) AT=255.025n

.meas tran vdout0_62ck500 FIND v(dout0_62) AT=255.025n

.meas tran vdout0_63ck500 FIND v(dout0_63) AT=255.025n

.meas tran vdout0_64ck500 FIND v(dout0_64) AT=255.025n

.meas tran vdout0_65ck500 FIND v(dout0_65) AT=255.025n

.meas tran vdout0_66ck500 FIND v(dout0_66) AT=255.025n

.meas tran vdout0_67ck500 FIND v(dout0_67) AT=255.025n

.meas tran vdout0_68ck500 FIND v(dout0_68) AT=255.025n

.meas tran vdout0_69ck500 FIND v(dout0_69) AT=255.025n

.meas tran vdout0_70ck500 FIND v(dout0_70) AT=255.025n

.meas tran vdout0_71ck500 FIND v(dout0_71) AT=255.025n

.meas tran vdout0_72ck500 FIND v(dout0_72) AT=255.025n

.meas tran vdout0_73ck500 FIND v(dout0_73) AT=255.025n

.meas tran vdout0_74ck500 FIND v(dout0_74) AT=255.025n

.meas tran vdout0_75ck500 FIND v(dout0_75) AT=255.025n

.meas tran vdout0_76ck500 FIND v(dout0_76) AT=255.025n

.meas tran vdout0_77ck500 FIND v(dout0_77) AT=255.025n

.meas tran vdout0_78ck500 FIND v(dout0_78) AT=255.025n

.meas tran vdout0_79ck500 FIND v(dout0_79) AT=255.025n

.meas tran vdout0_80ck500 FIND v(dout0_80) AT=255.025n

.meas tran vdout0_81ck500 FIND v(dout0_81) AT=255.025n

.meas tran vdout0_82ck500 FIND v(dout0_82) AT=255.025n

.meas tran vdout0_83ck500 FIND v(dout0_83) AT=255.025n

.meas tran vdout0_84ck500 FIND v(dout0_84) AT=255.025n

.meas tran vdout0_85ck500 FIND v(dout0_85) AT=255.025n

.meas tran vdout0_86ck500 FIND v(dout0_86) AT=255.025n

.meas tran vdout0_87ck500 FIND v(dout0_87) AT=255.025n

.meas tran vdout0_88ck500 FIND v(dout0_88) AT=255.025n

.meas tran vdout0_89ck500 FIND v(dout0_89) AT=255.025n

.meas tran vdout0_90ck500 FIND v(dout0_90) AT=255.025n

.meas tran vdout0_91ck500 FIND v(dout0_91) AT=255.025n

.meas tran vdout0_92ck500 FIND v(dout0_92) AT=255.025n

.meas tran vdout0_93ck500 FIND v(dout0_93) AT=255.025n

.meas tran vdout0_94ck500 FIND v(dout0_94) AT=255.025n

.meas tran vdout0_95ck500 FIND v(dout0_95) AT=255.025n

.meas tran vdout0_96ck500 FIND v(dout0_96) AT=255.025n

.meas tran vdout0_97ck500 FIND v(dout0_97) AT=255.025n

.meas tran vdout0_98ck500 FIND v(dout0_98) AT=255.025n

.meas tran vdout0_99ck500 FIND v(dout0_99) AT=255.025n

.meas tran vdout0_100ck500 FIND v(dout0_100) AT=255.025n

.meas tran vdout0_101ck500 FIND v(dout0_101) AT=255.025n

.meas tran vdout0_102ck500 FIND v(dout0_102) AT=255.025n

.meas tran vdout0_103ck500 FIND v(dout0_103) AT=255.025n

.meas tran vdout0_104ck500 FIND v(dout0_104) AT=255.025n

.meas tran vdout0_105ck500 FIND v(dout0_105) AT=255.025n

.meas tran vdout0_106ck500 FIND v(dout0_106) AT=255.025n

.meas tran vdout0_107ck500 FIND v(dout0_107) AT=255.025n

.meas tran vdout0_108ck500 FIND v(dout0_108) AT=255.025n

.meas tran vdout0_109ck500 FIND v(dout0_109) AT=255.025n

.meas tran vdout0_110ck500 FIND v(dout0_110) AT=255.025n

.meas tran vdout0_111ck500 FIND v(dout0_111) AT=255.025n

.meas tran vdout0_112ck500 FIND v(dout0_112) AT=255.025n

.meas tran vdout0_113ck500 FIND v(dout0_113) AT=255.025n

.meas tran vdout0_114ck500 FIND v(dout0_114) AT=255.025n

.meas tran vdout0_115ck500 FIND v(dout0_115) AT=255.025n

.meas tran vdout0_116ck500 FIND v(dout0_116) AT=255.025n

.meas tran vdout0_117ck500 FIND v(dout0_117) AT=255.025n

.meas tran vdout0_118ck500 FIND v(dout0_118) AT=255.025n

.meas tran vdout0_119ck500 FIND v(dout0_119) AT=255.025n

.meas tran vdout0_120ck500 FIND v(dout0_120) AT=255.025n

.meas tran vdout0_121ck500 FIND v(dout0_121) AT=255.025n

.meas tran vdout0_122ck500 FIND v(dout0_122) AT=255.025n

.meas tran vdout0_123ck500 FIND v(dout0_123) AT=255.025n

.meas tran vdout0_124ck500 FIND v(dout0_124) AT=255.025n

.meas tran vdout0_125ck500 FIND v(dout0_125) AT=255.025n

.meas tran vdout0_126ck500 FIND v(dout0_126) AT=255.025n

.meas tran vdout0_127ck500 FIND v(dout0_127) AT=255.025n

.meas tran vdout0_128ck500 FIND v(dout0_128) AT=255.025n

.meas tran vdout0_129ck500 FIND v(dout0_129) AT=255.025n

.meas tran vdout0_130ck500 FIND v(dout0_130) AT=255.025n

.meas tran vdout0_131ck500 FIND v(dout0_131) AT=255.025n

.meas tran vdout0_132ck500 FIND v(dout0_132) AT=255.025n

.meas tran vdout0_133ck500 FIND v(dout0_133) AT=255.025n

.meas tran vdout0_134ck500 FIND v(dout0_134) AT=255.025n

.meas tran vdout0_135ck500 FIND v(dout0_135) AT=255.025n

.meas tran vdout0_136ck500 FIND v(dout0_136) AT=255.025n

.meas tran vdout0_137ck500 FIND v(dout0_137) AT=255.025n

.meas tran vdout0_138ck500 FIND v(dout0_138) AT=255.025n

.meas tran vdout0_139ck500 FIND v(dout0_139) AT=255.025n

.meas tran vdout0_140ck500 FIND v(dout0_140) AT=255.025n

.meas tran vdout0_141ck500 FIND v(dout0_141) AT=255.025n

.meas tran vdout0_142ck500 FIND v(dout0_142) AT=255.025n

.meas tran vdout0_143ck500 FIND v(dout0_143) AT=255.025n

.meas tran vdout0_144ck500 FIND v(dout0_144) AT=255.025n

.meas tran vdout0_145ck500 FIND v(dout0_145) AT=255.025n

.meas tran vdout0_146ck500 FIND v(dout0_146) AT=255.025n

.meas tran vdout0_147ck500 FIND v(dout0_147) AT=255.025n

.meas tran vdout0_148ck500 FIND v(dout0_148) AT=255.025n

.meas tran vdout0_149ck500 FIND v(dout0_149) AT=255.025n

.meas tran vdout0_0ck530 FIND v(dout0_0) AT=270.025n

.meas tran vdout0_1ck530 FIND v(dout0_1) AT=270.025n

.meas tran vdout0_2ck530 FIND v(dout0_2) AT=270.025n

.meas tran vdout0_3ck530 FIND v(dout0_3) AT=270.025n

.meas tran vdout0_4ck530 FIND v(dout0_4) AT=270.025n

.meas tran vdout0_5ck530 FIND v(dout0_5) AT=270.025n

.meas tran vdout0_6ck530 FIND v(dout0_6) AT=270.025n

.meas tran vdout0_7ck530 FIND v(dout0_7) AT=270.025n

.meas tran vdout0_8ck530 FIND v(dout0_8) AT=270.025n

.meas tran vdout0_9ck530 FIND v(dout0_9) AT=270.025n

.meas tran vdout0_10ck530 FIND v(dout0_10) AT=270.025n

.meas tran vdout0_11ck530 FIND v(dout0_11) AT=270.025n

.meas tran vdout0_12ck530 FIND v(dout0_12) AT=270.025n

.meas tran vdout0_13ck530 FIND v(dout0_13) AT=270.025n

.meas tran vdout0_14ck530 FIND v(dout0_14) AT=270.025n

.meas tran vdout0_15ck530 FIND v(dout0_15) AT=270.025n

.meas tran vdout0_16ck530 FIND v(dout0_16) AT=270.025n

.meas tran vdout0_17ck530 FIND v(dout0_17) AT=270.025n

.meas tran vdout0_18ck530 FIND v(dout0_18) AT=270.025n

.meas tran vdout0_19ck530 FIND v(dout0_19) AT=270.025n

.meas tran vdout0_20ck530 FIND v(dout0_20) AT=270.025n

.meas tran vdout0_21ck530 FIND v(dout0_21) AT=270.025n

.meas tran vdout0_22ck530 FIND v(dout0_22) AT=270.025n

.meas tran vdout0_23ck530 FIND v(dout0_23) AT=270.025n

.meas tran vdout0_24ck530 FIND v(dout0_24) AT=270.025n

.meas tran vdout0_25ck530 FIND v(dout0_25) AT=270.025n

.meas tran vdout0_26ck530 FIND v(dout0_26) AT=270.025n

.meas tran vdout0_27ck530 FIND v(dout0_27) AT=270.025n

.meas tran vdout0_28ck530 FIND v(dout0_28) AT=270.025n

.meas tran vdout0_29ck530 FIND v(dout0_29) AT=270.025n

.meas tran vdout0_30ck530 FIND v(dout0_30) AT=270.025n

.meas tran vdout0_31ck530 FIND v(dout0_31) AT=270.025n

.meas tran vdout0_32ck530 FIND v(dout0_32) AT=270.025n

.meas tran vdout0_33ck530 FIND v(dout0_33) AT=270.025n

.meas tran vdout0_34ck530 FIND v(dout0_34) AT=270.025n

.meas tran vdout0_35ck530 FIND v(dout0_35) AT=270.025n

.meas tran vdout0_36ck530 FIND v(dout0_36) AT=270.025n

.meas tran vdout0_37ck530 FIND v(dout0_37) AT=270.025n

.meas tran vdout0_38ck530 FIND v(dout0_38) AT=270.025n

.meas tran vdout0_39ck530 FIND v(dout0_39) AT=270.025n

.meas tran vdout0_40ck530 FIND v(dout0_40) AT=270.025n

.meas tran vdout0_41ck530 FIND v(dout0_41) AT=270.025n

.meas tran vdout0_42ck530 FIND v(dout0_42) AT=270.025n

.meas tran vdout0_43ck530 FIND v(dout0_43) AT=270.025n

.meas tran vdout0_44ck530 FIND v(dout0_44) AT=270.025n

.meas tran vdout0_45ck530 FIND v(dout0_45) AT=270.025n

.meas tran vdout0_46ck530 FIND v(dout0_46) AT=270.025n

.meas tran vdout0_47ck530 FIND v(dout0_47) AT=270.025n

.meas tran vdout0_48ck530 FIND v(dout0_48) AT=270.025n

.meas tran vdout0_49ck530 FIND v(dout0_49) AT=270.025n

.meas tran vdout0_50ck530 FIND v(dout0_50) AT=270.025n

.meas tran vdout0_51ck530 FIND v(dout0_51) AT=270.025n

.meas tran vdout0_52ck530 FIND v(dout0_52) AT=270.025n

.meas tran vdout0_53ck530 FIND v(dout0_53) AT=270.025n

.meas tran vdout0_54ck530 FIND v(dout0_54) AT=270.025n

.meas tran vdout0_55ck530 FIND v(dout0_55) AT=270.025n

.meas tran vdout0_56ck530 FIND v(dout0_56) AT=270.025n

.meas tran vdout0_57ck530 FIND v(dout0_57) AT=270.025n

.meas tran vdout0_58ck530 FIND v(dout0_58) AT=270.025n

.meas tran vdout0_59ck530 FIND v(dout0_59) AT=270.025n

.meas tran vdout0_60ck530 FIND v(dout0_60) AT=270.025n

.meas tran vdout0_61ck530 FIND v(dout0_61) AT=270.025n

.meas tran vdout0_62ck530 FIND v(dout0_62) AT=270.025n

.meas tran vdout0_63ck530 FIND v(dout0_63) AT=270.025n

.meas tran vdout0_64ck530 FIND v(dout0_64) AT=270.025n

.meas tran vdout0_65ck530 FIND v(dout0_65) AT=270.025n

.meas tran vdout0_66ck530 FIND v(dout0_66) AT=270.025n

.meas tran vdout0_67ck530 FIND v(dout0_67) AT=270.025n

.meas tran vdout0_68ck530 FIND v(dout0_68) AT=270.025n

.meas tran vdout0_69ck530 FIND v(dout0_69) AT=270.025n

.meas tran vdout0_70ck530 FIND v(dout0_70) AT=270.025n

.meas tran vdout0_71ck530 FIND v(dout0_71) AT=270.025n

.meas tran vdout0_72ck530 FIND v(dout0_72) AT=270.025n

.meas tran vdout0_73ck530 FIND v(dout0_73) AT=270.025n

.meas tran vdout0_74ck530 FIND v(dout0_74) AT=270.025n

.meas tran vdout0_75ck530 FIND v(dout0_75) AT=270.025n

.meas tran vdout0_76ck530 FIND v(dout0_76) AT=270.025n

.meas tran vdout0_77ck530 FIND v(dout0_77) AT=270.025n

.meas tran vdout0_78ck530 FIND v(dout0_78) AT=270.025n

.meas tran vdout0_79ck530 FIND v(dout0_79) AT=270.025n

.meas tran vdout0_80ck530 FIND v(dout0_80) AT=270.025n

.meas tran vdout0_81ck530 FIND v(dout0_81) AT=270.025n

.meas tran vdout0_82ck530 FIND v(dout0_82) AT=270.025n

.meas tran vdout0_83ck530 FIND v(dout0_83) AT=270.025n

.meas tran vdout0_84ck530 FIND v(dout0_84) AT=270.025n

.meas tran vdout0_85ck530 FIND v(dout0_85) AT=270.025n

.meas tran vdout0_86ck530 FIND v(dout0_86) AT=270.025n

.meas tran vdout0_87ck530 FIND v(dout0_87) AT=270.025n

.meas tran vdout0_88ck530 FIND v(dout0_88) AT=270.025n

.meas tran vdout0_89ck530 FIND v(dout0_89) AT=270.025n

.meas tran vdout0_90ck530 FIND v(dout0_90) AT=270.025n

.meas tran vdout0_91ck530 FIND v(dout0_91) AT=270.025n

.meas tran vdout0_92ck530 FIND v(dout0_92) AT=270.025n

.meas tran vdout0_93ck530 FIND v(dout0_93) AT=270.025n

.meas tran vdout0_94ck530 FIND v(dout0_94) AT=270.025n

.meas tran vdout0_95ck530 FIND v(dout0_95) AT=270.025n

.meas tran vdout0_96ck530 FIND v(dout0_96) AT=270.025n

.meas tran vdout0_97ck530 FIND v(dout0_97) AT=270.025n

.meas tran vdout0_98ck530 FIND v(dout0_98) AT=270.025n

.meas tran vdout0_99ck530 FIND v(dout0_99) AT=270.025n

.meas tran vdout0_100ck530 FIND v(dout0_100) AT=270.025n

.meas tran vdout0_101ck530 FIND v(dout0_101) AT=270.025n

.meas tran vdout0_102ck530 FIND v(dout0_102) AT=270.025n

.meas tran vdout0_103ck530 FIND v(dout0_103) AT=270.025n

.meas tran vdout0_104ck530 FIND v(dout0_104) AT=270.025n

.meas tran vdout0_105ck530 FIND v(dout0_105) AT=270.025n

.meas tran vdout0_106ck530 FIND v(dout0_106) AT=270.025n

.meas tran vdout0_107ck530 FIND v(dout0_107) AT=270.025n

.meas tran vdout0_108ck530 FIND v(dout0_108) AT=270.025n

.meas tran vdout0_109ck530 FIND v(dout0_109) AT=270.025n

.meas tran vdout0_110ck530 FIND v(dout0_110) AT=270.025n

.meas tran vdout0_111ck530 FIND v(dout0_111) AT=270.025n

.meas tran vdout0_112ck530 FIND v(dout0_112) AT=270.025n

.meas tran vdout0_113ck530 FIND v(dout0_113) AT=270.025n

.meas tran vdout0_114ck530 FIND v(dout0_114) AT=270.025n

.meas tran vdout0_115ck530 FIND v(dout0_115) AT=270.025n

.meas tran vdout0_116ck530 FIND v(dout0_116) AT=270.025n

.meas tran vdout0_117ck530 FIND v(dout0_117) AT=270.025n

.meas tran vdout0_118ck530 FIND v(dout0_118) AT=270.025n

.meas tran vdout0_119ck530 FIND v(dout0_119) AT=270.025n

.meas tran vdout0_120ck530 FIND v(dout0_120) AT=270.025n

.meas tran vdout0_121ck530 FIND v(dout0_121) AT=270.025n

.meas tran vdout0_122ck530 FIND v(dout0_122) AT=270.025n

.meas tran vdout0_123ck530 FIND v(dout0_123) AT=270.025n

.meas tran vdout0_124ck530 FIND v(dout0_124) AT=270.025n

.meas tran vdout0_125ck530 FIND v(dout0_125) AT=270.025n

.meas tran vdout0_126ck530 FIND v(dout0_126) AT=270.025n

.meas tran vdout0_127ck530 FIND v(dout0_127) AT=270.025n

.meas tran vdout0_128ck530 FIND v(dout0_128) AT=270.025n

.meas tran vdout0_129ck530 FIND v(dout0_129) AT=270.025n

.meas tran vdout0_130ck530 FIND v(dout0_130) AT=270.025n

.meas tran vdout0_131ck530 FIND v(dout0_131) AT=270.025n

.meas tran vdout0_132ck530 FIND v(dout0_132) AT=270.025n

.meas tran vdout0_133ck530 FIND v(dout0_133) AT=270.025n

.meas tran vdout0_134ck530 FIND v(dout0_134) AT=270.025n

.meas tran vdout0_135ck530 FIND v(dout0_135) AT=270.025n

.meas tran vdout0_136ck530 FIND v(dout0_136) AT=270.025n

.meas tran vdout0_137ck530 FIND v(dout0_137) AT=270.025n

.meas tran vdout0_138ck530 FIND v(dout0_138) AT=270.025n

.meas tran vdout0_139ck530 FIND v(dout0_139) AT=270.025n

.meas tran vdout0_140ck530 FIND v(dout0_140) AT=270.025n

.meas tran vdout0_141ck530 FIND v(dout0_141) AT=270.025n

.meas tran vdout0_142ck530 FIND v(dout0_142) AT=270.025n

.meas tran vdout0_143ck530 FIND v(dout0_143) AT=270.025n

.meas tran vdout0_144ck530 FIND v(dout0_144) AT=270.025n

.meas tran vdout0_145ck530 FIND v(dout0_145) AT=270.025n

.meas tran vdout0_146ck530 FIND v(dout0_146) AT=270.025n

.meas tran vdout0_147ck530 FIND v(dout0_147) AT=270.025n

.meas tran vdout0_148ck530 FIND v(dout0_148) AT=270.025n

.meas tran vdout0_149ck530 FIND v(dout0_149) AT=270.025n

.meas tran vdout0_0ck560 FIND v(dout0_0) AT=285.025n

.meas tran vdout0_1ck560 FIND v(dout0_1) AT=285.025n

.meas tran vdout0_2ck560 FIND v(dout0_2) AT=285.025n

.meas tran vdout0_3ck560 FIND v(dout0_3) AT=285.025n

.meas tran vdout0_4ck560 FIND v(dout0_4) AT=285.025n

.meas tran vdout0_5ck560 FIND v(dout0_5) AT=285.025n

.meas tran vdout0_6ck560 FIND v(dout0_6) AT=285.025n

.meas tran vdout0_7ck560 FIND v(dout0_7) AT=285.025n

.meas tran vdout0_8ck560 FIND v(dout0_8) AT=285.025n

.meas tran vdout0_9ck560 FIND v(dout0_9) AT=285.025n

.meas tran vdout0_10ck560 FIND v(dout0_10) AT=285.025n

.meas tran vdout0_11ck560 FIND v(dout0_11) AT=285.025n

.meas tran vdout0_12ck560 FIND v(dout0_12) AT=285.025n

.meas tran vdout0_13ck560 FIND v(dout0_13) AT=285.025n

.meas tran vdout0_14ck560 FIND v(dout0_14) AT=285.025n

.meas tran vdout0_15ck560 FIND v(dout0_15) AT=285.025n

.meas tran vdout0_16ck560 FIND v(dout0_16) AT=285.025n

.meas tran vdout0_17ck560 FIND v(dout0_17) AT=285.025n

.meas tran vdout0_18ck560 FIND v(dout0_18) AT=285.025n

.meas tran vdout0_19ck560 FIND v(dout0_19) AT=285.025n

.meas tran vdout0_20ck560 FIND v(dout0_20) AT=285.025n

.meas tran vdout0_21ck560 FIND v(dout0_21) AT=285.025n

.meas tran vdout0_22ck560 FIND v(dout0_22) AT=285.025n

.meas tran vdout0_23ck560 FIND v(dout0_23) AT=285.025n

.meas tran vdout0_24ck560 FIND v(dout0_24) AT=285.025n

.meas tran vdout0_25ck560 FIND v(dout0_25) AT=285.025n

.meas tran vdout0_26ck560 FIND v(dout0_26) AT=285.025n

.meas tran vdout0_27ck560 FIND v(dout0_27) AT=285.025n

.meas tran vdout0_28ck560 FIND v(dout0_28) AT=285.025n

.meas tran vdout0_29ck560 FIND v(dout0_29) AT=285.025n

.meas tran vdout0_30ck560 FIND v(dout0_30) AT=285.025n

.meas tran vdout0_31ck560 FIND v(dout0_31) AT=285.025n

.meas tran vdout0_32ck560 FIND v(dout0_32) AT=285.025n

.meas tran vdout0_33ck560 FIND v(dout0_33) AT=285.025n

.meas tran vdout0_34ck560 FIND v(dout0_34) AT=285.025n

.meas tran vdout0_35ck560 FIND v(dout0_35) AT=285.025n

.meas tran vdout0_36ck560 FIND v(dout0_36) AT=285.025n

.meas tran vdout0_37ck560 FIND v(dout0_37) AT=285.025n

.meas tran vdout0_38ck560 FIND v(dout0_38) AT=285.025n

.meas tran vdout0_39ck560 FIND v(dout0_39) AT=285.025n

.meas tran vdout0_40ck560 FIND v(dout0_40) AT=285.025n

.meas tran vdout0_41ck560 FIND v(dout0_41) AT=285.025n

.meas tran vdout0_42ck560 FIND v(dout0_42) AT=285.025n

.meas tran vdout0_43ck560 FIND v(dout0_43) AT=285.025n

.meas tran vdout0_44ck560 FIND v(dout0_44) AT=285.025n

.meas tran vdout0_45ck560 FIND v(dout0_45) AT=285.025n

.meas tran vdout0_46ck560 FIND v(dout0_46) AT=285.025n

.meas tran vdout0_47ck560 FIND v(dout0_47) AT=285.025n

.meas tran vdout0_48ck560 FIND v(dout0_48) AT=285.025n

.meas tran vdout0_49ck560 FIND v(dout0_49) AT=285.025n

.meas tran vdout0_50ck560 FIND v(dout0_50) AT=285.025n

.meas tran vdout0_51ck560 FIND v(dout0_51) AT=285.025n

.meas tran vdout0_52ck560 FIND v(dout0_52) AT=285.025n

.meas tran vdout0_53ck560 FIND v(dout0_53) AT=285.025n

.meas tran vdout0_54ck560 FIND v(dout0_54) AT=285.025n

.meas tran vdout0_55ck560 FIND v(dout0_55) AT=285.025n

.meas tran vdout0_56ck560 FIND v(dout0_56) AT=285.025n

.meas tran vdout0_57ck560 FIND v(dout0_57) AT=285.025n

.meas tran vdout0_58ck560 FIND v(dout0_58) AT=285.025n

.meas tran vdout0_59ck560 FIND v(dout0_59) AT=285.025n

.meas tran vdout0_60ck560 FIND v(dout0_60) AT=285.025n

.meas tran vdout0_61ck560 FIND v(dout0_61) AT=285.025n

.meas tran vdout0_62ck560 FIND v(dout0_62) AT=285.025n

.meas tran vdout0_63ck560 FIND v(dout0_63) AT=285.025n

.meas tran vdout0_64ck560 FIND v(dout0_64) AT=285.025n

.meas tran vdout0_65ck560 FIND v(dout0_65) AT=285.025n

.meas tran vdout0_66ck560 FIND v(dout0_66) AT=285.025n

.meas tran vdout0_67ck560 FIND v(dout0_67) AT=285.025n

.meas tran vdout0_68ck560 FIND v(dout0_68) AT=285.025n

.meas tran vdout0_69ck560 FIND v(dout0_69) AT=285.025n

.meas tran vdout0_70ck560 FIND v(dout0_70) AT=285.025n

.meas tran vdout0_71ck560 FIND v(dout0_71) AT=285.025n

.meas tran vdout0_72ck560 FIND v(dout0_72) AT=285.025n

.meas tran vdout0_73ck560 FIND v(dout0_73) AT=285.025n

.meas tran vdout0_74ck560 FIND v(dout0_74) AT=285.025n

.meas tran vdout0_75ck560 FIND v(dout0_75) AT=285.025n

.meas tran vdout0_76ck560 FIND v(dout0_76) AT=285.025n

.meas tran vdout0_77ck560 FIND v(dout0_77) AT=285.025n

.meas tran vdout0_78ck560 FIND v(dout0_78) AT=285.025n

.meas tran vdout0_79ck560 FIND v(dout0_79) AT=285.025n

.meas tran vdout0_80ck560 FIND v(dout0_80) AT=285.025n

.meas tran vdout0_81ck560 FIND v(dout0_81) AT=285.025n

.meas tran vdout0_82ck560 FIND v(dout0_82) AT=285.025n

.meas tran vdout0_83ck560 FIND v(dout0_83) AT=285.025n

.meas tran vdout0_84ck560 FIND v(dout0_84) AT=285.025n

.meas tran vdout0_85ck560 FIND v(dout0_85) AT=285.025n

.meas tran vdout0_86ck560 FIND v(dout0_86) AT=285.025n

.meas tran vdout0_87ck560 FIND v(dout0_87) AT=285.025n

.meas tran vdout0_88ck560 FIND v(dout0_88) AT=285.025n

.meas tran vdout0_89ck560 FIND v(dout0_89) AT=285.025n

.meas tran vdout0_90ck560 FIND v(dout0_90) AT=285.025n

.meas tran vdout0_91ck560 FIND v(dout0_91) AT=285.025n

.meas tran vdout0_92ck560 FIND v(dout0_92) AT=285.025n

.meas tran vdout0_93ck560 FIND v(dout0_93) AT=285.025n

.meas tran vdout0_94ck560 FIND v(dout0_94) AT=285.025n

.meas tran vdout0_95ck560 FIND v(dout0_95) AT=285.025n

.meas tran vdout0_96ck560 FIND v(dout0_96) AT=285.025n

.meas tran vdout0_97ck560 FIND v(dout0_97) AT=285.025n

.meas tran vdout0_98ck560 FIND v(dout0_98) AT=285.025n

.meas tran vdout0_99ck560 FIND v(dout0_99) AT=285.025n

.meas tran vdout0_100ck560 FIND v(dout0_100) AT=285.025n

.meas tran vdout0_101ck560 FIND v(dout0_101) AT=285.025n

.meas tran vdout0_102ck560 FIND v(dout0_102) AT=285.025n

.meas tran vdout0_103ck560 FIND v(dout0_103) AT=285.025n

.meas tran vdout0_104ck560 FIND v(dout0_104) AT=285.025n

.meas tran vdout0_105ck560 FIND v(dout0_105) AT=285.025n

.meas tran vdout0_106ck560 FIND v(dout0_106) AT=285.025n

.meas tran vdout0_107ck560 FIND v(dout0_107) AT=285.025n

.meas tran vdout0_108ck560 FIND v(dout0_108) AT=285.025n

.meas tran vdout0_109ck560 FIND v(dout0_109) AT=285.025n

.meas tran vdout0_110ck560 FIND v(dout0_110) AT=285.025n

.meas tran vdout0_111ck560 FIND v(dout0_111) AT=285.025n

.meas tran vdout0_112ck560 FIND v(dout0_112) AT=285.025n

.meas tran vdout0_113ck560 FIND v(dout0_113) AT=285.025n

.meas tran vdout0_114ck560 FIND v(dout0_114) AT=285.025n

.meas tran vdout0_115ck560 FIND v(dout0_115) AT=285.025n

.meas tran vdout0_116ck560 FIND v(dout0_116) AT=285.025n

.meas tran vdout0_117ck560 FIND v(dout0_117) AT=285.025n

.meas tran vdout0_118ck560 FIND v(dout0_118) AT=285.025n

.meas tran vdout0_119ck560 FIND v(dout0_119) AT=285.025n

.meas tran vdout0_120ck560 FIND v(dout0_120) AT=285.025n

.meas tran vdout0_121ck560 FIND v(dout0_121) AT=285.025n

.meas tran vdout0_122ck560 FIND v(dout0_122) AT=285.025n

.meas tran vdout0_123ck560 FIND v(dout0_123) AT=285.025n

.meas tran vdout0_124ck560 FIND v(dout0_124) AT=285.025n

.meas tran vdout0_125ck560 FIND v(dout0_125) AT=285.025n

.meas tran vdout0_126ck560 FIND v(dout0_126) AT=285.025n

.meas tran vdout0_127ck560 FIND v(dout0_127) AT=285.025n

.meas tran vdout0_128ck560 FIND v(dout0_128) AT=285.025n

.meas tran vdout0_129ck560 FIND v(dout0_129) AT=285.025n

.meas tran vdout0_130ck560 FIND v(dout0_130) AT=285.025n

.meas tran vdout0_131ck560 FIND v(dout0_131) AT=285.025n

.meas tran vdout0_132ck560 FIND v(dout0_132) AT=285.025n

.meas tran vdout0_133ck560 FIND v(dout0_133) AT=285.025n

.meas tran vdout0_134ck560 FIND v(dout0_134) AT=285.025n

.meas tran vdout0_135ck560 FIND v(dout0_135) AT=285.025n

.meas tran vdout0_136ck560 FIND v(dout0_136) AT=285.025n

.meas tran vdout0_137ck560 FIND v(dout0_137) AT=285.025n

.meas tran vdout0_138ck560 FIND v(dout0_138) AT=285.025n

.meas tran vdout0_139ck560 FIND v(dout0_139) AT=285.025n

.meas tran vdout0_140ck560 FIND v(dout0_140) AT=285.025n

.meas tran vdout0_141ck560 FIND v(dout0_141) AT=285.025n

.meas tran vdout0_142ck560 FIND v(dout0_142) AT=285.025n

.meas tran vdout0_143ck560 FIND v(dout0_143) AT=285.025n

.meas tran vdout0_144ck560 FIND v(dout0_144) AT=285.025n

.meas tran vdout0_145ck560 FIND v(dout0_145) AT=285.025n

.meas tran vdout0_146ck560 FIND v(dout0_146) AT=285.025n

.meas tran vdout0_147ck560 FIND v(dout0_147) AT=285.025n

.meas tran vdout0_148ck560 FIND v(dout0_148) AT=285.025n

.meas tran vdout0_149ck560 FIND v(dout0_149) AT=285.025n

.meas tran vdout0_0ck570 FIND v(dout0_0) AT=290.025n

.meas tran vdout0_1ck570 FIND v(dout0_1) AT=290.025n

.meas tran vdout0_2ck570 FIND v(dout0_2) AT=290.025n

.meas tran vdout0_3ck570 FIND v(dout0_3) AT=290.025n

.meas tran vdout0_4ck570 FIND v(dout0_4) AT=290.025n

.meas tran vdout0_5ck570 FIND v(dout0_5) AT=290.025n

.meas tran vdout0_6ck570 FIND v(dout0_6) AT=290.025n

.meas tran vdout0_7ck570 FIND v(dout0_7) AT=290.025n

.meas tran vdout0_8ck570 FIND v(dout0_8) AT=290.025n

.meas tran vdout0_9ck570 FIND v(dout0_9) AT=290.025n

.meas tran vdout0_10ck570 FIND v(dout0_10) AT=290.025n

.meas tran vdout0_11ck570 FIND v(dout0_11) AT=290.025n

.meas tran vdout0_12ck570 FIND v(dout0_12) AT=290.025n

.meas tran vdout0_13ck570 FIND v(dout0_13) AT=290.025n

.meas tran vdout0_14ck570 FIND v(dout0_14) AT=290.025n

.meas tran vdout0_15ck570 FIND v(dout0_15) AT=290.025n

.meas tran vdout0_16ck570 FIND v(dout0_16) AT=290.025n

.meas tran vdout0_17ck570 FIND v(dout0_17) AT=290.025n

.meas tran vdout0_18ck570 FIND v(dout0_18) AT=290.025n

.meas tran vdout0_19ck570 FIND v(dout0_19) AT=290.025n

.meas tran vdout0_20ck570 FIND v(dout0_20) AT=290.025n

.meas tran vdout0_21ck570 FIND v(dout0_21) AT=290.025n

.meas tran vdout0_22ck570 FIND v(dout0_22) AT=290.025n

.meas tran vdout0_23ck570 FIND v(dout0_23) AT=290.025n

.meas tran vdout0_24ck570 FIND v(dout0_24) AT=290.025n

.meas tran vdout0_25ck570 FIND v(dout0_25) AT=290.025n

.meas tran vdout0_26ck570 FIND v(dout0_26) AT=290.025n

.meas tran vdout0_27ck570 FIND v(dout0_27) AT=290.025n

.meas tran vdout0_28ck570 FIND v(dout0_28) AT=290.025n

.meas tran vdout0_29ck570 FIND v(dout0_29) AT=290.025n

.meas tran vdout0_30ck570 FIND v(dout0_30) AT=290.025n

.meas tran vdout0_31ck570 FIND v(dout0_31) AT=290.025n

.meas tran vdout0_32ck570 FIND v(dout0_32) AT=290.025n

.meas tran vdout0_33ck570 FIND v(dout0_33) AT=290.025n

.meas tran vdout0_34ck570 FIND v(dout0_34) AT=290.025n

.meas tran vdout0_35ck570 FIND v(dout0_35) AT=290.025n

.meas tran vdout0_36ck570 FIND v(dout0_36) AT=290.025n

.meas tran vdout0_37ck570 FIND v(dout0_37) AT=290.025n

.meas tran vdout0_38ck570 FIND v(dout0_38) AT=290.025n

.meas tran vdout0_39ck570 FIND v(dout0_39) AT=290.025n

.meas tran vdout0_40ck570 FIND v(dout0_40) AT=290.025n

.meas tran vdout0_41ck570 FIND v(dout0_41) AT=290.025n

.meas tran vdout0_42ck570 FIND v(dout0_42) AT=290.025n

.meas tran vdout0_43ck570 FIND v(dout0_43) AT=290.025n

.meas tran vdout0_44ck570 FIND v(dout0_44) AT=290.025n

.meas tran vdout0_45ck570 FIND v(dout0_45) AT=290.025n

.meas tran vdout0_46ck570 FIND v(dout0_46) AT=290.025n

.meas tran vdout0_47ck570 FIND v(dout0_47) AT=290.025n

.meas tran vdout0_48ck570 FIND v(dout0_48) AT=290.025n

.meas tran vdout0_49ck570 FIND v(dout0_49) AT=290.025n

.meas tran vdout0_50ck570 FIND v(dout0_50) AT=290.025n

.meas tran vdout0_51ck570 FIND v(dout0_51) AT=290.025n

.meas tran vdout0_52ck570 FIND v(dout0_52) AT=290.025n

.meas tran vdout0_53ck570 FIND v(dout0_53) AT=290.025n

.meas tran vdout0_54ck570 FIND v(dout0_54) AT=290.025n

.meas tran vdout0_55ck570 FIND v(dout0_55) AT=290.025n

.meas tran vdout0_56ck570 FIND v(dout0_56) AT=290.025n

.meas tran vdout0_57ck570 FIND v(dout0_57) AT=290.025n

.meas tran vdout0_58ck570 FIND v(dout0_58) AT=290.025n

.meas tran vdout0_59ck570 FIND v(dout0_59) AT=290.025n

.meas tran vdout0_60ck570 FIND v(dout0_60) AT=290.025n

.meas tran vdout0_61ck570 FIND v(dout0_61) AT=290.025n

.meas tran vdout0_62ck570 FIND v(dout0_62) AT=290.025n

.meas tran vdout0_63ck570 FIND v(dout0_63) AT=290.025n

.meas tran vdout0_64ck570 FIND v(dout0_64) AT=290.025n

.meas tran vdout0_65ck570 FIND v(dout0_65) AT=290.025n

.meas tran vdout0_66ck570 FIND v(dout0_66) AT=290.025n

.meas tran vdout0_67ck570 FIND v(dout0_67) AT=290.025n

.meas tran vdout0_68ck570 FIND v(dout0_68) AT=290.025n

.meas tran vdout0_69ck570 FIND v(dout0_69) AT=290.025n

.meas tran vdout0_70ck570 FIND v(dout0_70) AT=290.025n

.meas tran vdout0_71ck570 FIND v(dout0_71) AT=290.025n

.meas tran vdout0_72ck570 FIND v(dout0_72) AT=290.025n

.meas tran vdout0_73ck570 FIND v(dout0_73) AT=290.025n

.meas tran vdout0_74ck570 FIND v(dout0_74) AT=290.025n

.meas tran vdout0_75ck570 FIND v(dout0_75) AT=290.025n

.meas tran vdout0_76ck570 FIND v(dout0_76) AT=290.025n

.meas tran vdout0_77ck570 FIND v(dout0_77) AT=290.025n

.meas tran vdout0_78ck570 FIND v(dout0_78) AT=290.025n

.meas tran vdout0_79ck570 FIND v(dout0_79) AT=290.025n

.meas tran vdout0_80ck570 FIND v(dout0_80) AT=290.025n

.meas tran vdout0_81ck570 FIND v(dout0_81) AT=290.025n

.meas tran vdout0_82ck570 FIND v(dout0_82) AT=290.025n

.meas tran vdout0_83ck570 FIND v(dout0_83) AT=290.025n

.meas tran vdout0_84ck570 FIND v(dout0_84) AT=290.025n

.meas tran vdout0_85ck570 FIND v(dout0_85) AT=290.025n

.meas tran vdout0_86ck570 FIND v(dout0_86) AT=290.025n

.meas tran vdout0_87ck570 FIND v(dout0_87) AT=290.025n

.meas tran vdout0_88ck570 FIND v(dout0_88) AT=290.025n

.meas tran vdout0_89ck570 FIND v(dout0_89) AT=290.025n

.meas tran vdout0_90ck570 FIND v(dout0_90) AT=290.025n

.meas tran vdout0_91ck570 FIND v(dout0_91) AT=290.025n

.meas tran vdout0_92ck570 FIND v(dout0_92) AT=290.025n

.meas tran vdout0_93ck570 FIND v(dout0_93) AT=290.025n

.meas tran vdout0_94ck570 FIND v(dout0_94) AT=290.025n

.meas tran vdout0_95ck570 FIND v(dout0_95) AT=290.025n

.meas tran vdout0_96ck570 FIND v(dout0_96) AT=290.025n

.meas tran vdout0_97ck570 FIND v(dout0_97) AT=290.025n

.meas tran vdout0_98ck570 FIND v(dout0_98) AT=290.025n

.meas tran vdout0_99ck570 FIND v(dout0_99) AT=290.025n

.meas tran vdout0_100ck570 FIND v(dout0_100) AT=290.025n

.meas tran vdout0_101ck570 FIND v(dout0_101) AT=290.025n

.meas tran vdout0_102ck570 FIND v(dout0_102) AT=290.025n

.meas tran vdout0_103ck570 FIND v(dout0_103) AT=290.025n

.meas tran vdout0_104ck570 FIND v(dout0_104) AT=290.025n

.meas tran vdout0_105ck570 FIND v(dout0_105) AT=290.025n

.meas tran vdout0_106ck570 FIND v(dout0_106) AT=290.025n

.meas tran vdout0_107ck570 FIND v(dout0_107) AT=290.025n

.meas tran vdout0_108ck570 FIND v(dout0_108) AT=290.025n

.meas tran vdout0_109ck570 FIND v(dout0_109) AT=290.025n

.meas tran vdout0_110ck570 FIND v(dout0_110) AT=290.025n

.meas tran vdout0_111ck570 FIND v(dout0_111) AT=290.025n

.meas tran vdout0_112ck570 FIND v(dout0_112) AT=290.025n

.meas tran vdout0_113ck570 FIND v(dout0_113) AT=290.025n

.meas tran vdout0_114ck570 FIND v(dout0_114) AT=290.025n

.meas tran vdout0_115ck570 FIND v(dout0_115) AT=290.025n

.meas tran vdout0_116ck570 FIND v(dout0_116) AT=290.025n

.meas tran vdout0_117ck570 FIND v(dout0_117) AT=290.025n

.meas tran vdout0_118ck570 FIND v(dout0_118) AT=290.025n

.meas tran vdout0_119ck570 FIND v(dout0_119) AT=290.025n

.meas tran vdout0_120ck570 FIND v(dout0_120) AT=290.025n

.meas tran vdout0_121ck570 FIND v(dout0_121) AT=290.025n

.meas tran vdout0_122ck570 FIND v(dout0_122) AT=290.025n

.meas tran vdout0_123ck570 FIND v(dout0_123) AT=290.025n

.meas tran vdout0_124ck570 FIND v(dout0_124) AT=290.025n

.meas tran vdout0_125ck570 FIND v(dout0_125) AT=290.025n

.meas tran vdout0_126ck570 FIND v(dout0_126) AT=290.025n

.meas tran vdout0_127ck570 FIND v(dout0_127) AT=290.025n

.meas tran vdout0_128ck570 FIND v(dout0_128) AT=290.025n

.meas tran vdout0_129ck570 FIND v(dout0_129) AT=290.025n

.meas tran vdout0_130ck570 FIND v(dout0_130) AT=290.025n

.meas tran vdout0_131ck570 FIND v(dout0_131) AT=290.025n

.meas tran vdout0_132ck570 FIND v(dout0_132) AT=290.025n

.meas tran vdout0_133ck570 FIND v(dout0_133) AT=290.025n

.meas tran vdout0_134ck570 FIND v(dout0_134) AT=290.025n

.meas tran vdout0_135ck570 FIND v(dout0_135) AT=290.025n

.meas tran vdout0_136ck570 FIND v(dout0_136) AT=290.025n

.meas tran vdout0_137ck570 FIND v(dout0_137) AT=290.025n

.meas tran vdout0_138ck570 FIND v(dout0_138) AT=290.025n

.meas tran vdout0_139ck570 FIND v(dout0_139) AT=290.025n

.meas tran vdout0_140ck570 FIND v(dout0_140) AT=290.025n

.meas tran vdout0_141ck570 FIND v(dout0_141) AT=290.025n

.meas tran vdout0_142ck570 FIND v(dout0_142) AT=290.025n

.meas tran vdout0_143ck570 FIND v(dout0_143) AT=290.025n

.meas tran vdout0_144ck570 FIND v(dout0_144) AT=290.025n

.meas tran vdout0_145ck570 FIND v(dout0_145) AT=290.025n

.meas tran vdout0_146ck570 FIND v(dout0_146) AT=290.025n

.meas tran vdout0_147ck570 FIND v(dout0_147) AT=290.025n

.meas tran vdout0_148ck570 FIND v(dout0_148) AT=290.025n

.meas tran vdout0_149ck570 FIND v(dout0_149) AT=290.025n

.meas tran vdout0_0ck600 FIND v(dout0_0) AT=305.025n

.meas tran vdout0_1ck600 FIND v(dout0_1) AT=305.025n

.meas tran vdout0_2ck600 FIND v(dout0_2) AT=305.025n

.meas tran vdout0_3ck600 FIND v(dout0_3) AT=305.025n

.meas tran vdout0_4ck600 FIND v(dout0_4) AT=305.025n

.meas tran vdout0_5ck600 FIND v(dout0_5) AT=305.025n

.meas tran vdout0_6ck600 FIND v(dout0_6) AT=305.025n

.meas tran vdout0_7ck600 FIND v(dout0_7) AT=305.025n

.meas tran vdout0_8ck600 FIND v(dout0_8) AT=305.025n

.meas tran vdout0_9ck600 FIND v(dout0_9) AT=305.025n

.meas tran vdout0_10ck600 FIND v(dout0_10) AT=305.025n

.meas tran vdout0_11ck600 FIND v(dout0_11) AT=305.025n

.meas tran vdout0_12ck600 FIND v(dout0_12) AT=305.025n

.meas tran vdout0_13ck600 FIND v(dout0_13) AT=305.025n

.meas tran vdout0_14ck600 FIND v(dout0_14) AT=305.025n

.meas tran vdout0_15ck600 FIND v(dout0_15) AT=305.025n

.meas tran vdout0_16ck600 FIND v(dout0_16) AT=305.025n

.meas tran vdout0_17ck600 FIND v(dout0_17) AT=305.025n

.meas tran vdout0_18ck600 FIND v(dout0_18) AT=305.025n

.meas tran vdout0_19ck600 FIND v(dout0_19) AT=305.025n

.meas tran vdout0_20ck600 FIND v(dout0_20) AT=305.025n

.meas tran vdout0_21ck600 FIND v(dout0_21) AT=305.025n

.meas tran vdout0_22ck600 FIND v(dout0_22) AT=305.025n

.meas tran vdout0_23ck600 FIND v(dout0_23) AT=305.025n

.meas tran vdout0_24ck600 FIND v(dout0_24) AT=305.025n

.meas tran vdout0_25ck600 FIND v(dout0_25) AT=305.025n

.meas tran vdout0_26ck600 FIND v(dout0_26) AT=305.025n

.meas tran vdout0_27ck600 FIND v(dout0_27) AT=305.025n

.meas tran vdout0_28ck600 FIND v(dout0_28) AT=305.025n

.meas tran vdout0_29ck600 FIND v(dout0_29) AT=305.025n

.meas tran vdout0_30ck600 FIND v(dout0_30) AT=305.025n

.meas tran vdout0_31ck600 FIND v(dout0_31) AT=305.025n

.meas tran vdout0_32ck600 FIND v(dout0_32) AT=305.025n

.meas tran vdout0_33ck600 FIND v(dout0_33) AT=305.025n

.meas tran vdout0_34ck600 FIND v(dout0_34) AT=305.025n

.meas tran vdout0_35ck600 FIND v(dout0_35) AT=305.025n

.meas tran vdout0_36ck600 FIND v(dout0_36) AT=305.025n

.meas tran vdout0_37ck600 FIND v(dout0_37) AT=305.025n

.meas tran vdout0_38ck600 FIND v(dout0_38) AT=305.025n

.meas tran vdout0_39ck600 FIND v(dout0_39) AT=305.025n

.meas tran vdout0_40ck600 FIND v(dout0_40) AT=305.025n

.meas tran vdout0_41ck600 FIND v(dout0_41) AT=305.025n

.meas tran vdout0_42ck600 FIND v(dout0_42) AT=305.025n

.meas tran vdout0_43ck600 FIND v(dout0_43) AT=305.025n

.meas tran vdout0_44ck600 FIND v(dout0_44) AT=305.025n

.meas tran vdout0_45ck600 FIND v(dout0_45) AT=305.025n

.meas tran vdout0_46ck600 FIND v(dout0_46) AT=305.025n

.meas tran vdout0_47ck600 FIND v(dout0_47) AT=305.025n

.meas tran vdout0_48ck600 FIND v(dout0_48) AT=305.025n

.meas tran vdout0_49ck600 FIND v(dout0_49) AT=305.025n

.meas tran vdout0_50ck600 FIND v(dout0_50) AT=305.025n

.meas tran vdout0_51ck600 FIND v(dout0_51) AT=305.025n

.meas tran vdout0_52ck600 FIND v(dout0_52) AT=305.025n

.meas tran vdout0_53ck600 FIND v(dout0_53) AT=305.025n

.meas tran vdout0_54ck600 FIND v(dout0_54) AT=305.025n

.meas tran vdout0_55ck600 FIND v(dout0_55) AT=305.025n

.meas tran vdout0_56ck600 FIND v(dout0_56) AT=305.025n

.meas tran vdout0_57ck600 FIND v(dout0_57) AT=305.025n

.meas tran vdout0_58ck600 FIND v(dout0_58) AT=305.025n

.meas tran vdout0_59ck600 FIND v(dout0_59) AT=305.025n

.meas tran vdout0_60ck600 FIND v(dout0_60) AT=305.025n

.meas tran vdout0_61ck600 FIND v(dout0_61) AT=305.025n

.meas tran vdout0_62ck600 FIND v(dout0_62) AT=305.025n

.meas tran vdout0_63ck600 FIND v(dout0_63) AT=305.025n

.meas tran vdout0_64ck600 FIND v(dout0_64) AT=305.025n

.meas tran vdout0_65ck600 FIND v(dout0_65) AT=305.025n

.meas tran vdout0_66ck600 FIND v(dout0_66) AT=305.025n

.meas tran vdout0_67ck600 FIND v(dout0_67) AT=305.025n

.meas tran vdout0_68ck600 FIND v(dout0_68) AT=305.025n

.meas tran vdout0_69ck600 FIND v(dout0_69) AT=305.025n

.meas tran vdout0_70ck600 FIND v(dout0_70) AT=305.025n

.meas tran vdout0_71ck600 FIND v(dout0_71) AT=305.025n

.meas tran vdout0_72ck600 FIND v(dout0_72) AT=305.025n

.meas tran vdout0_73ck600 FIND v(dout0_73) AT=305.025n

.meas tran vdout0_74ck600 FIND v(dout0_74) AT=305.025n

.meas tran vdout0_75ck600 FIND v(dout0_75) AT=305.025n

.meas tran vdout0_76ck600 FIND v(dout0_76) AT=305.025n

.meas tran vdout0_77ck600 FIND v(dout0_77) AT=305.025n

.meas tran vdout0_78ck600 FIND v(dout0_78) AT=305.025n

.meas tran vdout0_79ck600 FIND v(dout0_79) AT=305.025n

.meas tran vdout0_80ck600 FIND v(dout0_80) AT=305.025n

.meas tran vdout0_81ck600 FIND v(dout0_81) AT=305.025n

.meas tran vdout0_82ck600 FIND v(dout0_82) AT=305.025n

.meas tran vdout0_83ck600 FIND v(dout0_83) AT=305.025n

.meas tran vdout0_84ck600 FIND v(dout0_84) AT=305.025n

.meas tran vdout0_85ck600 FIND v(dout0_85) AT=305.025n

.meas tran vdout0_86ck600 FIND v(dout0_86) AT=305.025n

.meas tran vdout0_87ck600 FIND v(dout0_87) AT=305.025n

.meas tran vdout0_88ck600 FIND v(dout0_88) AT=305.025n

.meas tran vdout0_89ck600 FIND v(dout0_89) AT=305.025n

.meas tran vdout0_90ck600 FIND v(dout0_90) AT=305.025n

.meas tran vdout0_91ck600 FIND v(dout0_91) AT=305.025n

.meas tran vdout0_92ck600 FIND v(dout0_92) AT=305.025n

.meas tran vdout0_93ck600 FIND v(dout0_93) AT=305.025n

.meas tran vdout0_94ck600 FIND v(dout0_94) AT=305.025n

.meas tran vdout0_95ck600 FIND v(dout0_95) AT=305.025n

.meas tran vdout0_96ck600 FIND v(dout0_96) AT=305.025n

.meas tran vdout0_97ck600 FIND v(dout0_97) AT=305.025n

.meas tran vdout0_98ck600 FIND v(dout0_98) AT=305.025n

.meas tran vdout0_99ck600 FIND v(dout0_99) AT=305.025n

.meas tran vdout0_100ck600 FIND v(dout0_100) AT=305.025n

.meas tran vdout0_101ck600 FIND v(dout0_101) AT=305.025n

.meas tran vdout0_102ck600 FIND v(dout0_102) AT=305.025n

.meas tran vdout0_103ck600 FIND v(dout0_103) AT=305.025n

.meas tran vdout0_104ck600 FIND v(dout0_104) AT=305.025n

.meas tran vdout0_105ck600 FIND v(dout0_105) AT=305.025n

.meas tran vdout0_106ck600 FIND v(dout0_106) AT=305.025n

.meas tran vdout0_107ck600 FIND v(dout0_107) AT=305.025n

.meas tran vdout0_108ck600 FIND v(dout0_108) AT=305.025n

.meas tran vdout0_109ck600 FIND v(dout0_109) AT=305.025n

.meas tran vdout0_110ck600 FIND v(dout0_110) AT=305.025n

.meas tran vdout0_111ck600 FIND v(dout0_111) AT=305.025n

.meas tran vdout0_112ck600 FIND v(dout0_112) AT=305.025n

.meas tran vdout0_113ck600 FIND v(dout0_113) AT=305.025n

.meas tran vdout0_114ck600 FIND v(dout0_114) AT=305.025n

.meas tran vdout0_115ck600 FIND v(dout0_115) AT=305.025n

.meas tran vdout0_116ck600 FIND v(dout0_116) AT=305.025n

.meas tran vdout0_117ck600 FIND v(dout0_117) AT=305.025n

.meas tran vdout0_118ck600 FIND v(dout0_118) AT=305.025n

.meas tran vdout0_119ck600 FIND v(dout0_119) AT=305.025n

.meas tran vdout0_120ck600 FIND v(dout0_120) AT=305.025n

.meas tran vdout0_121ck600 FIND v(dout0_121) AT=305.025n

.meas tran vdout0_122ck600 FIND v(dout0_122) AT=305.025n

.meas tran vdout0_123ck600 FIND v(dout0_123) AT=305.025n

.meas tran vdout0_124ck600 FIND v(dout0_124) AT=305.025n

.meas tran vdout0_125ck600 FIND v(dout0_125) AT=305.025n

.meas tran vdout0_126ck600 FIND v(dout0_126) AT=305.025n

.meas tran vdout0_127ck600 FIND v(dout0_127) AT=305.025n

.meas tran vdout0_128ck600 FIND v(dout0_128) AT=305.025n

.meas tran vdout0_129ck600 FIND v(dout0_129) AT=305.025n

.meas tran vdout0_130ck600 FIND v(dout0_130) AT=305.025n

.meas tran vdout0_131ck600 FIND v(dout0_131) AT=305.025n

.meas tran vdout0_132ck600 FIND v(dout0_132) AT=305.025n

.meas tran vdout0_133ck600 FIND v(dout0_133) AT=305.025n

.meas tran vdout0_134ck600 FIND v(dout0_134) AT=305.025n

.meas tran vdout0_135ck600 FIND v(dout0_135) AT=305.025n

.meas tran vdout0_136ck600 FIND v(dout0_136) AT=305.025n

.meas tran vdout0_137ck600 FIND v(dout0_137) AT=305.025n

.meas tran vdout0_138ck600 FIND v(dout0_138) AT=305.025n

.meas tran vdout0_139ck600 FIND v(dout0_139) AT=305.025n

.meas tran vdout0_140ck600 FIND v(dout0_140) AT=305.025n

.meas tran vdout0_141ck600 FIND v(dout0_141) AT=305.025n

.meas tran vdout0_142ck600 FIND v(dout0_142) AT=305.025n

.meas tran vdout0_143ck600 FIND v(dout0_143) AT=305.025n

.meas tran vdout0_144ck600 FIND v(dout0_144) AT=305.025n

.meas tran vdout0_145ck600 FIND v(dout0_145) AT=305.025n

.meas tran vdout0_146ck600 FIND v(dout0_146) AT=305.025n

.meas tran vdout0_147ck600 FIND v(dout0_147) AT=305.025n

.meas tran vdout0_148ck600 FIND v(dout0_148) AT=305.025n

.meas tran vdout0_149ck600 FIND v(dout0_149) AT=305.025n

.meas tran vdout0_0ck620 FIND v(dout0_0) AT=315.025n

.meas tran vdout0_1ck620 FIND v(dout0_1) AT=315.025n

.meas tran vdout0_2ck620 FIND v(dout0_2) AT=315.025n

.meas tran vdout0_3ck620 FIND v(dout0_3) AT=315.025n

.meas tran vdout0_4ck620 FIND v(dout0_4) AT=315.025n

.meas tran vdout0_5ck620 FIND v(dout0_5) AT=315.025n

.meas tran vdout0_6ck620 FIND v(dout0_6) AT=315.025n

.meas tran vdout0_7ck620 FIND v(dout0_7) AT=315.025n

.meas tran vdout0_8ck620 FIND v(dout0_8) AT=315.025n

.meas tran vdout0_9ck620 FIND v(dout0_9) AT=315.025n

.meas tran vdout0_10ck620 FIND v(dout0_10) AT=315.025n

.meas tran vdout0_11ck620 FIND v(dout0_11) AT=315.025n

.meas tran vdout0_12ck620 FIND v(dout0_12) AT=315.025n

.meas tran vdout0_13ck620 FIND v(dout0_13) AT=315.025n

.meas tran vdout0_14ck620 FIND v(dout0_14) AT=315.025n

.meas tran vdout0_15ck620 FIND v(dout0_15) AT=315.025n

.meas tran vdout0_16ck620 FIND v(dout0_16) AT=315.025n

.meas tran vdout0_17ck620 FIND v(dout0_17) AT=315.025n

.meas tran vdout0_18ck620 FIND v(dout0_18) AT=315.025n

.meas tran vdout0_19ck620 FIND v(dout0_19) AT=315.025n

.meas tran vdout0_20ck620 FIND v(dout0_20) AT=315.025n

.meas tran vdout0_21ck620 FIND v(dout0_21) AT=315.025n

.meas tran vdout0_22ck620 FIND v(dout0_22) AT=315.025n

.meas tran vdout0_23ck620 FIND v(dout0_23) AT=315.025n

.meas tran vdout0_24ck620 FIND v(dout0_24) AT=315.025n

.meas tran vdout0_25ck620 FIND v(dout0_25) AT=315.025n

.meas tran vdout0_26ck620 FIND v(dout0_26) AT=315.025n

.meas tran vdout0_27ck620 FIND v(dout0_27) AT=315.025n

.meas tran vdout0_28ck620 FIND v(dout0_28) AT=315.025n

.meas tran vdout0_29ck620 FIND v(dout0_29) AT=315.025n

.meas tran vdout0_30ck620 FIND v(dout0_30) AT=315.025n

.meas tran vdout0_31ck620 FIND v(dout0_31) AT=315.025n

.meas tran vdout0_32ck620 FIND v(dout0_32) AT=315.025n

.meas tran vdout0_33ck620 FIND v(dout0_33) AT=315.025n

.meas tran vdout0_34ck620 FIND v(dout0_34) AT=315.025n

.meas tran vdout0_35ck620 FIND v(dout0_35) AT=315.025n

.meas tran vdout0_36ck620 FIND v(dout0_36) AT=315.025n

.meas tran vdout0_37ck620 FIND v(dout0_37) AT=315.025n

.meas tran vdout0_38ck620 FIND v(dout0_38) AT=315.025n

.meas tran vdout0_39ck620 FIND v(dout0_39) AT=315.025n

.meas tran vdout0_40ck620 FIND v(dout0_40) AT=315.025n

.meas tran vdout0_41ck620 FIND v(dout0_41) AT=315.025n

.meas tran vdout0_42ck620 FIND v(dout0_42) AT=315.025n

.meas tran vdout0_43ck620 FIND v(dout0_43) AT=315.025n

.meas tran vdout0_44ck620 FIND v(dout0_44) AT=315.025n

.meas tran vdout0_45ck620 FIND v(dout0_45) AT=315.025n

.meas tran vdout0_46ck620 FIND v(dout0_46) AT=315.025n

.meas tran vdout0_47ck620 FIND v(dout0_47) AT=315.025n

.meas tran vdout0_48ck620 FIND v(dout0_48) AT=315.025n

.meas tran vdout0_49ck620 FIND v(dout0_49) AT=315.025n

.meas tran vdout0_50ck620 FIND v(dout0_50) AT=315.025n

.meas tran vdout0_51ck620 FIND v(dout0_51) AT=315.025n

.meas tran vdout0_52ck620 FIND v(dout0_52) AT=315.025n

.meas tran vdout0_53ck620 FIND v(dout0_53) AT=315.025n

.meas tran vdout0_54ck620 FIND v(dout0_54) AT=315.025n

.meas tran vdout0_55ck620 FIND v(dout0_55) AT=315.025n

.meas tran vdout0_56ck620 FIND v(dout0_56) AT=315.025n

.meas tran vdout0_57ck620 FIND v(dout0_57) AT=315.025n

.meas tran vdout0_58ck620 FIND v(dout0_58) AT=315.025n

.meas tran vdout0_59ck620 FIND v(dout0_59) AT=315.025n

.meas tran vdout0_60ck620 FIND v(dout0_60) AT=315.025n

.meas tran vdout0_61ck620 FIND v(dout0_61) AT=315.025n

.meas tran vdout0_62ck620 FIND v(dout0_62) AT=315.025n

.meas tran vdout0_63ck620 FIND v(dout0_63) AT=315.025n

.meas tran vdout0_64ck620 FIND v(dout0_64) AT=315.025n

.meas tran vdout0_65ck620 FIND v(dout0_65) AT=315.025n

.meas tran vdout0_66ck620 FIND v(dout0_66) AT=315.025n

.meas tran vdout0_67ck620 FIND v(dout0_67) AT=315.025n

.meas tran vdout0_68ck620 FIND v(dout0_68) AT=315.025n

.meas tran vdout0_69ck620 FIND v(dout0_69) AT=315.025n

.meas tran vdout0_70ck620 FIND v(dout0_70) AT=315.025n

.meas tran vdout0_71ck620 FIND v(dout0_71) AT=315.025n

.meas tran vdout0_72ck620 FIND v(dout0_72) AT=315.025n

.meas tran vdout0_73ck620 FIND v(dout0_73) AT=315.025n

.meas tran vdout0_74ck620 FIND v(dout0_74) AT=315.025n

.meas tran vdout0_75ck620 FIND v(dout0_75) AT=315.025n

.meas tran vdout0_76ck620 FIND v(dout0_76) AT=315.025n

.meas tran vdout0_77ck620 FIND v(dout0_77) AT=315.025n

.meas tran vdout0_78ck620 FIND v(dout0_78) AT=315.025n

.meas tran vdout0_79ck620 FIND v(dout0_79) AT=315.025n

.meas tran vdout0_80ck620 FIND v(dout0_80) AT=315.025n

.meas tran vdout0_81ck620 FIND v(dout0_81) AT=315.025n

.meas tran vdout0_82ck620 FIND v(dout0_82) AT=315.025n

.meas tran vdout0_83ck620 FIND v(dout0_83) AT=315.025n

.meas tran vdout0_84ck620 FIND v(dout0_84) AT=315.025n

.meas tran vdout0_85ck620 FIND v(dout0_85) AT=315.025n

.meas tran vdout0_86ck620 FIND v(dout0_86) AT=315.025n

.meas tran vdout0_87ck620 FIND v(dout0_87) AT=315.025n

.meas tran vdout0_88ck620 FIND v(dout0_88) AT=315.025n

.meas tran vdout0_89ck620 FIND v(dout0_89) AT=315.025n

.meas tran vdout0_90ck620 FIND v(dout0_90) AT=315.025n

.meas tran vdout0_91ck620 FIND v(dout0_91) AT=315.025n

.meas tran vdout0_92ck620 FIND v(dout0_92) AT=315.025n

.meas tran vdout0_93ck620 FIND v(dout0_93) AT=315.025n

.meas tran vdout0_94ck620 FIND v(dout0_94) AT=315.025n

.meas tran vdout0_95ck620 FIND v(dout0_95) AT=315.025n

.meas tran vdout0_96ck620 FIND v(dout0_96) AT=315.025n

.meas tran vdout0_97ck620 FIND v(dout0_97) AT=315.025n

.meas tran vdout0_98ck620 FIND v(dout0_98) AT=315.025n

.meas tran vdout0_99ck620 FIND v(dout0_99) AT=315.025n

.meas tran vdout0_100ck620 FIND v(dout0_100) AT=315.025n

.meas tran vdout0_101ck620 FIND v(dout0_101) AT=315.025n

.meas tran vdout0_102ck620 FIND v(dout0_102) AT=315.025n

.meas tran vdout0_103ck620 FIND v(dout0_103) AT=315.025n

.meas tran vdout0_104ck620 FIND v(dout0_104) AT=315.025n

.meas tran vdout0_105ck620 FIND v(dout0_105) AT=315.025n

.meas tran vdout0_106ck620 FIND v(dout0_106) AT=315.025n

.meas tran vdout0_107ck620 FIND v(dout0_107) AT=315.025n

.meas tran vdout0_108ck620 FIND v(dout0_108) AT=315.025n

.meas tran vdout0_109ck620 FIND v(dout0_109) AT=315.025n

.meas tran vdout0_110ck620 FIND v(dout0_110) AT=315.025n

.meas tran vdout0_111ck620 FIND v(dout0_111) AT=315.025n

.meas tran vdout0_112ck620 FIND v(dout0_112) AT=315.025n

.meas tran vdout0_113ck620 FIND v(dout0_113) AT=315.025n

.meas tran vdout0_114ck620 FIND v(dout0_114) AT=315.025n

.meas tran vdout0_115ck620 FIND v(dout0_115) AT=315.025n

.meas tran vdout0_116ck620 FIND v(dout0_116) AT=315.025n

.meas tran vdout0_117ck620 FIND v(dout0_117) AT=315.025n

.meas tran vdout0_118ck620 FIND v(dout0_118) AT=315.025n

.meas tran vdout0_119ck620 FIND v(dout0_119) AT=315.025n

.meas tran vdout0_120ck620 FIND v(dout0_120) AT=315.025n

.meas tran vdout0_121ck620 FIND v(dout0_121) AT=315.025n

.meas tran vdout0_122ck620 FIND v(dout0_122) AT=315.025n

.meas tran vdout0_123ck620 FIND v(dout0_123) AT=315.025n

.meas tran vdout0_124ck620 FIND v(dout0_124) AT=315.025n

.meas tran vdout0_125ck620 FIND v(dout0_125) AT=315.025n

.meas tran vdout0_126ck620 FIND v(dout0_126) AT=315.025n

.meas tran vdout0_127ck620 FIND v(dout0_127) AT=315.025n

.meas tran vdout0_128ck620 FIND v(dout0_128) AT=315.025n

.meas tran vdout0_129ck620 FIND v(dout0_129) AT=315.025n

.meas tran vdout0_130ck620 FIND v(dout0_130) AT=315.025n

.meas tran vdout0_131ck620 FIND v(dout0_131) AT=315.025n

.meas tran vdout0_132ck620 FIND v(dout0_132) AT=315.025n

.meas tran vdout0_133ck620 FIND v(dout0_133) AT=315.025n

.meas tran vdout0_134ck620 FIND v(dout0_134) AT=315.025n

.meas tran vdout0_135ck620 FIND v(dout0_135) AT=315.025n

.meas tran vdout0_136ck620 FIND v(dout0_136) AT=315.025n

.meas tran vdout0_137ck620 FIND v(dout0_137) AT=315.025n

.meas tran vdout0_138ck620 FIND v(dout0_138) AT=315.025n

.meas tran vdout0_139ck620 FIND v(dout0_139) AT=315.025n

.meas tran vdout0_140ck620 FIND v(dout0_140) AT=315.025n

.meas tran vdout0_141ck620 FIND v(dout0_141) AT=315.025n

.meas tran vdout0_142ck620 FIND v(dout0_142) AT=315.025n

.meas tran vdout0_143ck620 FIND v(dout0_143) AT=315.025n

.meas tran vdout0_144ck620 FIND v(dout0_144) AT=315.025n

.meas tran vdout0_145ck620 FIND v(dout0_145) AT=315.025n

.meas tran vdout0_146ck620 FIND v(dout0_146) AT=315.025n

.meas tran vdout0_147ck620 FIND v(dout0_147) AT=315.025n

.meas tran vdout0_148ck620 FIND v(dout0_148) AT=315.025n

.meas tran vdout0_149ck620 FIND v(dout0_149) AT=315.025n

.meas tran vdout0_0ck630 FIND v(dout0_0) AT=320.025n

.meas tran vdout0_1ck630 FIND v(dout0_1) AT=320.025n

.meas tran vdout0_2ck630 FIND v(dout0_2) AT=320.025n

.meas tran vdout0_3ck630 FIND v(dout0_3) AT=320.025n

.meas tran vdout0_4ck630 FIND v(dout0_4) AT=320.025n

.meas tran vdout0_5ck630 FIND v(dout0_5) AT=320.025n

.meas tran vdout0_6ck630 FIND v(dout0_6) AT=320.025n

.meas tran vdout0_7ck630 FIND v(dout0_7) AT=320.025n

.meas tran vdout0_8ck630 FIND v(dout0_8) AT=320.025n

.meas tran vdout0_9ck630 FIND v(dout0_9) AT=320.025n

.meas tran vdout0_10ck630 FIND v(dout0_10) AT=320.025n

.meas tran vdout0_11ck630 FIND v(dout0_11) AT=320.025n

.meas tran vdout0_12ck630 FIND v(dout0_12) AT=320.025n

.meas tran vdout0_13ck630 FIND v(dout0_13) AT=320.025n

.meas tran vdout0_14ck630 FIND v(dout0_14) AT=320.025n

.meas tran vdout0_15ck630 FIND v(dout0_15) AT=320.025n

.meas tran vdout0_16ck630 FIND v(dout0_16) AT=320.025n

.meas tran vdout0_17ck630 FIND v(dout0_17) AT=320.025n

.meas tran vdout0_18ck630 FIND v(dout0_18) AT=320.025n

.meas tran vdout0_19ck630 FIND v(dout0_19) AT=320.025n

.meas tran vdout0_20ck630 FIND v(dout0_20) AT=320.025n

.meas tran vdout0_21ck630 FIND v(dout0_21) AT=320.025n

.meas tran vdout0_22ck630 FIND v(dout0_22) AT=320.025n

.meas tran vdout0_23ck630 FIND v(dout0_23) AT=320.025n

.meas tran vdout0_24ck630 FIND v(dout0_24) AT=320.025n

.meas tran vdout0_25ck630 FIND v(dout0_25) AT=320.025n

.meas tran vdout0_26ck630 FIND v(dout0_26) AT=320.025n

.meas tran vdout0_27ck630 FIND v(dout0_27) AT=320.025n

.meas tran vdout0_28ck630 FIND v(dout0_28) AT=320.025n

.meas tran vdout0_29ck630 FIND v(dout0_29) AT=320.025n

.meas tran vdout0_30ck630 FIND v(dout0_30) AT=320.025n

.meas tran vdout0_31ck630 FIND v(dout0_31) AT=320.025n

.meas tran vdout0_32ck630 FIND v(dout0_32) AT=320.025n

.meas tran vdout0_33ck630 FIND v(dout0_33) AT=320.025n

.meas tran vdout0_34ck630 FIND v(dout0_34) AT=320.025n

.meas tran vdout0_35ck630 FIND v(dout0_35) AT=320.025n

.meas tran vdout0_36ck630 FIND v(dout0_36) AT=320.025n

.meas tran vdout0_37ck630 FIND v(dout0_37) AT=320.025n

.meas tran vdout0_38ck630 FIND v(dout0_38) AT=320.025n

.meas tran vdout0_39ck630 FIND v(dout0_39) AT=320.025n

.meas tran vdout0_40ck630 FIND v(dout0_40) AT=320.025n

.meas tran vdout0_41ck630 FIND v(dout0_41) AT=320.025n

.meas tran vdout0_42ck630 FIND v(dout0_42) AT=320.025n

.meas tran vdout0_43ck630 FIND v(dout0_43) AT=320.025n

.meas tran vdout0_44ck630 FIND v(dout0_44) AT=320.025n

.meas tran vdout0_45ck630 FIND v(dout0_45) AT=320.025n

.meas tran vdout0_46ck630 FIND v(dout0_46) AT=320.025n

.meas tran vdout0_47ck630 FIND v(dout0_47) AT=320.025n

.meas tran vdout0_48ck630 FIND v(dout0_48) AT=320.025n

.meas tran vdout0_49ck630 FIND v(dout0_49) AT=320.025n

.meas tran vdout0_50ck630 FIND v(dout0_50) AT=320.025n

.meas tran vdout0_51ck630 FIND v(dout0_51) AT=320.025n

.meas tran vdout0_52ck630 FIND v(dout0_52) AT=320.025n

.meas tran vdout0_53ck630 FIND v(dout0_53) AT=320.025n

.meas tran vdout0_54ck630 FIND v(dout0_54) AT=320.025n

.meas tran vdout0_55ck630 FIND v(dout0_55) AT=320.025n

.meas tran vdout0_56ck630 FIND v(dout0_56) AT=320.025n

.meas tran vdout0_57ck630 FIND v(dout0_57) AT=320.025n

.meas tran vdout0_58ck630 FIND v(dout0_58) AT=320.025n

.meas tran vdout0_59ck630 FIND v(dout0_59) AT=320.025n

.meas tran vdout0_60ck630 FIND v(dout0_60) AT=320.025n

.meas tran vdout0_61ck630 FIND v(dout0_61) AT=320.025n

.meas tran vdout0_62ck630 FIND v(dout0_62) AT=320.025n

.meas tran vdout0_63ck630 FIND v(dout0_63) AT=320.025n

.meas tran vdout0_64ck630 FIND v(dout0_64) AT=320.025n

.meas tran vdout0_65ck630 FIND v(dout0_65) AT=320.025n

.meas tran vdout0_66ck630 FIND v(dout0_66) AT=320.025n

.meas tran vdout0_67ck630 FIND v(dout0_67) AT=320.025n

.meas tran vdout0_68ck630 FIND v(dout0_68) AT=320.025n

.meas tran vdout0_69ck630 FIND v(dout0_69) AT=320.025n

.meas tran vdout0_70ck630 FIND v(dout0_70) AT=320.025n

.meas tran vdout0_71ck630 FIND v(dout0_71) AT=320.025n

.meas tran vdout0_72ck630 FIND v(dout0_72) AT=320.025n

.meas tran vdout0_73ck630 FIND v(dout0_73) AT=320.025n

.meas tran vdout0_74ck630 FIND v(dout0_74) AT=320.025n

.meas tran vdout0_75ck630 FIND v(dout0_75) AT=320.025n

.meas tran vdout0_76ck630 FIND v(dout0_76) AT=320.025n

.meas tran vdout0_77ck630 FIND v(dout0_77) AT=320.025n

.meas tran vdout0_78ck630 FIND v(dout0_78) AT=320.025n

.meas tran vdout0_79ck630 FIND v(dout0_79) AT=320.025n

.meas tran vdout0_80ck630 FIND v(dout0_80) AT=320.025n

.meas tran vdout0_81ck630 FIND v(dout0_81) AT=320.025n

.meas tran vdout0_82ck630 FIND v(dout0_82) AT=320.025n

.meas tran vdout0_83ck630 FIND v(dout0_83) AT=320.025n

.meas tran vdout0_84ck630 FIND v(dout0_84) AT=320.025n

.meas tran vdout0_85ck630 FIND v(dout0_85) AT=320.025n

.meas tran vdout0_86ck630 FIND v(dout0_86) AT=320.025n

.meas tran vdout0_87ck630 FIND v(dout0_87) AT=320.025n

.meas tran vdout0_88ck630 FIND v(dout0_88) AT=320.025n

.meas tran vdout0_89ck630 FIND v(dout0_89) AT=320.025n

.meas tran vdout0_90ck630 FIND v(dout0_90) AT=320.025n

.meas tran vdout0_91ck630 FIND v(dout0_91) AT=320.025n

.meas tran vdout0_92ck630 FIND v(dout0_92) AT=320.025n

.meas tran vdout0_93ck630 FIND v(dout0_93) AT=320.025n

.meas tran vdout0_94ck630 FIND v(dout0_94) AT=320.025n

.meas tran vdout0_95ck630 FIND v(dout0_95) AT=320.025n

.meas tran vdout0_96ck630 FIND v(dout0_96) AT=320.025n

.meas tran vdout0_97ck630 FIND v(dout0_97) AT=320.025n

.meas tran vdout0_98ck630 FIND v(dout0_98) AT=320.025n

.meas tran vdout0_99ck630 FIND v(dout0_99) AT=320.025n

.meas tran vdout0_100ck630 FIND v(dout0_100) AT=320.025n

.meas tran vdout0_101ck630 FIND v(dout0_101) AT=320.025n

.meas tran vdout0_102ck630 FIND v(dout0_102) AT=320.025n

.meas tran vdout0_103ck630 FIND v(dout0_103) AT=320.025n

.meas tran vdout0_104ck630 FIND v(dout0_104) AT=320.025n

.meas tran vdout0_105ck630 FIND v(dout0_105) AT=320.025n

.meas tran vdout0_106ck630 FIND v(dout0_106) AT=320.025n

.meas tran vdout0_107ck630 FIND v(dout0_107) AT=320.025n

.meas tran vdout0_108ck630 FIND v(dout0_108) AT=320.025n

.meas tran vdout0_109ck630 FIND v(dout0_109) AT=320.025n

.meas tran vdout0_110ck630 FIND v(dout0_110) AT=320.025n

.meas tran vdout0_111ck630 FIND v(dout0_111) AT=320.025n

.meas tran vdout0_112ck630 FIND v(dout0_112) AT=320.025n

.meas tran vdout0_113ck630 FIND v(dout0_113) AT=320.025n

.meas tran vdout0_114ck630 FIND v(dout0_114) AT=320.025n

.meas tran vdout0_115ck630 FIND v(dout0_115) AT=320.025n

.meas tran vdout0_116ck630 FIND v(dout0_116) AT=320.025n

.meas tran vdout0_117ck630 FIND v(dout0_117) AT=320.025n

.meas tran vdout0_118ck630 FIND v(dout0_118) AT=320.025n

.meas tran vdout0_119ck630 FIND v(dout0_119) AT=320.025n

.meas tran vdout0_120ck630 FIND v(dout0_120) AT=320.025n

.meas tran vdout0_121ck630 FIND v(dout0_121) AT=320.025n

.meas tran vdout0_122ck630 FIND v(dout0_122) AT=320.025n

.meas tran vdout0_123ck630 FIND v(dout0_123) AT=320.025n

.meas tran vdout0_124ck630 FIND v(dout0_124) AT=320.025n

.meas tran vdout0_125ck630 FIND v(dout0_125) AT=320.025n

.meas tran vdout0_126ck630 FIND v(dout0_126) AT=320.025n

.meas tran vdout0_127ck630 FIND v(dout0_127) AT=320.025n

.meas tran vdout0_128ck630 FIND v(dout0_128) AT=320.025n

.meas tran vdout0_129ck630 FIND v(dout0_129) AT=320.025n

.meas tran vdout0_130ck630 FIND v(dout0_130) AT=320.025n

.meas tran vdout0_131ck630 FIND v(dout0_131) AT=320.025n

.meas tran vdout0_132ck630 FIND v(dout0_132) AT=320.025n

.meas tran vdout0_133ck630 FIND v(dout0_133) AT=320.025n

.meas tran vdout0_134ck630 FIND v(dout0_134) AT=320.025n

.meas tran vdout0_135ck630 FIND v(dout0_135) AT=320.025n

.meas tran vdout0_136ck630 FIND v(dout0_136) AT=320.025n

.meas tran vdout0_137ck630 FIND v(dout0_137) AT=320.025n

.meas tran vdout0_138ck630 FIND v(dout0_138) AT=320.025n

.meas tran vdout0_139ck630 FIND v(dout0_139) AT=320.025n

.meas tran vdout0_140ck630 FIND v(dout0_140) AT=320.025n

.meas tran vdout0_141ck630 FIND v(dout0_141) AT=320.025n

.meas tran vdout0_142ck630 FIND v(dout0_142) AT=320.025n

.meas tran vdout0_143ck630 FIND v(dout0_143) AT=320.025n

.meas tran vdout0_144ck630 FIND v(dout0_144) AT=320.025n

.meas tran vdout0_145ck630 FIND v(dout0_145) AT=320.025n

.meas tran vdout0_146ck630 FIND v(dout0_146) AT=320.025n

.meas tran vdout0_147ck630 FIND v(dout0_147) AT=320.025n

.meas tran vdout0_148ck630 FIND v(dout0_148) AT=320.025n

.meas tran vdout0_149ck630 FIND v(dout0_149) AT=320.025n

.meas tran vdout0_0ck660 FIND v(dout0_0) AT=335.025n

.meas tran vdout0_1ck660 FIND v(dout0_1) AT=335.025n

.meas tran vdout0_2ck660 FIND v(dout0_2) AT=335.025n

.meas tran vdout0_3ck660 FIND v(dout0_3) AT=335.025n

.meas tran vdout0_4ck660 FIND v(dout0_4) AT=335.025n

.meas tran vdout0_5ck660 FIND v(dout0_5) AT=335.025n

.meas tran vdout0_6ck660 FIND v(dout0_6) AT=335.025n

.meas tran vdout0_7ck660 FIND v(dout0_7) AT=335.025n

.meas tran vdout0_8ck660 FIND v(dout0_8) AT=335.025n

.meas tran vdout0_9ck660 FIND v(dout0_9) AT=335.025n

.meas tran vdout0_10ck660 FIND v(dout0_10) AT=335.025n

.meas tran vdout0_11ck660 FIND v(dout0_11) AT=335.025n

.meas tran vdout0_12ck660 FIND v(dout0_12) AT=335.025n

.meas tran vdout0_13ck660 FIND v(dout0_13) AT=335.025n

.meas tran vdout0_14ck660 FIND v(dout0_14) AT=335.025n

.meas tran vdout0_15ck660 FIND v(dout0_15) AT=335.025n

.meas tran vdout0_16ck660 FIND v(dout0_16) AT=335.025n

.meas tran vdout0_17ck660 FIND v(dout0_17) AT=335.025n

.meas tran vdout0_18ck660 FIND v(dout0_18) AT=335.025n

.meas tran vdout0_19ck660 FIND v(dout0_19) AT=335.025n

.meas tran vdout0_20ck660 FIND v(dout0_20) AT=335.025n

.meas tran vdout0_21ck660 FIND v(dout0_21) AT=335.025n

.meas tran vdout0_22ck660 FIND v(dout0_22) AT=335.025n

.meas tran vdout0_23ck660 FIND v(dout0_23) AT=335.025n

.meas tran vdout0_24ck660 FIND v(dout0_24) AT=335.025n

.meas tran vdout0_25ck660 FIND v(dout0_25) AT=335.025n

.meas tran vdout0_26ck660 FIND v(dout0_26) AT=335.025n

.meas tran vdout0_27ck660 FIND v(dout0_27) AT=335.025n

.meas tran vdout0_28ck660 FIND v(dout0_28) AT=335.025n

.meas tran vdout0_29ck660 FIND v(dout0_29) AT=335.025n

.meas tran vdout0_30ck660 FIND v(dout0_30) AT=335.025n

.meas tran vdout0_31ck660 FIND v(dout0_31) AT=335.025n

.meas tran vdout0_32ck660 FIND v(dout0_32) AT=335.025n

.meas tran vdout0_33ck660 FIND v(dout0_33) AT=335.025n

.meas tran vdout0_34ck660 FIND v(dout0_34) AT=335.025n

.meas tran vdout0_35ck660 FIND v(dout0_35) AT=335.025n

.meas tran vdout0_36ck660 FIND v(dout0_36) AT=335.025n

.meas tran vdout0_37ck660 FIND v(dout0_37) AT=335.025n

.meas tran vdout0_38ck660 FIND v(dout0_38) AT=335.025n

.meas tran vdout0_39ck660 FIND v(dout0_39) AT=335.025n

.meas tran vdout0_40ck660 FIND v(dout0_40) AT=335.025n

.meas tran vdout0_41ck660 FIND v(dout0_41) AT=335.025n

.meas tran vdout0_42ck660 FIND v(dout0_42) AT=335.025n

.meas tran vdout0_43ck660 FIND v(dout0_43) AT=335.025n

.meas tran vdout0_44ck660 FIND v(dout0_44) AT=335.025n

.meas tran vdout0_45ck660 FIND v(dout0_45) AT=335.025n

.meas tran vdout0_46ck660 FIND v(dout0_46) AT=335.025n

.meas tran vdout0_47ck660 FIND v(dout0_47) AT=335.025n

.meas tran vdout0_48ck660 FIND v(dout0_48) AT=335.025n

.meas tran vdout0_49ck660 FIND v(dout0_49) AT=335.025n

.meas tran vdout0_50ck660 FIND v(dout0_50) AT=335.025n

.meas tran vdout0_51ck660 FIND v(dout0_51) AT=335.025n

.meas tran vdout0_52ck660 FIND v(dout0_52) AT=335.025n

.meas tran vdout0_53ck660 FIND v(dout0_53) AT=335.025n

.meas tran vdout0_54ck660 FIND v(dout0_54) AT=335.025n

.meas tran vdout0_55ck660 FIND v(dout0_55) AT=335.025n

.meas tran vdout0_56ck660 FIND v(dout0_56) AT=335.025n

.meas tran vdout0_57ck660 FIND v(dout0_57) AT=335.025n

.meas tran vdout0_58ck660 FIND v(dout0_58) AT=335.025n

.meas tran vdout0_59ck660 FIND v(dout0_59) AT=335.025n

.meas tran vdout0_60ck660 FIND v(dout0_60) AT=335.025n

.meas tran vdout0_61ck660 FIND v(dout0_61) AT=335.025n

.meas tran vdout0_62ck660 FIND v(dout0_62) AT=335.025n

.meas tran vdout0_63ck660 FIND v(dout0_63) AT=335.025n

.meas tran vdout0_64ck660 FIND v(dout0_64) AT=335.025n

.meas tran vdout0_65ck660 FIND v(dout0_65) AT=335.025n

.meas tran vdout0_66ck660 FIND v(dout0_66) AT=335.025n

.meas tran vdout0_67ck660 FIND v(dout0_67) AT=335.025n

.meas tran vdout0_68ck660 FIND v(dout0_68) AT=335.025n

.meas tran vdout0_69ck660 FIND v(dout0_69) AT=335.025n

.meas tran vdout0_70ck660 FIND v(dout0_70) AT=335.025n

.meas tran vdout0_71ck660 FIND v(dout0_71) AT=335.025n

.meas tran vdout0_72ck660 FIND v(dout0_72) AT=335.025n

.meas tran vdout0_73ck660 FIND v(dout0_73) AT=335.025n

.meas tran vdout0_74ck660 FIND v(dout0_74) AT=335.025n

.meas tran vdout0_75ck660 FIND v(dout0_75) AT=335.025n

.meas tran vdout0_76ck660 FIND v(dout0_76) AT=335.025n

.meas tran vdout0_77ck660 FIND v(dout0_77) AT=335.025n

.meas tran vdout0_78ck660 FIND v(dout0_78) AT=335.025n

.meas tran vdout0_79ck660 FIND v(dout0_79) AT=335.025n

.meas tran vdout0_80ck660 FIND v(dout0_80) AT=335.025n

.meas tran vdout0_81ck660 FIND v(dout0_81) AT=335.025n

.meas tran vdout0_82ck660 FIND v(dout0_82) AT=335.025n

.meas tran vdout0_83ck660 FIND v(dout0_83) AT=335.025n

.meas tran vdout0_84ck660 FIND v(dout0_84) AT=335.025n

.meas tran vdout0_85ck660 FIND v(dout0_85) AT=335.025n

.meas tran vdout0_86ck660 FIND v(dout0_86) AT=335.025n

.meas tran vdout0_87ck660 FIND v(dout0_87) AT=335.025n

.meas tran vdout0_88ck660 FIND v(dout0_88) AT=335.025n

.meas tran vdout0_89ck660 FIND v(dout0_89) AT=335.025n

.meas tran vdout0_90ck660 FIND v(dout0_90) AT=335.025n

.meas tran vdout0_91ck660 FIND v(dout0_91) AT=335.025n

.meas tran vdout0_92ck660 FIND v(dout0_92) AT=335.025n

.meas tran vdout0_93ck660 FIND v(dout0_93) AT=335.025n

.meas tran vdout0_94ck660 FIND v(dout0_94) AT=335.025n

.meas tran vdout0_95ck660 FIND v(dout0_95) AT=335.025n

.meas tran vdout0_96ck660 FIND v(dout0_96) AT=335.025n

.meas tran vdout0_97ck660 FIND v(dout0_97) AT=335.025n

.meas tran vdout0_98ck660 FIND v(dout0_98) AT=335.025n

.meas tran vdout0_99ck660 FIND v(dout0_99) AT=335.025n

.meas tran vdout0_100ck660 FIND v(dout0_100) AT=335.025n

.meas tran vdout0_101ck660 FIND v(dout0_101) AT=335.025n

.meas tran vdout0_102ck660 FIND v(dout0_102) AT=335.025n

.meas tran vdout0_103ck660 FIND v(dout0_103) AT=335.025n

.meas tran vdout0_104ck660 FIND v(dout0_104) AT=335.025n

.meas tran vdout0_105ck660 FIND v(dout0_105) AT=335.025n

.meas tran vdout0_106ck660 FIND v(dout0_106) AT=335.025n

.meas tran vdout0_107ck660 FIND v(dout0_107) AT=335.025n

.meas tran vdout0_108ck660 FIND v(dout0_108) AT=335.025n

.meas tran vdout0_109ck660 FIND v(dout0_109) AT=335.025n

.meas tran vdout0_110ck660 FIND v(dout0_110) AT=335.025n

.meas tran vdout0_111ck660 FIND v(dout0_111) AT=335.025n

.meas tran vdout0_112ck660 FIND v(dout0_112) AT=335.025n

.meas tran vdout0_113ck660 FIND v(dout0_113) AT=335.025n

.meas tran vdout0_114ck660 FIND v(dout0_114) AT=335.025n

.meas tran vdout0_115ck660 FIND v(dout0_115) AT=335.025n

.meas tran vdout0_116ck660 FIND v(dout0_116) AT=335.025n

.meas tran vdout0_117ck660 FIND v(dout0_117) AT=335.025n

.meas tran vdout0_118ck660 FIND v(dout0_118) AT=335.025n

.meas tran vdout0_119ck660 FIND v(dout0_119) AT=335.025n

.meas tran vdout0_120ck660 FIND v(dout0_120) AT=335.025n

.meas tran vdout0_121ck660 FIND v(dout0_121) AT=335.025n

.meas tran vdout0_122ck660 FIND v(dout0_122) AT=335.025n

.meas tran vdout0_123ck660 FIND v(dout0_123) AT=335.025n

.meas tran vdout0_124ck660 FIND v(dout0_124) AT=335.025n

.meas tran vdout0_125ck660 FIND v(dout0_125) AT=335.025n

.meas tran vdout0_126ck660 FIND v(dout0_126) AT=335.025n

.meas tran vdout0_127ck660 FIND v(dout0_127) AT=335.025n

.meas tran vdout0_128ck660 FIND v(dout0_128) AT=335.025n

.meas tran vdout0_129ck660 FIND v(dout0_129) AT=335.025n

.meas tran vdout0_130ck660 FIND v(dout0_130) AT=335.025n

.meas tran vdout0_131ck660 FIND v(dout0_131) AT=335.025n

.meas tran vdout0_132ck660 FIND v(dout0_132) AT=335.025n

.meas tran vdout0_133ck660 FIND v(dout0_133) AT=335.025n

.meas tran vdout0_134ck660 FIND v(dout0_134) AT=335.025n

.meas tran vdout0_135ck660 FIND v(dout0_135) AT=335.025n

.meas tran vdout0_136ck660 FIND v(dout0_136) AT=335.025n

.meas tran vdout0_137ck660 FIND v(dout0_137) AT=335.025n

.meas tran vdout0_138ck660 FIND v(dout0_138) AT=335.025n

.meas tran vdout0_139ck660 FIND v(dout0_139) AT=335.025n

.meas tran vdout0_140ck660 FIND v(dout0_140) AT=335.025n

.meas tran vdout0_141ck660 FIND v(dout0_141) AT=335.025n

.meas tran vdout0_142ck660 FIND v(dout0_142) AT=335.025n

.meas tran vdout0_143ck660 FIND v(dout0_143) AT=335.025n

.meas tran vdout0_144ck660 FIND v(dout0_144) AT=335.025n

.meas tran vdout0_145ck660 FIND v(dout0_145) AT=335.025n

.meas tran vdout0_146ck660 FIND v(dout0_146) AT=335.025n

.meas tran vdout0_147ck660 FIND v(dout0_147) AT=335.025n

.meas tran vdout0_148ck660 FIND v(dout0_148) AT=335.025n

.meas tran vdout0_149ck660 FIND v(dout0_149) AT=335.025n

.meas tran vdout0_0ck670 FIND v(dout0_0) AT=340.025n

.meas tran vdout0_1ck670 FIND v(dout0_1) AT=340.025n

.meas tran vdout0_2ck670 FIND v(dout0_2) AT=340.025n

.meas tran vdout0_3ck670 FIND v(dout0_3) AT=340.025n

.meas tran vdout0_4ck670 FIND v(dout0_4) AT=340.025n

.meas tran vdout0_5ck670 FIND v(dout0_5) AT=340.025n

.meas tran vdout0_6ck670 FIND v(dout0_6) AT=340.025n

.meas tran vdout0_7ck670 FIND v(dout0_7) AT=340.025n

.meas tran vdout0_8ck670 FIND v(dout0_8) AT=340.025n

.meas tran vdout0_9ck670 FIND v(dout0_9) AT=340.025n

.meas tran vdout0_10ck670 FIND v(dout0_10) AT=340.025n

.meas tran vdout0_11ck670 FIND v(dout0_11) AT=340.025n

.meas tran vdout0_12ck670 FIND v(dout0_12) AT=340.025n

.meas tran vdout0_13ck670 FIND v(dout0_13) AT=340.025n

.meas tran vdout0_14ck670 FIND v(dout0_14) AT=340.025n

.meas tran vdout0_15ck670 FIND v(dout0_15) AT=340.025n

.meas tran vdout0_16ck670 FIND v(dout0_16) AT=340.025n

.meas tran vdout0_17ck670 FIND v(dout0_17) AT=340.025n

.meas tran vdout0_18ck670 FIND v(dout0_18) AT=340.025n

.meas tran vdout0_19ck670 FIND v(dout0_19) AT=340.025n

.meas tran vdout0_20ck670 FIND v(dout0_20) AT=340.025n

.meas tran vdout0_21ck670 FIND v(dout0_21) AT=340.025n

.meas tran vdout0_22ck670 FIND v(dout0_22) AT=340.025n

.meas tran vdout0_23ck670 FIND v(dout0_23) AT=340.025n

.meas tran vdout0_24ck670 FIND v(dout0_24) AT=340.025n

.meas tran vdout0_25ck670 FIND v(dout0_25) AT=340.025n

.meas tran vdout0_26ck670 FIND v(dout0_26) AT=340.025n

.meas tran vdout0_27ck670 FIND v(dout0_27) AT=340.025n

.meas tran vdout0_28ck670 FIND v(dout0_28) AT=340.025n

.meas tran vdout0_29ck670 FIND v(dout0_29) AT=340.025n

.meas tran vdout0_30ck670 FIND v(dout0_30) AT=340.025n

.meas tran vdout0_31ck670 FIND v(dout0_31) AT=340.025n

.meas tran vdout0_32ck670 FIND v(dout0_32) AT=340.025n

.meas tran vdout0_33ck670 FIND v(dout0_33) AT=340.025n

.meas tran vdout0_34ck670 FIND v(dout0_34) AT=340.025n

.meas tran vdout0_35ck670 FIND v(dout0_35) AT=340.025n

.meas tran vdout0_36ck670 FIND v(dout0_36) AT=340.025n

.meas tran vdout0_37ck670 FIND v(dout0_37) AT=340.025n

.meas tran vdout0_38ck670 FIND v(dout0_38) AT=340.025n

.meas tran vdout0_39ck670 FIND v(dout0_39) AT=340.025n

.meas tran vdout0_40ck670 FIND v(dout0_40) AT=340.025n

.meas tran vdout0_41ck670 FIND v(dout0_41) AT=340.025n

.meas tran vdout0_42ck670 FIND v(dout0_42) AT=340.025n

.meas tran vdout0_43ck670 FIND v(dout0_43) AT=340.025n

.meas tran vdout0_44ck670 FIND v(dout0_44) AT=340.025n

.meas tran vdout0_45ck670 FIND v(dout0_45) AT=340.025n

.meas tran vdout0_46ck670 FIND v(dout0_46) AT=340.025n

.meas tran vdout0_47ck670 FIND v(dout0_47) AT=340.025n

.meas tran vdout0_48ck670 FIND v(dout0_48) AT=340.025n

.meas tran vdout0_49ck670 FIND v(dout0_49) AT=340.025n

.meas tran vdout0_50ck670 FIND v(dout0_50) AT=340.025n

.meas tran vdout0_51ck670 FIND v(dout0_51) AT=340.025n

.meas tran vdout0_52ck670 FIND v(dout0_52) AT=340.025n

.meas tran vdout0_53ck670 FIND v(dout0_53) AT=340.025n

.meas tran vdout0_54ck670 FIND v(dout0_54) AT=340.025n

.meas tran vdout0_55ck670 FIND v(dout0_55) AT=340.025n

.meas tran vdout0_56ck670 FIND v(dout0_56) AT=340.025n

.meas tran vdout0_57ck670 FIND v(dout0_57) AT=340.025n

.meas tran vdout0_58ck670 FIND v(dout0_58) AT=340.025n

.meas tran vdout0_59ck670 FIND v(dout0_59) AT=340.025n

.meas tran vdout0_60ck670 FIND v(dout0_60) AT=340.025n

.meas tran vdout0_61ck670 FIND v(dout0_61) AT=340.025n

.meas tran vdout0_62ck670 FIND v(dout0_62) AT=340.025n

.meas tran vdout0_63ck670 FIND v(dout0_63) AT=340.025n

.meas tran vdout0_64ck670 FIND v(dout0_64) AT=340.025n

.meas tran vdout0_65ck670 FIND v(dout0_65) AT=340.025n

.meas tran vdout0_66ck670 FIND v(dout0_66) AT=340.025n

.meas tran vdout0_67ck670 FIND v(dout0_67) AT=340.025n

.meas tran vdout0_68ck670 FIND v(dout0_68) AT=340.025n

.meas tran vdout0_69ck670 FIND v(dout0_69) AT=340.025n

.meas tran vdout0_70ck670 FIND v(dout0_70) AT=340.025n

.meas tran vdout0_71ck670 FIND v(dout0_71) AT=340.025n

.meas tran vdout0_72ck670 FIND v(dout0_72) AT=340.025n

.meas tran vdout0_73ck670 FIND v(dout0_73) AT=340.025n

.meas tran vdout0_74ck670 FIND v(dout0_74) AT=340.025n

.meas tran vdout0_75ck670 FIND v(dout0_75) AT=340.025n

.meas tran vdout0_76ck670 FIND v(dout0_76) AT=340.025n

.meas tran vdout0_77ck670 FIND v(dout0_77) AT=340.025n

.meas tran vdout0_78ck670 FIND v(dout0_78) AT=340.025n

.meas tran vdout0_79ck670 FIND v(dout0_79) AT=340.025n

.meas tran vdout0_80ck670 FIND v(dout0_80) AT=340.025n

.meas tran vdout0_81ck670 FIND v(dout0_81) AT=340.025n

.meas tran vdout0_82ck670 FIND v(dout0_82) AT=340.025n

.meas tran vdout0_83ck670 FIND v(dout0_83) AT=340.025n

.meas tran vdout0_84ck670 FIND v(dout0_84) AT=340.025n

.meas tran vdout0_85ck670 FIND v(dout0_85) AT=340.025n

.meas tran vdout0_86ck670 FIND v(dout0_86) AT=340.025n

.meas tran vdout0_87ck670 FIND v(dout0_87) AT=340.025n

.meas tran vdout0_88ck670 FIND v(dout0_88) AT=340.025n

.meas tran vdout0_89ck670 FIND v(dout0_89) AT=340.025n

.meas tran vdout0_90ck670 FIND v(dout0_90) AT=340.025n

.meas tran vdout0_91ck670 FIND v(dout0_91) AT=340.025n

.meas tran vdout0_92ck670 FIND v(dout0_92) AT=340.025n

.meas tran vdout0_93ck670 FIND v(dout0_93) AT=340.025n

.meas tran vdout0_94ck670 FIND v(dout0_94) AT=340.025n

.meas tran vdout0_95ck670 FIND v(dout0_95) AT=340.025n

.meas tran vdout0_96ck670 FIND v(dout0_96) AT=340.025n

.meas tran vdout0_97ck670 FIND v(dout0_97) AT=340.025n

.meas tran vdout0_98ck670 FIND v(dout0_98) AT=340.025n

.meas tran vdout0_99ck670 FIND v(dout0_99) AT=340.025n

.meas tran vdout0_100ck670 FIND v(dout0_100) AT=340.025n

.meas tran vdout0_101ck670 FIND v(dout0_101) AT=340.025n

.meas tran vdout0_102ck670 FIND v(dout0_102) AT=340.025n

.meas tran vdout0_103ck670 FIND v(dout0_103) AT=340.025n

.meas tran vdout0_104ck670 FIND v(dout0_104) AT=340.025n

.meas tran vdout0_105ck670 FIND v(dout0_105) AT=340.025n

.meas tran vdout0_106ck670 FIND v(dout0_106) AT=340.025n

.meas tran vdout0_107ck670 FIND v(dout0_107) AT=340.025n

.meas tran vdout0_108ck670 FIND v(dout0_108) AT=340.025n

.meas tran vdout0_109ck670 FIND v(dout0_109) AT=340.025n

.meas tran vdout0_110ck670 FIND v(dout0_110) AT=340.025n

.meas tran vdout0_111ck670 FIND v(dout0_111) AT=340.025n

.meas tran vdout0_112ck670 FIND v(dout0_112) AT=340.025n

.meas tran vdout0_113ck670 FIND v(dout0_113) AT=340.025n

.meas tran vdout0_114ck670 FIND v(dout0_114) AT=340.025n

.meas tran vdout0_115ck670 FIND v(dout0_115) AT=340.025n

.meas tran vdout0_116ck670 FIND v(dout0_116) AT=340.025n

.meas tran vdout0_117ck670 FIND v(dout0_117) AT=340.025n

.meas tran vdout0_118ck670 FIND v(dout0_118) AT=340.025n

.meas tran vdout0_119ck670 FIND v(dout0_119) AT=340.025n

.meas tran vdout0_120ck670 FIND v(dout0_120) AT=340.025n

.meas tran vdout0_121ck670 FIND v(dout0_121) AT=340.025n

.meas tran vdout0_122ck670 FIND v(dout0_122) AT=340.025n

.meas tran vdout0_123ck670 FIND v(dout0_123) AT=340.025n

.meas tran vdout0_124ck670 FIND v(dout0_124) AT=340.025n

.meas tran vdout0_125ck670 FIND v(dout0_125) AT=340.025n

.meas tran vdout0_126ck670 FIND v(dout0_126) AT=340.025n

.meas tran vdout0_127ck670 FIND v(dout0_127) AT=340.025n

.meas tran vdout0_128ck670 FIND v(dout0_128) AT=340.025n

.meas tran vdout0_129ck670 FIND v(dout0_129) AT=340.025n

.meas tran vdout0_130ck670 FIND v(dout0_130) AT=340.025n

.meas tran vdout0_131ck670 FIND v(dout0_131) AT=340.025n

.meas tran vdout0_132ck670 FIND v(dout0_132) AT=340.025n

.meas tran vdout0_133ck670 FIND v(dout0_133) AT=340.025n

.meas tran vdout0_134ck670 FIND v(dout0_134) AT=340.025n

.meas tran vdout0_135ck670 FIND v(dout0_135) AT=340.025n

.meas tran vdout0_136ck670 FIND v(dout0_136) AT=340.025n

.meas tran vdout0_137ck670 FIND v(dout0_137) AT=340.025n

.meas tran vdout0_138ck670 FIND v(dout0_138) AT=340.025n

.meas tran vdout0_139ck670 FIND v(dout0_139) AT=340.025n

.meas tran vdout0_140ck670 FIND v(dout0_140) AT=340.025n

.meas tran vdout0_141ck670 FIND v(dout0_141) AT=340.025n

.meas tran vdout0_142ck670 FIND v(dout0_142) AT=340.025n

.meas tran vdout0_143ck670 FIND v(dout0_143) AT=340.025n

.meas tran vdout0_144ck670 FIND v(dout0_144) AT=340.025n

.meas tran vdout0_145ck670 FIND v(dout0_145) AT=340.025n

.meas tran vdout0_146ck670 FIND v(dout0_146) AT=340.025n

.meas tran vdout0_147ck670 FIND v(dout0_147) AT=340.025n

.meas tran vdout0_148ck670 FIND v(dout0_148) AT=340.025n

.meas tran vdout0_149ck670 FIND v(dout0_149) AT=340.025n

.meas tran vdout0_0ck680 FIND v(dout0_0) AT=345.025n

.meas tran vdout0_1ck680 FIND v(dout0_1) AT=345.025n

.meas tran vdout0_2ck680 FIND v(dout0_2) AT=345.025n

.meas tran vdout0_3ck680 FIND v(dout0_3) AT=345.025n

.meas tran vdout0_4ck680 FIND v(dout0_4) AT=345.025n

.meas tran vdout0_5ck680 FIND v(dout0_5) AT=345.025n

.meas tran vdout0_6ck680 FIND v(dout0_6) AT=345.025n

.meas tran vdout0_7ck680 FIND v(dout0_7) AT=345.025n

.meas tran vdout0_8ck680 FIND v(dout0_8) AT=345.025n

.meas tran vdout0_9ck680 FIND v(dout0_9) AT=345.025n

.meas tran vdout0_10ck680 FIND v(dout0_10) AT=345.025n

.meas tran vdout0_11ck680 FIND v(dout0_11) AT=345.025n

.meas tran vdout0_12ck680 FIND v(dout0_12) AT=345.025n

.meas tran vdout0_13ck680 FIND v(dout0_13) AT=345.025n

.meas tran vdout0_14ck680 FIND v(dout0_14) AT=345.025n

.meas tran vdout0_15ck680 FIND v(dout0_15) AT=345.025n

.meas tran vdout0_16ck680 FIND v(dout0_16) AT=345.025n

.meas tran vdout0_17ck680 FIND v(dout0_17) AT=345.025n

.meas tran vdout0_18ck680 FIND v(dout0_18) AT=345.025n

.meas tran vdout0_19ck680 FIND v(dout0_19) AT=345.025n

.meas tran vdout0_20ck680 FIND v(dout0_20) AT=345.025n

.meas tran vdout0_21ck680 FIND v(dout0_21) AT=345.025n

.meas tran vdout0_22ck680 FIND v(dout0_22) AT=345.025n

.meas tran vdout0_23ck680 FIND v(dout0_23) AT=345.025n

.meas tran vdout0_24ck680 FIND v(dout0_24) AT=345.025n

.meas tran vdout0_25ck680 FIND v(dout0_25) AT=345.025n

.meas tran vdout0_26ck680 FIND v(dout0_26) AT=345.025n

.meas tran vdout0_27ck680 FIND v(dout0_27) AT=345.025n

.meas tran vdout0_28ck680 FIND v(dout0_28) AT=345.025n

.meas tran vdout0_29ck680 FIND v(dout0_29) AT=345.025n

.meas tran vdout0_30ck680 FIND v(dout0_30) AT=345.025n

.meas tran vdout0_31ck680 FIND v(dout0_31) AT=345.025n

.meas tran vdout0_32ck680 FIND v(dout0_32) AT=345.025n

.meas tran vdout0_33ck680 FIND v(dout0_33) AT=345.025n

.meas tran vdout0_34ck680 FIND v(dout0_34) AT=345.025n

.meas tran vdout0_35ck680 FIND v(dout0_35) AT=345.025n

.meas tran vdout0_36ck680 FIND v(dout0_36) AT=345.025n

.meas tran vdout0_37ck680 FIND v(dout0_37) AT=345.025n

.meas tran vdout0_38ck680 FIND v(dout0_38) AT=345.025n

.meas tran vdout0_39ck680 FIND v(dout0_39) AT=345.025n

.meas tran vdout0_40ck680 FIND v(dout0_40) AT=345.025n

.meas tran vdout0_41ck680 FIND v(dout0_41) AT=345.025n

.meas tran vdout0_42ck680 FIND v(dout0_42) AT=345.025n

.meas tran vdout0_43ck680 FIND v(dout0_43) AT=345.025n

.meas tran vdout0_44ck680 FIND v(dout0_44) AT=345.025n

.meas tran vdout0_45ck680 FIND v(dout0_45) AT=345.025n

.meas tran vdout0_46ck680 FIND v(dout0_46) AT=345.025n

.meas tran vdout0_47ck680 FIND v(dout0_47) AT=345.025n

.meas tran vdout0_48ck680 FIND v(dout0_48) AT=345.025n

.meas tran vdout0_49ck680 FIND v(dout0_49) AT=345.025n

.meas tran vdout0_50ck680 FIND v(dout0_50) AT=345.025n

.meas tran vdout0_51ck680 FIND v(dout0_51) AT=345.025n

.meas tran vdout0_52ck680 FIND v(dout0_52) AT=345.025n

.meas tran vdout0_53ck680 FIND v(dout0_53) AT=345.025n

.meas tran vdout0_54ck680 FIND v(dout0_54) AT=345.025n

.meas tran vdout0_55ck680 FIND v(dout0_55) AT=345.025n

.meas tran vdout0_56ck680 FIND v(dout0_56) AT=345.025n

.meas tran vdout0_57ck680 FIND v(dout0_57) AT=345.025n

.meas tran vdout0_58ck680 FIND v(dout0_58) AT=345.025n

.meas tran vdout0_59ck680 FIND v(dout0_59) AT=345.025n

.meas tran vdout0_60ck680 FIND v(dout0_60) AT=345.025n

.meas tran vdout0_61ck680 FIND v(dout0_61) AT=345.025n

.meas tran vdout0_62ck680 FIND v(dout0_62) AT=345.025n

.meas tran vdout0_63ck680 FIND v(dout0_63) AT=345.025n

.meas tran vdout0_64ck680 FIND v(dout0_64) AT=345.025n

.meas tran vdout0_65ck680 FIND v(dout0_65) AT=345.025n

.meas tran vdout0_66ck680 FIND v(dout0_66) AT=345.025n

.meas tran vdout0_67ck680 FIND v(dout0_67) AT=345.025n

.meas tran vdout0_68ck680 FIND v(dout0_68) AT=345.025n

.meas tran vdout0_69ck680 FIND v(dout0_69) AT=345.025n

.meas tran vdout0_70ck680 FIND v(dout0_70) AT=345.025n

.meas tran vdout0_71ck680 FIND v(dout0_71) AT=345.025n

.meas tran vdout0_72ck680 FIND v(dout0_72) AT=345.025n

.meas tran vdout0_73ck680 FIND v(dout0_73) AT=345.025n

.meas tran vdout0_74ck680 FIND v(dout0_74) AT=345.025n

.meas tran vdout0_75ck680 FIND v(dout0_75) AT=345.025n

.meas tran vdout0_76ck680 FIND v(dout0_76) AT=345.025n

.meas tran vdout0_77ck680 FIND v(dout0_77) AT=345.025n

.meas tran vdout0_78ck680 FIND v(dout0_78) AT=345.025n

.meas tran vdout0_79ck680 FIND v(dout0_79) AT=345.025n

.meas tran vdout0_80ck680 FIND v(dout0_80) AT=345.025n

.meas tran vdout0_81ck680 FIND v(dout0_81) AT=345.025n

.meas tran vdout0_82ck680 FIND v(dout0_82) AT=345.025n

.meas tran vdout0_83ck680 FIND v(dout0_83) AT=345.025n

.meas tran vdout0_84ck680 FIND v(dout0_84) AT=345.025n

.meas tran vdout0_85ck680 FIND v(dout0_85) AT=345.025n

.meas tran vdout0_86ck680 FIND v(dout0_86) AT=345.025n

.meas tran vdout0_87ck680 FIND v(dout0_87) AT=345.025n

.meas tran vdout0_88ck680 FIND v(dout0_88) AT=345.025n

.meas tran vdout0_89ck680 FIND v(dout0_89) AT=345.025n

.meas tran vdout0_90ck680 FIND v(dout0_90) AT=345.025n

.meas tran vdout0_91ck680 FIND v(dout0_91) AT=345.025n

.meas tran vdout0_92ck680 FIND v(dout0_92) AT=345.025n

.meas tran vdout0_93ck680 FIND v(dout0_93) AT=345.025n

.meas tran vdout0_94ck680 FIND v(dout0_94) AT=345.025n

.meas tran vdout0_95ck680 FIND v(dout0_95) AT=345.025n

.meas tran vdout0_96ck680 FIND v(dout0_96) AT=345.025n

.meas tran vdout0_97ck680 FIND v(dout0_97) AT=345.025n

.meas tran vdout0_98ck680 FIND v(dout0_98) AT=345.025n

.meas tran vdout0_99ck680 FIND v(dout0_99) AT=345.025n

.meas tran vdout0_100ck680 FIND v(dout0_100) AT=345.025n

.meas tran vdout0_101ck680 FIND v(dout0_101) AT=345.025n

.meas tran vdout0_102ck680 FIND v(dout0_102) AT=345.025n

.meas tran vdout0_103ck680 FIND v(dout0_103) AT=345.025n

.meas tran vdout0_104ck680 FIND v(dout0_104) AT=345.025n

.meas tran vdout0_105ck680 FIND v(dout0_105) AT=345.025n

.meas tran vdout0_106ck680 FIND v(dout0_106) AT=345.025n

.meas tran vdout0_107ck680 FIND v(dout0_107) AT=345.025n

.meas tran vdout0_108ck680 FIND v(dout0_108) AT=345.025n

.meas tran vdout0_109ck680 FIND v(dout0_109) AT=345.025n

.meas tran vdout0_110ck680 FIND v(dout0_110) AT=345.025n

.meas tran vdout0_111ck680 FIND v(dout0_111) AT=345.025n

.meas tran vdout0_112ck680 FIND v(dout0_112) AT=345.025n

.meas tran vdout0_113ck680 FIND v(dout0_113) AT=345.025n

.meas tran vdout0_114ck680 FIND v(dout0_114) AT=345.025n

.meas tran vdout0_115ck680 FIND v(dout0_115) AT=345.025n

.meas tran vdout0_116ck680 FIND v(dout0_116) AT=345.025n

.meas tran vdout0_117ck680 FIND v(dout0_117) AT=345.025n

.meas tran vdout0_118ck680 FIND v(dout0_118) AT=345.025n

.meas tran vdout0_119ck680 FIND v(dout0_119) AT=345.025n

.meas tran vdout0_120ck680 FIND v(dout0_120) AT=345.025n

.meas tran vdout0_121ck680 FIND v(dout0_121) AT=345.025n

.meas tran vdout0_122ck680 FIND v(dout0_122) AT=345.025n

.meas tran vdout0_123ck680 FIND v(dout0_123) AT=345.025n

.meas tran vdout0_124ck680 FIND v(dout0_124) AT=345.025n

.meas tran vdout0_125ck680 FIND v(dout0_125) AT=345.025n

.meas tran vdout0_126ck680 FIND v(dout0_126) AT=345.025n

.meas tran vdout0_127ck680 FIND v(dout0_127) AT=345.025n

.meas tran vdout0_128ck680 FIND v(dout0_128) AT=345.025n

.meas tran vdout0_129ck680 FIND v(dout0_129) AT=345.025n

.meas tran vdout0_130ck680 FIND v(dout0_130) AT=345.025n

.meas tran vdout0_131ck680 FIND v(dout0_131) AT=345.025n

.meas tran vdout0_132ck680 FIND v(dout0_132) AT=345.025n

.meas tran vdout0_133ck680 FIND v(dout0_133) AT=345.025n

.meas tran vdout0_134ck680 FIND v(dout0_134) AT=345.025n

.meas tran vdout0_135ck680 FIND v(dout0_135) AT=345.025n

.meas tran vdout0_136ck680 FIND v(dout0_136) AT=345.025n

.meas tran vdout0_137ck680 FIND v(dout0_137) AT=345.025n

.meas tran vdout0_138ck680 FIND v(dout0_138) AT=345.025n

.meas tran vdout0_139ck680 FIND v(dout0_139) AT=345.025n

.meas tran vdout0_140ck680 FIND v(dout0_140) AT=345.025n

.meas tran vdout0_141ck680 FIND v(dout0_141) AT=345.025n

.meas tran vdout0_142ck680 FIND v(dout0_142) AT=345.025n

.meas tran vdout0_143ck680 FIND v(dout0_143) AT=345.025n

.meas tran vdout0_144ck680 FIND v(dout0_144) AT=345.025n

.meas tran vdout0_145ck680 FIND v(dout0_145) AT=345.025n

.meas tran vdout0_146ck680 FIND v(dout0_146) AT=345.025n

.meas tran vdout0_147ck680 FIND v(dout0_147) AT=345.025n

.meas tran vdout0_148ck680 FIND v(dout0_148) AT=345.025n

.meas tran vdout0_149ck680 FIND v(dout0_149) AT=345.025n

.meas tran vdout0_0ck700 FIND v(dout0_0) AT=355.025n

.meas tran vdout0_1ck700 FIND v(dout0_1) AT=355.025n

.meas tran vdout0_2ck700 FIND v(dout0_2) AT=355.025n

.meas tran vdout0_3ck700 FIND v(dout0_3) AT=355.025n

.meas tran vdout0_4ck700 FIND v(dout0_4) AT=355.025n

.meas tran vdout0_5ck700 FIND v(dout0_5) AT=355.025n

.meas tran vdout0_6ck700 FIND v(dout0_6) AT=355.025n

.meas tran vdout0_7ck700 FIND v(dout0_7) AT=355.025n

.meas tran vdout0_8ck700 FIND v(dout0_8) AT=355.025n

.meas tran vdout0_9ck700 FIND v(dout0_9) AT=355.025n

.meas tran vdout0_10ck700 FIND v(dout0_10) AT=355.025n

.meas tran vdout0_11ck700 FIND v(dout0_11) AT=355.025n

.meas tran vdout0_12ck700 FIND v(dout0_12) AT=355.025n

.meas tran vdout0_13ck700 FIND v(dout0_13) AT=355.025n

.meas tran vdout0_14ck700 FIND v(dout0_14) AT=355.025n

.meas tran vdout0_15ck700 FIND v(dout0_15) AT=355.025n

.meas tran vdout0_16ck700 FIND v(dout0_16) AT=355.025n

.meas tran vdout0_17ck700 FIND v(dout0_17) AT=355.025n

.meas tran vdout0_18ck700 FIND v(dout0_18) AT=355.025n

.meas tran vdout0_19ck700 FIND v(dout0_19) AT=355.025n

.meas tran vdout0_20ck700 FIND v(dout0_20) AT=355.025n

.meas tran vdout0_21ck700 FIND v(dout0_21) AT=355.025n

.meas tran vdout0_22ck700 FIND v(dout0_22) AT=355.025n

.meas tran vdout0_23ck700 FIND v(dout0_23) AT=355.025n

.meas tran vdout0_24ck700 FIND v(dout0_24) AT=355.025n

.meas tran vdout0_25ck700 FIND v(dout0_25) AT=355.025n

.meas tran vdout0_26ck700 FIND v(dout0_26) AT=355.025n

.meas tran vdout0_27ck700 FIND v(dout0_27) AT=355.025n

.meas tran vdout0_28ck700 FIND v(dout0_28) AT=355.025n

.meas tran vdout0_29ck700 FIND v(dout0_29) AT=355.025n

.meas tran vdout0_30ck700 FIND v(dout0_30) AT=355.025n

.meas tran vdout0_31ck700 FIND v(dout0_31) AT=355.025n

.meas tran vdout0_32ck700 FIND v(dout0_32) AT=355.025n

.meas tran vdout0_33ck700 FIND v(dout0_33) AT=355.025n

.meas tran vdout0_34ck700 FIND v(dout0_34) AT=355.025n

.meas tran vdout0_35ck700 FIND v(dout0_35) AT=355.025n

.meas tran vdout0_36ck700 FIND v(dout0_36) AT=355.025n

.meas tran vdout0_37ck700 FIND v(dout0_37) AT=355.025n

.meas tran vdout0_38ck700 FIND v(dout0_38) AT=355.025n

.meas tran vdout0_39ck700 FIND v(dout0_39) AT=355.025n

.meas tran vdout0_40ck700 FIND v(dout0_40) AT=355.025n

.meas tran vdout0_41ck700 FIND v(dout0_41) AT=355.025n

.meas tran vdout0_42ck700 FIND v(dout0_42) AT=355.025n

.meas tran vdout0_43ck700 FIND v(dout0_43) AT=355.025n

.meas tran vdout0_44ck700 FIND v(dout0_44) AT=355.025n

.meas tran vdout0_45ck700 FIND v(dout0_45) AT=355.025n

.meas tran vdout0_46ck700 FIND v(dout0_46) AT=355.025n

.meas tran vdout0_47ck700 FIND v(dout0_47) AT=355.025n

.meas tran vdout0_48ck700 FIND v(dout0_48) AT=355.025n

.meas tran vdout0_49ck700 FIND v(dout0_49) AT=355.025n

.meas tran vdout0_50ck700 FIND v(dout0_50) AT=355.025n

.meas tran vdout0_51ck700 FIND v(dout0_51) AT=355.025n

.meas tran vdout0_52ck700 FIND v(dout0_52) AT=355.025n

.meas tran vdout0_53ck700 FIND v(dout0_53) AT=355.025n

.meas tran vdout0_54ck700 FIND v(dout0_54) AT=355.025n

.meas tran vdout0_55ck700 FIND v(dout0_55) AT=355.025n

.meas tran vdout0_56ck700 FIND v(dout0_56) AT=355.025n

.meas tran vdout0_57ck700 FIND v(dout0_57) AT=355.025n

.meas tran vdout0_58ck700 FIND v(dout0_58) AT=355.025n

.meas tran vdout0_59ck700 FIND v(dout0_59) AT=355.025n

.meas tran vdout0_60ck700 FIND v(dout0_60) AT=355.025n

.meas tran vdout0_61ck700 FIND v(dout0_61) AT=355.025n

.meas tran vdout0_62ck700 FIND v(dout0_62) AT=355.025n

.meas tran vdout0_63ck700 FIND v(dout0_63) AT=355.025n

.meas tran vdout0_64ck700 FIND v(dout0_64) AT=355.025n

.meas tran vdout0_65ck700 FIND v(dout0_65) AT=355.025n

.meas tran vdout0_66ck700 FIND v(dout0_66) AT=355.025n

.meas tran vdout0_67ck700 FIND v(dout0_67) AT=355.025n

.meas tran vdout0_68ck700 FIND v(dout0_68) AT=355.025n

.meas tran vdout0_69ck700 FIND v(dout0_69) AT=355.025n

.meas tran vdout0_70ck700 FIND v(dout0_70) AT=355.025n

.meas tran vdout0_71ck700 FIND v(dout0_71) AT=355.025n

.meas tran vdout0_72ck700 FIND v(dout0_72) AT=355.025n

.meas tran vdout0_73ck700 FIND v(dout0_73) AT=355.025n

.meas tran vdout0_74ck700 FIND v(dout0_74) AT=355.025n

.meas tran vdout0_75ck700 FIND v(dout0_75) AT=355.025n

.meas tran vdout0_76ck700 FIND v(dout0_76) AT=355.025n

.meas tran vdout0_77ck700 FIND v(dout0_77) AT=355.025n

.meas tran vdout0_78ck700 FIND v(dout0_78) AT=355.025n

.meas tran vdout0_79ck700 FIND v(dout0_79) AT=355.025n

.meas tran vdout0_80ck700 FIND v(dout0_80) AT=355.025n

.meas tran vdout0_81ck700 FIND v(dout0_81) AT=355.025n

.meas tran vdout0_82ck700 FIND v(dout0_82) AT=355.025n

.meas tran vdout0_83ck700 FIND v(dout0_83) AT=355.025n

.meas tran vdout0_84ck700 FIND v(dout0_84) AT=355.025n

.meas tran vdout0_85ck700 FIND v(dout0_85) AT=355.025n

.meas tran vdout0_86ck700 FIND v(dout0_86) AT=355.025n

.meas tran vdout0_87ck700 FIND v(dout0_87) AT=355.025n

.meas tran vdout0_88ck700 FIND v(dout0_88) AT=355.025n

.meas tran vdout0_89ck700 FIND v(dout0_89) AT=355.025n

.meas tran vdout0_90ck700 FIND v(dout0_90) AT=355.025n

.meas tran vdout0_91ck700 FIND v(dout0_91) AT=355.025n

.meas tran vdout0_92ck700 FIND v(dout0_92) AT=355.025n

.meas tran vdout0_93ck700 FIND v(dout0_93) AT=355.025n

.meas tran vdout0_94ck700 FIND v(dout0_94) AT=355.025n

.meas tran vdout0_95ck700 FIND v(dout0_95) AT=355.025n

.meas tran vdout0_96ck700 FIND v(dout0_96) AT=355.025n

.meas tran vdout0_97ck700 FIND v(dout0_97) AT=355.025n

.meas tran vdout0_98ck700 FIND v(dout0_98) AT=355.025n

.meas tran vdout0_99ck700 FIND v(dout0_99) AT=355.025n

.meas tran vdout0_100ck700 FIND v(dout0_100) AT=355.025n

.meas tran vdout0_101ck700 FIND v(dout0_101) AT=355.025n

.meas tran vdout0_102ck700 FIND v(dout0_102) AT=355.025n

.meas tran vdout0_103ck700 FIND v(dout0_103) AT=355.025n

.meas tran vdout0_104ck700 FIND v(dout0_104) AT=355.025n

.meas tran vdout0_105ck700 FIND v(dout0_105) AT=355.025n

.meas tran vdout0_106ck700 FIND v(dout0_106) AT=355.025n

.meas tran vdout0_107ck700 FIND v(dout0_107) AT=355.025n

.meas tran vdout0_108ck700 FIND v(dout0_108) AT=355.025n

.meas tran vdout0_109ck700 FIND v(dout0_109) AT=355.025n

.meas tran vdout0_110ck700 FIND v(dout0_110) AT=355.025n

.meas tran vdout0_111ck700 FIND v(dout0_111) AT=355.025n

.meas tran vdout0_112ck700 FIND v(dout0_112) AT=355.025n

.meas tran vdout0_113ck700 FIND v(dout0_113) AT=355.025n

.meas tran vdout0_114ck700 FIND v(dout0_114) AT=355.025n

.meas tran vdout0_115ck700 FIND v(dout0_115) AT=355.025n

.meas tran vdout0_116ck700 FIND v(dout0_116) AT=355.025n

.meas tran vdout0_117ck700 FIND v(dout0_117) AT=355.025n

.meas tran vdout0_118ck700 FIND v(dout0_118) AT=355.025n

.meas tran vdout0_119ck700 FIND v(dout0_119) AT=355.025n

.meas tran vdout0_120ck700 FIND v(dout0_120) AT=355.025n

.meas tran vdout0_121ck700 FIND v(dout0_121) AT=355.025n

.meas tran vdout0_122ck700 FIND v(dout0_122) AT=355.025n

.meas tran vdout0_123ck700 FIND v(dout0_123) AT=355.025n

.meas tran vdout0_124ck700 FIND v(dout0_124) AT=355.025n

.meas tran vdout0_125ck700 FIND v(dout0_125) AT=355.025n

.meas tran vdout0_126ck700 FIND v(dout0_126) AT=355.025n

.meas tran vdout0_127ck700 FIND v(dout0_127) AT=355.025n

.meas tran vdout0_128ck700 FIND v(dout0_128) AT=355.025n

.meas tran vdout0_129ck700 FIND v(dout0_129) AT=355.025n

.meas tran vdout0_130ck700 FIND v(dout0_130) AT=355.025n

.meas tran vdout0_131ck700 FIND v(dout0_131) AT=355.025n

.meas tran vdout0_132ck700 FIND v(dout0_132) AT=355.025n

.meas tran vdout0_133ck700 FIND v(dout0_133) AT=355.025n

.meas tran vdout0_134ck700 FIND v(dout0_134) AT=355.025n

.meas tran vdout0_135ck700 FIND v(dout0_135) AT=355.025n

.meas tran vdout0_136ck700 FIND v(dout0_136) AT=355.025n

.meas tran vdout0_137ck700 FIND v(dout0_137) AT=355.025n

.meas tran vdout0_138ck700 FIND v(dout0_138) AT=355.025n

.meas tran vdout0_139ck700 FIND v(dout0_139) AT=355.025n

.meas tran vdout0_140ck700 FIND v(dout0_140) AT=355.025n

.meas tran vdout0_141ck700 FIND v(dout0_141) AT=355.025n

.meas tran vdout0_142ck700 FIND v(dout0_142) AT=355.025n

.meas tran vdout0_143ck700 FIND v(dout0_143) AT=355.025n

.meas tran vdout0_144ck700 FIND v(dout0_144) AT=355.025n

.meas tran vdout0_145ck700 FIND v(dout0_145) AT=355.025n

.meas tran vdout0_146ck700 FIND v(dout0_146) AT=355.025n

.meas tran vdout0_147ck700 FIND v(dout0_147) AT=355.025n

.meas tran vdout0_148ck700 FIND v(dout0_148) AT=355.025n

.meas tran vdout0_149ck700 FIND v(dout0_149) AT=355.025n

.meas tran vdout0_0ck710 FIND v(dout0_0) AT=360.025n

.meas tran vdout0_1ck710 FIND v(dout0_1) AT=360.025n

.meas tran vdout0_2ck710 FIND v(dout0_2) AT=360.025n

.meas tran vdout0_3ck710 FIND v(dout0_3) AT=360.025n

.meas tran vdout0_4ck710 FIND v(dout0_4) AT=360.025n

.meas tran vdout0_5ck710 FIND v(dout0_5) AT=360.025n

.meas tran vdout0_6ck710 FIND v(dout0_6) AT=360.025n

.meas tran vdout0_7ck710 FIND v(dout0_7) AT=360.025n

.meas tran vdout0_8ck710 FIND v(dout0_8) AT=360.025n

.meas tran vdout0_9ck710 FIND v(dout0_9) AT=360.025n

.meas tran vdout0_10ck710 FIND v(dout0_10) AT=360.025n

.meas tran vdout0_11ck710 FIND v(dout0_11) AT=360.025n

.meas tran vdout0_12ck710 FIND v(dout0_12) AT=360.025n

.meas tran vdout0_13ck710 FIND v(dout0_13) AT=360.025n

.meas tran vdout0_14ck710 FIND v(dout0_14) AT=360.025n

.meas tran vdout0_15ck710 FIND v(dout0_15) AT=360.025n

.meas tran vdout0_16ck710 FIND v(dout0_16) AT=360.025n

.meas tran vdout0_17ck710 FIND v(dout0_17) AT=360.025n

.meas tran vdout0_18ck710 FIND v(dout0_18) AT=360.025n

.meas tran vdout0_19ck710 FIND v(dout0_19) AT=360.025n

.meas tran vdout0_20ck710 FIND v(dout0_20) AT=360.025n

.meas tran vdout0_21ck710 FIND v(dout0_21) AT=360.025n

.meas tran vdout0_22ck710 FIND v(dout0_22) AT=360.025n

.meas tran vdout0_23ck710 FIND v(dout0_23) AT=360.025n

.meas tran vdout0_24ck710 FIND v(dout0_24) AT=360.025n

.meas tran vdout0_25ck710 FIND v(dout0_25) AT=360.025n

.meas tran vdout0_26ck710 FIND v(dout0_26) AT=360.025n

.meas tran vdout0_27ck710 FIND v(dout0_27) AT=360.025n

.meas tran vdout0_28ck710 FIND v(dout0_28) AT=360.025n

.meas tran vdout0_29ck710 FIND v(dout0_29) AT=360.025n

.meas tran vdout0_30ck710 FIND v(dout0_30) AT=360.025n

.meas tran vdout0_31ck710 FIND v(dout0_31) AT=360.025n

.meas tran vdout0_32ck710 FIND v(dout0_32) AT=360.025n

.meas tran vdout0_33ck710 FIND v(dout0_33) AT=360.025n

.meas tran vdout0_34ck710 FIND v(dout0_34) AT=360.025n

.meas tran vdout0_35ck710 FIND v(dout0_35) AT=360.025n

.meas tran vdout0_36ck710 FIND v(dout0_36) AT=360.025n

.meas tran vdout0_37ck710 FIND v(dout0_37) AT=360.025n

.meas tran vdout0_38ck710 FIND v(dout0_38) AT=360.025n

.meas tran vdout0_39ck710 FIND v(dout0_39) AT=360.025n

.meas tran vdout0_40ck710 FIND v(dout0_40) AT=360.025n

.meas tran vdout0_41ck710 FIND v(dout0_41) AT=360.025n

.meas tran vdout0_42ck710 FIND v(dout0_42) AT=360.025n

.meas tran vdout0_43ck710 FIND v(dout0_43) AT=360.025n

.meas tran vdout0_44ck710 FIND v(dout0_44) AT=360.025n

.meas tran vdout0_45ck710 FIND v(dout0_45) AT=360.025n

.meas tran vdout0_46ck710 FIND v(dout0_46) AT=360.025n

.meas tran vdout0_47ck710 FIND v(dout0_47) AT=360.025n

.meas tran vdout0_48ck710 FIND v(dout0_48) AT=360.025n

.meas tran vdout0_49ck710 FIND v(dout0_49) AT=360.025n

.meas tran vdout0_50ck710 FIND v(dout0_50) AT=360.025n

.meas tran vdout0_51ck710 FIND v(dout0_51) AT=360.025n

.meas tran vdout0_52ck710 FIND v(dout0_52) AT=360.025n

.meas tran vdout0_53ck710 FIND v(dout0_53) AT=360.025n

.meas tran vdout0_54ck710 FIND v(dout0_54) AT=360.025n

.meas tran vdout0_55ck710 FIND v(dout0_55) AT=360.025n

.meas tran vdout0_56ck710 FIND v(dout0_56) AT=360.025n

.meas tran vdout0_57ck710 FIND v(dout0_57) AT=360.025n

.meas tran vdout0_58ck710 FIND v(dout0_58) AT=360.025n

.meas tran vdout0_59ck710 FIND v(dout0_59) AT=360.025n

.meas tran vdout0_60ck710 FIND v(dout0_60) AT=360.025n

.meas tran vdout0_61ck710 FIND v(dout0_61) AT=360.025n

.meas tran vdout0_62ck710 FIND v(dout0_62) AT=360.025n

.meas tran vdout0_63ck710 FIND v(dout0_63) AT=360.025n

.meas tran vdout0_64ck710 FIND v(dout0_64) AT=360.025n

.meas tran vdout0_65ck710 FIND v(dout0_65) AT=360.025n

.meas tran vdout0_66ck710 FIND v(dout0_66) AT=360.025n

.meas tran vdout0_67ck710 FIND v(dout0_67) AT=360.025n

.meas tran vdout0_68ck710 FIND v(dout0_68) AT=360.025n

.meas tran vdout0_69ck710 FIND v(dout0_69) AT=360.025n

.meas tran vdout0_70ck710 FIND v(dout0_70) AT=360.025n

.meas tran vdout0_71ck710 FIND v(dout0_71) AT=360.025n

.meas tran vdout0_72ck710 FIND v(dout0_72) AT=360.025n

.meas tran vdout0_73ck710 FIND v(dout0_73) AT=360.025n

.meas tran vdout0_74ck710 FIND v(dout0_74) AT=360.025n

.meas tran vdout0_75ck710 FIND v(dout0_75) AT=360.025n

.meas tran vdout0_76ck710 FIND v(dout0_76) AT=360.025n

.meas tran vdout0_77ck710 FIND v(dout0_77) AT=360.025n

.meas tran vdout0_78ck710 FIND v(dout0_78) AT=360.025n

.meas tran vdout0_79ck710 FIND v(dout0_79) AT=360.025n

.meas tran vdout0_80ck710 FIND v(dout0_80) AT=360.025n

.meas tran vdout0_81ck710 FIND v(dout0_81) AT=360.025n

.meas tran vdout0_82ck710 FIND v(dout0_82) AT=360.025n

.meas tran vdout0_83ck710 FIND v(dout0_83) AT=360.025n

.meas tran vdout0_84ck710 FIND v(dout0_84) AT=360.025n

.meas tran vdout0_85ck710 FIND v(dout0_85) AT=360.025n

.meas tran vdout0_86ck710 FIND v(dout0_86) AT=360.025n

.meas tran vdout0_87ck710 FIND v(dout0_87) AT=360.025n

.meas tran vdout0_88ck710 FIND v(dout0_88) AT=360.025n

.meas tran vdout0_89ck710 FIND v(dout0_89) AT=360.025n

.meas tran vdout0_90ck710 FIND v(dout0_90) AT=360.025n

.meas tran vdout0_91ck710 FIND v(dout0_91) AT=360.025n

.meas tran vdout0_92ck710 FIND v(dout0_92) AT=360.025n

.meas tran vdout0_93ck710 FIND v(dout0_93) AT=360.025n

.meas tran vdout0_94ck710 FIND v(dout0_94) AT=360.025n

.meas tran vdout0_95ck710 FIND v(dout0_95) AT=360.025n

.meas tran vdout0_96ck710 FIND v(dout0_96) AT=360.025n

.meas tran vdout0_97ck710 FIND v(dout0_97) AT=360.025n

.meas tran vdout0_98ck710 FIND v(dout0_98) AT=360.025n

.meas tran vdout0_99ck710 FIND v(dout0_99) AT=360.025n

.meas tran vdout0_100ck710 FIND v(dout0_100) AT=360.025n

.meas tran vdout0_101ck710 FIND v(dout0_101) AT=360.025n

.meas tran vdout0_102ck710 FIND v(dout0_102) AT=360.025n

.meas tran vdout0_103ck710 FIND v(dout0_103) AT=360.025n

.meas tran vdout0_104ck710 FIND v(dout0_104) AT=360.025n

.meas tran vdout0_105ck710 FIND v(dout0_105) AT=360.025n

.meas tran vdout0_106ck710 FIND v(dout0_106) AT=360.025n

.meas tran vdout0_107ck710 FIND v(dout0_107) AT=360.025n

.meas tran vdout0_108ck710 FIND v(dout0_108) AT=360.025n

.meas tran vdout0_109ck710 FIND v(dout0_109) AT=360.025n

.meas tran vdout0_110ck710 FIND v(dout0_110) AT=360.025n

.meas tran vdout0_111ck710 FIND v(dout0_111) AT=360.025n

.meas tran vdout0_112ck710 FIND v(dout0_112) AT=360.025n

.meas tran vdout0_113ck710 FIND v(dout0_113) AT=360.025n

.meas tran vdout0_114ck710 FIND v(dout0_114) AT=360.025n

.meas tran vdout0_115ck710 FIND v(dout0_115) AT=360.025n

.meas tran vdout0_116ck710 FIND v(dout0_116) AT=360.025n

.meas tran vdout0_117ck710 FIND v(dout0_117) AT=360.025n

.meas tran vdout0_118ck710 FIND v(dout0_118) AT=360.025n

.meas tran vdout0_119ck710 FIND v(dout0_119) AT=360.025n

.meas tran vdout0_120ck710 FIND v(dout0_120) AT=360.025n

.meas tran vdout0_121ck710 FIND v(dout0_121) AT=360.025n

.meas tran vdout0_122ck710 FIND v(dout0_122) AT=360.025n

.meas tran vdout0_123ck710 FIND v(dout0_123) AT=360.025n

.meas tran vdout0_124ck710 FIND v(dout0_124) AT=360.025n

.meas tran vdout0_125ck710 FIND v(dout0_125) AT=360.025n

.meas tran vdout0_126ck710 FIND v(dout0_126) AT=360.025n

.meas tran vdout0_127ck710 FIND v(dout0_127) AT=360.025n

.meas tran vdout0_128ck710 FIND v(dout0_128) AT=360.025n

.meas tran vdout0_129ck710 FIND v(dout0_129) AT=360.025n

.meas tran vdout0_130ck710 FIND v(dout0_130) AT=360.025n

.meas tran vdout0_131ck710 FIND v(dout0_131) AT=360.025n

.meas tran vdout0_132ck710 FIND v(dout0_132) AT=360.025n

.meas tran vdout0_133ck710 FIND v(dout0_133) AT=360.025n

.meas tran vdout0_134ck710 FIND v(dout0_134) AT=360.025n

.meas tran vdout0_135ck710 FIND v(dout0_135) AT=360.025n

.meas tran vdout0_136ck710 FIND v(dout0_136) AT=360.025n

.meas tran vdout0_137ck710 FIND v(dout0_137) AT=360.025n

.meas tran vdout0_138ck710 FIND v(dout0_138) AT=360.025n

.meas tran vdout0_139ck710 FIND v(dout0_139) AT=360.025n

.meas tran vdout0_140ck710 FIND v(dout0_140) AT=360.025n

.meas tran vdout0_141ck710 FIND v(dout0_141) AT=360.025n

.meas tran vdout0_142ck710 FIND v(dout0_142) AT=360.025n

.meas tran vdout0_143ck710 FIND v(dout0_143) AT=360.025n

.meas tran vdout0_144ck710 FIND v(dout0_144) AT=360.025n

.meas tran vdout0_145ck710 FIND v(dout0_145) AT=360.025n

.meas tran vdout0_146ck710 FIND v(dout0_146) AT=360.025n

.meas tran vdout0_147ck710 FIND v(dout0_147) AT=360.025n

.meas tran vdout0_148ck710 FIND v(dout0_148) AT=360.025n

.meas tran vdout0_149ck710 FIND v(dout0_149) AT=360.025n

.meas tran vdout0_0ck720 FIND v(dout0_0) AT=365.025n

.meas tran vdout0_1ck720 FIND v(dout0_1) AT=365.025n

.meas tran vdout0_2ck720 FIND v(dout0_2) AT=365.025n

.meas tran vdout0_3ck720 FIND v(dout0_3) AT=365.025n

.meas tran vdout0_4ck720 FIND v(dout0_4) AT=365.025n

.meas tran vdout0_5ck720 FIND v(dout0_5) AT=365.025n

.meas tran vdout0_6ck720 FIND v(dout0_6) AT=365.025n

.meas tran vdout0_7ck720 FIND v(dout0_7) AT=365.025n

.meas tran vdout0_8ck720 FIND v(dout0_8) AT=365.025n

.meas tran vdout0_9ck720 FIND v(dout0_9) AT=365.025n

.meas tran vdout0_10ck720 FIND v(dout0_10) AT=365.025n

.meas tran vdout0_11ck720 FIND v(dout0_11) AT=365.025n

.meas tran vdout0_12ck720 FIND v(dout0_12) AT=365.025n

.meas tran vdout0_13ck720 FIND v(dout0_13) AT=365.025n

.meas tran vdout0_14ck720 FIND v(dout0_14) AT=365.025n

.meas tran vdout0_15ck720 FIND v(dout0_15) AT=365.025n

.meas tran vdout0_16ck720 FIND v(dout0_16) AT=365.025n

.meas tran vdout0_17ck720 FIND v(dout0_17) AT=365.025n

.meas tran vdout0_18ck720 FIND v(dout0_18) AT=365.025n

.meas tran vdout0_19ck720 FIND v(dout0_19) AT=365.025n

.meas tran vdout0_20ck720 FIND v(dout0_20) AT=365.025n

.meas tran vdout0_21ck720 FIND v(dout0_21) AT=365.025n

.meas tran vdout0_22ck720 FIND v(dout0_22) AT=365.025n

.meas tran vdout0_23ck720 FIND v(dout0_23) AT=365.025n

.meas tran vdout0_24ck720 FIND v(dout0_24) AT=365.025n

.meas tran vdout0_25ck720 FIND v(dout0_25) AT=365.025n

.meas tran vdout0_26ck720 FIND v(dout0_26) AT=365.025n

.meas tran vdout0_27ck720 FIND v(dout0_27) AT=365.025n

.meas tran vdout0_28ck720 FIND v(dout0_28) AT=365.025n

.meas tran vdout0_29ck720 FIND v(dout0_29) AT=365.025n

.meas tran vdout0_30ck720 FIND v(dout0_30) AT=365.025n

.meas tran vdout0_31ck720 FIND v(dout0_31) AT=365.025n

.meas tran vdout0_32ck720 FIND v(dout0_32) AT=365.025n

.meas tran vdout0_33ck720 FIND v(dout0_33) AT=365.025n

.meas tran vdout0_34ck720 FIND v(dout0_34) AT=365.025n

.meas tran vdout0_35ck720 FIND v(dout0_35) AT=365.025n

.meas tran vdout0_36ck720 FIND v(dout0_36) AT=365.025n

.meas tran vdout0_37ck720 FIND v(dout0_37) AT=365.025n

.meas tran vdout0_38ck720 FIND v(dout0_38) AT=365.025n

.meas tran vdout0_39ck720 FIND v(dout0_39) AT=365.025n

.meas tran vdout0_40ck720 FIND v(dout0_40) AT=365.025n

.meas tran vdout0_41ck720 FIND v(dout0_41) AT=365.025n

.meas tran vdout0_42ck720 FIND v(dout0_42) AT=365.025n

.meas tran vdout0_43ck720 FIND v(dout0_43) AT=365.025n

.meas tran vdout0_44ck720 FIND v(dout0_44) AT=365.025n

.meas tran vdout0_45ck720 FIND v(dout0_45) AT=365.025n

.meas tran vdout0_46ck720 FIND v(dout0_46) AT=365.025n

.meas tran vdout0_47ck720 FIND v(dout0_47) AT=365.025n

.meas tran vdout0_48ck720 FIND v(dout0_48) AT=365.025n

.meas tran vdout0_49ck720 FIND v(dout0_49) AT=365.025n

.meas tran vdout0_50ck720 FIND v(dout0_50) AT=365.025n

.meas tran vdout0_51ck720 FIND v(dout0_51) AT=365.025n

.meas tran vdout0_52ck720 FIND v(dout0_52) AT=365.025n

.meas tran vdout0_53ck720 FIND v(dout0_53) AT=365.025n

.meas tran vdout0_54ck720 FIND v(dout0_54) AT=365.025n

.meas tran vdout0_55ck720 FIND v(dout0_55) AT=365.025n

.meas tran vdout0_56ck720 FIND v(dout0_56) AT=365.025n

.meas tran vdout0_57ck720 FIND v(dout0_57) AT=365.025n

.meas tran vdout0_58ck720 FIND v(dout0_58) AT=365.025n

.meas tran vdout0_59ck720 FIND v(dout0_59) AT=365.025n

.meas tran vdout0_60ck720 FIND v(dout0_60) AT=365.025n

.meas tran vdout0_61ck720 FIND v(dout0_61) AT=365.025n

.meas tran vdout0_62ck720 FIND v(dout0_62) AT=365.025n

.meas tran vdout0_63ck720 FIND v(dout0_63) AT=365.025n

.meas tran vdout0_64ck720 FIND v(dout0_64) AT=365.025n

.meas tran vdout0_65ck720 FIND v(dout0_65) AT=365.025n

.meas tran vdout0_66ck720 FIND v(dout0_66) AT=365.025n

.meas tran vdout0_67ck720 FIND v(dout0_67) AT=365.025n

.meas tran vdout0_68ck720 FIND v(dout0_68) AT=365.025n

.meas tran vdout0_69ck720 FIND v(dout0_69) AT=365.025n

.meas tran vdout0_70ck720 FIND v(dout0_70) AT=365.025n

.meas tran vdout0_71ck720 FIND v(dout0_71) AT=365.025n

.meas tran vdout0_72ck720 FIND v(dout0_72) AT=365.025n

.meas tran vdout0_73ck720 FIND v(dout0_73) AT=365.025n

.meas tran vdout0_74ck720 FIND v(dout0_74) AT=365.025n

.meas tran vdout0_75ck720 FIND v(dout0_75) AT=365.025n

.meas tran vdout0_76ck720 FIND v(dout0_76) AT=365.025n

.meas tran vdout0_77ck720 FIND v(dout0_77) AT=365.025n

.meas tran vdout0_78ck720 FIND v(dout0_78) AT=365.025n

.meas tran vdout0_79ck720 FIND v(dout0_79) AT=365.025n

.meas tran vdout0_80ck720 FIND v(dout0_80) AT=365.025n

.meas tran vdout0_81ck720 FIND v(dout0_81) AT=365.025n

.meas tran vdout0_82ck720 FIND v(dout0_82) AT=365.025n

.meas tran vdout0_83ck720 FIND v(dout0_83) AT=365.025n

.meas tran vdout0_84ck720 FIND v(dout0_84) AT=365.025n

.meas tran vdout0_85ck720 FIND v(dout0_85) AT=365.025n

.meas tran vdout0_86ck720 FIND v(dout0_86) AT=365.025n

.meas tran vdout0_87ck720 FIND v(dout0_87) AT=365.025n

.meas tran vdout0_88ck720 FIND v(dout0_88) AT=365.025n

.meas tran vdout0_89ck720 FIND v(dout0_89) AT=365.025n

.meas tran vdout0_90ck720 FIND v(dout0_90) AT=365.025n

.meas tran vdout0_91ck720 FIND v(dout0_91) AT=365.025n

.meas tran vdout0_92ck720 FIND v(dout0_92) AT=365.025n

.meas tran vdout0_93ck720 FIND v(dout0_93) AT=365.025n

.meas tran vdout0_94ck720 FIND v(dout0_94) AT=365.025n

.meas tran vdout0_95ck720 FIND v(dout0_95) AT=365.025n

.meas tran vdout0_96ck720 FIND v(dout0_96) AT=365.025n

.meas tran vdout0_97ck720 FIND v(dout0_97) AT=365.025n

.meas tran vdout0_98ck720 FIND v(dout0_98) AT=365.025n

.meas tran vdout0_99ck720 FIND v(dout0_99) AT=365.025n

.meas tran vdout0_100ck720 FIND v(dout0_100) AT=365.025n

.meas tran vdout0_101ck720 FIND v(dout0_101) AT=365.025n

.meas tran vdout0_102ck720 FIND v(dout0_102) AT=365.025n

.meas tran vdout0_103ck720 FIND v(dout0_103) AT=365.025n

.meas tran vdout0_104ck720 FIND v(dout0_104) AT=365.025n

.meas tran vdout0_105ck720 FIND v(dout0_105) AT=365.025n

.meas tran vdout0_106ck720 FIND v(dout0_106) AT=365.025n

.meas tran vdout0_107ck720 FIND v(dout0_107) AT=365.025n

.meas tran vdout0_108ck720 FIND v(dout0_108) AT=365.025n

.meas tran vdout0_109ck720 FIND v(dout0_109) AT=365.025n

.meas tran vdout0_110ck720 FIND v(dout0_110) AT=365.025n

.meas tran vdout0_111ck720 FIND v(dout0_111) AT=365.025n

.meas tran vdout0_112ck720 FIND v(dout0_112) AT=365.025n

.meas tran vdout0_113ck720 FIND v(dout0_113) AT=365.025n

.meas tran vdout0_114ck720 FIND v(dout0_114) AT=365.025n

.meas tran vdout0_115ck720 FIND v(dout0_115) AT=365.025n

.meas tran vdout0_116ck720 FIND v(dout0_116) AT=365.025n

.meas tran vdout0_117ck720 FIND v(dout0_117) AT=365.025n

.meas tran vdout0_118ck720 FIND v(dout0_118) AT=365.025n

.meas tran vdout0_119ck720 FIND v(dout0_119) AT=365.025n

.meas tran vdout0_120ck720 FIND v(dout0_120) AT=365.025n

.meas tran vdout0_121ck720 FIND v(dout0_121) AT=365.025n

.meas tran vdout0_122ck720 FIND v(dout0_122) AT=365.025n

.meas tran vdout0_123ck720 FIND v(dout0_123) AT=365.025n

.meas tran vdout0_124ck720 FIND v(dout0_124) AT=365.025n

.meas tran vdout0_125ck720 FIND v(dout0_125) AT=365.025n

.meas tran vdout0_126ck720 FIND v(dout0_126) AT=365.025n

.meas tran vdout0_127ck720 FIND v(dout0_127) AT=365.025n

.meas tran vdout0_128ck720 FIND v(dout0_128) AT=365.025n

.meas tran vdout0_129ck720 FIND v(dout0_129) AT=365.025n

.meas tran vdout0_130ck720 FIND v(dout0_130) AT=365.025n

.meas tran vdout0_131ck720 FIND v(dout0_131) AT=365.025n

.meas tran vdout0_132ck720 FIND v(dout0_132) AT=365.025n

.meas tran vdout0_133ck720 FIND v(dout0_133) AT=365.025n

.meas tran vdout0_134ck720 FIND v(dout0_134) AT=365.025n

.meas tran vdout0_135ck720 FIND v(dout0_135) AT=365.025n

.meas tran vdout0_136ck720 FIND v(dout0_136) AT=365.025n

.meas tran vdout0_137ck720 FIND v(dout0_137) AT=365.025n

.meas tran vdout0_138ck720 FIND v(dout0_138) AT=365.025n

.meas tran vdout0_139ck720 FIND v(dout0_139) AT=365.025n

.meas tran vdout0_140ck720 FIND v(dout0_140) AT=365.025n

.meas tran vdout0_141ck720 FIND v(dout0_141) AT=365.025n

.meas tran vdout0_142ck720 FIND v(dout0_142) AT=365.025n

.meas tran vdout0_143ck720 FIND v(dout0_143) AT=365.025n

.meas tran vdout0_144ck720 FIND v(dout0_144) AT=365.025n

.meas tran vdout0_145ck720 FIND v(dout0_145) AT=365.025n

.meas tran vdout0_146ck720 FIND v(dout0_146) AT=365.025n

.meas tran vdout0_147ck720 FIND v(dout0_147) AT=365.025n

.meas tran vdout0_148ck720 FIND v(dout0_148) AT=365.025n

.meas tran vdout0_149ck720 FIND v(dout0_149) AT=365.025n

.meas tran vdout0_0ck730 FIND v(dout0_0) AT=370.025n

.meas tran vdout0_1ck730 FIND v(dout0_1) AT=370.025n

.meas tran vdout0_2ck730 FIND v(dout0_2) AT=370.025n

.meas tran vdout0_3ck730 FIND v(dout0_3) AT=370.025n

.meas tran vdout0_4ck730 FIND v(dout0_4) AT=370.025n

.meas tran vdout0_5ck730 FIND v(dout0_5) AT=370.025n

.meas tran vdout0_6ck730 FIND v(dout0_6) AT=370.025n

.meas tran vdout0_7ck730 FIND v(dout0_7) AT=370.025n

.meas tran vdout0_8ck730 FIND v(dout0_8) AT=370.025n

.meas tran vdout0_9ck730 FIND v(dout0_9) AT=370.025n

.meas tran vdout0_10ck730 FIND v(dout0_10) AT=370.025n

.meas tran vdout0_11ck730 FIND v(dout0_11) AT=370.025n

.meas tran vdout0_12ck730 FIND v(dout0_12) AT=370.025n

.meas tran vdout0_13ck730 FIND v(dout0_13) AT=370.025n

.meas tran vdout0_14ck730 FIND v(dout0_14) AT=370.025n

.meas tran vdout0_15ck730 FIND v(dout0_15) AT=370.025n

.meas tran vdout0_16ck730 FIND v(dout0_16) AT=370.025n

.meas tran vdout0_17ck730 FIND v(dout0_17) AT=370.025n

.meas tran vdout0_18ck730 FIND v(dout0_18) AT=370.025n

.meas tran vdout0_19ck730 FIND v(dout0_19) AT=370.025n

.meas tran vdout0_20ck730 FIND v(dout0_20) AT=370.025n

.meas tran vdout0_21ck730 FIND v(dout0_21) AT=370.025n

.meas tran vdout0_22ck730 FIND v(dout0_22) AT=370.025n

.meas tran vdout0_23ck730 FIND v(dout0_23) AT=370.025n

.meas tran vdout0_24ck730 FIND v(dout0_24) AT=370.025n

.meas tran vdout0_25ck730 FIND v(dout0_25) AT=370.025n

.meas tran vdout0_26ck730 FIND v(dout0_26) AT=370.025n

.meas tran vdout0_27ck730 FIND v(dout0_27) AT=370.025n

.meas tran vdout0_28ck730 FIND v(dout0_28) AT=370.025n

.meas tran vdout0_29ck730 FIND v(dout0_29) AT=370.025n

.meas tran vdout0_30ck730 FIND v(dout0_30) AT=370.025n

.meas tran vdout0_31ck730 FIND v(dout0_31) AT=370.025n

.meas tran vdout0_32ck730 FIND v(dout0_32) AT=370.025n

.meas tran vdout0_33ck730 FIND v(dout0_33) AT=370.025n

.meas tran vdout0_34ck730 FIND v(dout0_34) AT=370.025n

.meas tran vdout0_35ck730 FIND v(dout0_35) AT=370.025n

.meas tran vdout0_36ck730 FIND v(dout0_36) AT=370.025n

.meas tran vdout0_37ck730 FIND v(dout0_37) AT=370.025n

.meas tran vdout0_38ck730 FIND v(dout0_38) AT=370.025n

.meas tran vdout0_39ck730 FIND v(dout0_39) AT=370.025n

.meas tran vdout0_40ck730 FIND v(dout0_40) AT=370.025n

.meas tran vdout0_41ck730 FIND v(dout0_41) AT=370.025n

.meas tran vdout0_42ck730 FIND v(dout0_42) AT=370.025n

.meas tran vdout0_43ck730 FIND v(dout0_43) AT=370.025n

.meas tran vdout0_44ck730 FIND v(dout0_44) AT=370.025n

.meas tran vdout0_45ck730 FIND v(dout0_45) AT=370.025n

.meas tran vdout0_46ck730 FIND v(dout0_46) AT=370.025n

.meas tran vdout0_47ck730 FIND v(dout0_47) AT=370.025n

.meas tran vdout0_48ck730 FIND v(dout0_48) AT=370.025n

.meas tran vdout0_49ck730 FIND v(dout0_49) AT=370.025n

.meas tran vdout0_50ck730 FIND v(dout0_50) AT=370.025n

.meas tran vdout0_51ck730 FIND v(dout0_51) AT=370.025n

.meas tran vdout0_52ck730 FIND v(dout0_52) AT=370.025n

.meas tran vdout0_53ck730 FIND v(dout0_53) AT=370.025n

.meas tran vdout0_54ck730 FIND v(dout0_54) AT=370.025n

.meas tran vdout0_55ck730 FIND v(dout0_55) AT=370.025n

.meas tran vdout0_56ck730 FIND v(dout0_56) AT=370.025n

.meas tran vdout0_57ck730 FIND v(dout0_57) AT=370.025n

.meas tran vdout0_58ck730 FIND v(dout0_58) AT=370.025n

.meas tran vdout0_59ck730 FIND v(dout0_59) AT=370.025n

.meas tran vdout0_60ck730 FIND v(dout0_60) AT=370.025n

.meas tran vdout0_61ck730 FIND v(dout0_61) AT=370.025n

.meas tran vdout0_62ck730 FIND v(dout0_62) AT=370.025n

.meas tran vdout0_63ck730 FIND v(dout0_63) AT=370.025n

.meas tran vdout0_64ck730 FIND v(dout0_64) AT=370.025n

.meas tran vdout0_65ck730 FIND v(dout0_65) AT=370.025n

.meas tran vdout0_66ck730 FIND v(dout0_66) AT=370.025n

.meas tran vdout0_67ck730 FIND v(dout0_67) AT=370.025n

.meas tran vdout0_68ck730 FIND v(dout0_68) AT=370.025n

.meas tran vdout0_69ck730 FIND v(dout0_69) AT=370.025n

.meas tran vdout0_70ck730 FIND v(dout0_70) AT=370.025n

.meas tran vdout0_71ck730 FIND v(dout0_71) AT=370.025n

.meas tran vdout0_72ck730 FIND v(dout0_72) AT=370.025n

.meas tran vdout0_73ck730 FIND v(dout0_73) AT=370.025n

.meas tran vdout0_74ck730 FIND v(dout0_74) AT=370.025n

.meas tran vdout0_75ck730 FIND v(dout0_75) AT=370.025n

.meas tran vdout0_76ck730 FIND v(dout0_76) AT=370.025n

.meas tran vdout0_77ck730 FIND v(dout0_77) AT=370.025n

.meas tran vdout0_78ck730 FIND v(dout0_78) AT=370.025n

.meas tran vdout0_79ck730 FIND v(dout0_79) AT=370.025n

.meas tran vdout0_80ck730 FIND v(dout0_80) AT=370.025n

.meas tran vdout0_81ck730 FIND v(dout0_81) AT=370.025n

.meas tran vdout0_82ck730 FIND v(dout0_82) AT=370.025n

.meas tran vdout0_83ck730 FIND v(dout0_83) AT=370.025n

.meas tran vdout0_84ck730 FIND v(dout0_84) AT=370.025n

.meas tran vdout0_85ck730 FIND v(dout0_85) AT=370.025n

.meas tran vdout0_86ck730 FIND v(dout0_86) AT=370.025n

.meas tran vdout0_87ck730 FIND v(dout0_87) AT=370.025n

.meas tran vdout0_88ck730 FIND v(dout0_88) AT=370.025n

.meas tran vdout0_89ck730 FIND v(dout0_89) AT=370.025n

.meas tran vdout0_90ck730 FIND v(dout0_90) AT=370.025n

.meas tran vdout0_91ck730 FIND v(dout0_91) AT=370.025n

.meas tran vdout0_92ck730 FIND v(dout0_92) AT=370.025n

.meas tran vdout0_93ck730 FIND v(dout0_93) AT=370.025n

.meas tran vdout0_94ck730 FIND v(dout0_94) AT=370.025n

.meas tran vdout0_95ck730 FIND v(dout0_95) AT=370.025n

.meas tran vdout0_96ck730 FIND v(dout0_96) AT=370.025n

.meas tran vdout0_97ck730 FIND v(dout0_97) AT=370.025n

.meas tran vdout0_98ck730 FIND v(dout0_98) AT=370.025n

.meas tran vdout0_99ck730 FIND v(dout0_99) AT=370.025n

.meas tran vdout0_100ck730 FIND v(dout0_100) AT=370.025n

.meas tran vdout0_101ck730 FIND v(dout0_101) AT=370.025n

.meas tran vdout0_102ck730 FIND v(dout0_102) AT=370.025n

.meas tran vdout0_103ck730 FIND v(dout0_103) AT=370.025n

.meas tran vdout0_104ck730 FIND v(dout0_104) AT=370.025n

.meas tran vdout0_105ck730 FIND v(dout0_105) AT=370.025n

.meas tran vdout0_106ck730 FIND v(dout0_106) AT=370.025n

.meas tran vdout0_107ck730 FIND v(dout0_107) AT=370.025n

.meas tran vdout0_108ck730 FIND v(dout0_108) AT=370.025n

.meas tran vdout0_109ck730 FIND v(dout0_109) AT=370.025n

.meas tran vdout0_110ck730 FIND v(dout0_110) AT=370.025n

.meas tran vdout0_111ck730 FIND v(dout0_111) AT=370.025n

.meas tran vdout0_112ck730 FIND v(dout0_112) AT=370.025n

.meas tran vdout0_113ck730 FIND v(dout0_113) AT=370.025n

.meas tran vdout0_114ck730 FIND v(dout0_114) AT=370.025n

.meas tran vdout0_115ck730 FIND v(dout0_115) AT=370.025n

.meas tran vdout0_116ck730 FIND v(dout0_116) AT=370.025n

.meas tran vdout0_117ck730 FIND v(dout0_117) AT=370.025n

.meas tran vdout0_118ck730 FIND v(dout0_118) AT=370.025n

.meas tran vdout0_119ck730 FIND v(dout0_119) AT=370.025n

.meas tran vdout0_120ck730 FIND v(dout0_120) AT=370.025n

.meas tran vdout0_121ck730 FIND v(dout0_121) AT=370.025n

.meas tran vdout0_122ck730 FIND v(dout0_122) AT=370.025n

.meas tran vdout0_123ck730 FIND v(dout0_123) AT=370.025n

.meas tran vdout0_124ck730 FIND v(dout0_124) AT=370.025n

.meas tran vdout0_125ck730 FIND v(dout0_125) AT=370.025n

.meas tran vdout0_126ck730 FIND v(dout0_126) AT=370.025n

.meas tran vdout0_127ck730 FIND v(dout0_127) AT=370.025n

.meas tran vdout0_128ck730 FIND v(dout0_128) AT=370.025n

.meas tran vdout0_129ck730 FIND v(dout0_129) AT=370.025n

.meas tran vdout0_130ck730 FIND v(dout0_130) AT=370.025n

.meas tran vdout0_131ck730 FIND v(dout0_131) AT=370.025n

.meas tran vdout0_132ck730 FIND v(dout0_132) AT=370.025n

.meas tran vdout0_133ck730 FIND v(dout0_133) AT=370.025n

.meas tran vdout0_134ck730 FIND v(dout0_134) AT=370.025n

.meas tran vdout0_135ck730 FIND v(dout0_135) AT=370.025n

.meas tran vdout0_136ck730 FIND v(dout0_136) AT=370.025n

.meas tran vdout0_137ck730 FIND v(dout0_137) AT=370.025n

.meas tran vdout0_138ck730 FIND v(dout0_138) AT=370.025n

.meas tran vdout0_139ck730 FIND v(dout0_139) AT=370.025n

.meas tran vdout0_140ck730 FIND v(dout0_140) AT=370.025n

.meas tran vdout0_141ck730 FIND v(dout0_141) AT=370.025n

.meas tran vdout0_142ck730 FIND v(dout0_142) AT=370.025n

.meas tran vdout0_143ck730 FIND v(dout0_143) AT=370.025n

.meas tran vdout0_144ck730 FIND v(dout0_144) AT=370.025n

.meas tran vdout0_145ck730 FIND v(dout0_145) AT=370.025n

.meas tran vdout0_146ck730 FIND v(dout0_146) AT=370.025n

.meas tran vdout0_147ck730 FIND v(dout0_147) AT=370.025n

.meas tran vdout0_148ck730 FIND v(dout0_148) AT=370.025n

.meas tran vdout0_149ck730 FIND v(dout0_149) AT=370.025n

.meas tran vdout0_0ck740 FIND v(dout0_0) AT=375.025n

.meas tran vdout0_1ck740 FIND v(dout0_1) AT=375.025n

.meas tran vdout0_2ck740 FIND v(dout0_2) AT=375.025n

.meas tran vdout0_3ck740 FIND v(dout0_3) AT=375.025n

.meas tran vdout0_4ck740 FIND v(dout0_4) AT=375.025n

.meas tran vdout0_5ck740 FIND v(dout0_5) AT=375.025n

.meas tran vdout0_6ck740 FIND v(dout0_6) AT=375.025n

.meas tran vdout0_7ck740 FIND v(dout0_7) AT=375.025n

.meas tran vdout0_8ck740 FIND v(dout0_8) AT=375.025n

.meas tran vdout0_9ck740 FIND v(dout0_9) AT=375.025n

.meas tran vdout0_10ck740 FIND v(dout0_10) AT=375.025n

.meas tran vdout0_11ck740 FIND v(dout0_11) AT=375.025n

.meas tran vdout0_12ck740 FIND v(dout0_12) AT=375.025n

.meas tran vdout0_13ck740 FIND v(dout0_13) AT=375.025n

.meas tran vdout0_14ck740 FIND v(dout0_14) AT=375.025n

.meas tran vdout0_15ck740 FIND v(dout0_15) AT=375.025n

.meas tran vdout0_16ck740 FIND v(dout0_16) AT=375.025n

.meas tran vdout0_17ck740 FIND v(dout0_17) AT=375.025n

.meas tran vdout0_18ck740 FIND v(dout0_18) AT=375.025n

.meas tran vdout0_19ck740 FIND v(dout0_19) AT=375.025n

.meas tran vdout0_20ck740 FIND v(dout0_20) AT=375.025n

.meas tran vdout0_21ck740 FIND v(dout0_21) AT=375.025n

.meas tran vdout0_22ck740 FIND v(dout0_22) AT=375.025n

.meas tran vdout0_23ck740 FIND v(dout0_23) AT=375.025n

.meas tran vdout0_24ck740 FIND v(dout0_24) AT=375.025n

.meas tran vdout0_25ck740 FIND v(dout0_25) AT=375.025n

.meas tran vdout0_26ck740 FIND v(dout0_26) AT=375.025n

.meas tran vdout0_27ck740 FIND v(dout0_27) AT=375.025n

.meas tran vdout0_28ck740 FIND v(dout0_28) AT=375.025n

.meas tran vdout0_29ck740 FIND v(dout0_29) AT=375.025n

.meas tran vdout0_30ck740 FIND v(dout0_30) AT=375.025n

.meas tran vdout0_31ck740 FIND v(dout0_31) AT=375.025n

.meas tran vdout0_32ck740 FIND v(dout0_32) AT=375.025n

.meas tran vdout0_33ck740 FIND v(dout0_33) AT=375.025n

.meas tran vdout0_34ck740 FIND v(dout0_34) AT=375.025n

.meas tran vdout0_35ck740 FIND v(dout0_35) AT=375.025n

.meas tran vdout0_36ck740 FIND v(dout0_36) AT=375.025n

.meas tran vdout0_37ck740 FIND v(dout0_37) AT=375.025n

.meas tran vdout0_38ck740 FIND v(dout0_38) AT=375.025n

.meas tran vdout0_39ck740 FIND v(dout0_39) AT=375.025n

.meas tran vdout0_40ck740 FIND v(dout0_40) AT=375.025n

.meas tran vdout0_41ck740 FIND v(dout0_41) AT=375.025n

.meas tran vdout0_42ck740 FIND v(dout0_42) AT=375.025n

.meas tran vdout0_43ck740 FIND v(dout0_43) AT=375.025n

.meas tran vdout0_44ck740 FIND v(dout0_44) AT=375.025n

.meas tran vdout0_45ck740 FIND v(dout0_45) AT=375.025n

.meas tran vdout0_46ck740 FIND v(dout0_46) AT=375.025n

.meas tran vdout0_47ck740 FIND v(dout0_47) AT=375.025n

.meas tran vdout0_48ck740 FIND v(dout0_48) AT=375.025n

.meas tran vdout0_49ck740 FIND v(dout0_49) AT=375.025n

.meas tran vdout0_50ck740 FIND v(dout0_50) AT=375.025n

.meas tran vdout0_51ck740 FIND v(dout0_51) AT=375.025n

.meas tran vdout0_52ck740 FIND v(dout0_52) AT=375.025n

.meas tran vdout0_53ck740 FIND v(dout0_53) AT=375.025n

.meas tran vdout0_54ck740 FIND v(dout0_54) AT=375.025n

.meas tran vdout0_55ck740 FIND v(dout0_55) AT=375.025n

.meas tran vdout0_56ck740 FIND v(dout0_56) AT=375.025n

.meas tran vdout0_57ck740 FIND v(dout0_57) AT=375.025n

.meas tran vdout0_58ck740 FIND v(dout0_58) AT=375.025n

.meas tran vdout0_59ck740 FIND v(dout0_59) AT=375.025n

.meas tran vdout0_60ck740 FIND v(dout0_60) AT=375.025n

.meas tran vdout0_61ck740 FIND v(dout0_61) AT=375.025n

.meas tran vdout0_62ck740 FIND v(dout0_62) AT=375.025n

.meas tran vdout0_63ck740 FIND v(dout0_63) AT=375.025n

.meas tran vdout0_64ck740 FIND v(dout0_64) AT=375.025n

.meas tran vdout0_65ck740 FIND v(dout0_65) AT=375.025n

.meas tran vdout0_66ck740 FIND v(dout0_66) AT=375.025n

.meas tran vdout0_67ck740 FIND v(dout0_67) AT=375.025n

.meas tran vdout0_68ck740 FIND v(dout0_68) AT=375.025n

.meas tran vdout0_69ck740 FIND v(dout0_69) AT=375.025n

.meas tran vdout0_70ck740 FIND v(dout0_70) AT=375.025n

.meas tran vdout0_71ck740 FIND v(dout0_71) AT=375.025n

.meas tran vdout0_72ck740 FIND v(dout0_72) AT=375.025n

.meas tran vdout0_73ck740 FIND v(dout0_73) AT=375.025n

.meas tran vdout0_74ck740 FIND v(dout0_74) AT=375.025n

.meas tran vdout0_75ck740 FIND v(dout0_75) AT=375.025n

.meas tran vdout0_76ck740 FIND v(dout0_76) AT=375.025n

.meas tran vdout0_77ck740 FIND v(dout0_77) AT=375.025n

.meas tran vdout0_78ck740 FIND v(dout0_78) AT=375.025n

.meas tran vdout0_79ck740 FIND v(dout0_79) AT=375.025n

.meas tran vdout0_80ck740 FIND v(dout0_80) AT=375.025n

.meas tran vdout0_81ck740 FIND v(dout0_81) AT=375.025n

.meas tran vdout0_82ck740 FIND v(dout0_82) AT=375.025n

.meas tran vdout0_83ck740 FIND v(dout0_83) AT=375.025n

.meas tran vdout0_84ck740 FIND v(dout0_84) AT=375.025n

.meas tran vdout0_85ck740 FIND v(dout0_85) AT=375.025n

.meas tran vdout0_86ck740 FIND v(dout0_86) AT=375.025n

.meas tran vdout0_87ck740 FIND v(dout0_87) AT=375.025n

.meas tran vdout0_88ck740 FIND v(dout0_88) AT=375.025n

.meas tran vdout0_89ck740 FIND v(dout0_89) AT=375.025n

.meas tran vdout0_90ck740 FIND v(dout0_90) AT=375.025n

.meas tran vdout0_91ck740 FIND v(dout0_91) AT=375.025n

.meas tran vdout0_92ck740 FIND v(dout0_92) AT=375.025n

.meas tran vdout0_93ck740 FIND v(dout0_93) AT=375.025n

.meas tran vdout0_94ck740 FIND v(dout0_94) AT=375.025n

.meas tran vdout0_95ck740 FIND v(dout0_95) AT=375.025n

.meas tran vdout0_96ck740 FIND v(dout0_96) AT=375.025n

.meas tran vdout0_97ck740 FIND v(dout0_97) AT=375.025n

.meas tran vdout0_98ck740 FIND v(dout0_98) AT=375.025n

.meas tran vdout0_99ck740 FIND v(dout0_99) AT=375.025n

.meas tran vdout0_100ck740 FIND v(dout0_100) AT=375.025n

.meas tran vdout0_101ck740 FIND v(dout0_101) AT=375.025n

.meas tran vdout0_102ck740 FIND v(dout0_102) AT=375.025n

.meas tran vdout0_103ck740 FIND v(dout0_103) AT=375.025n

.meas tran vdout0_104ck740 FIND v(dout0_104) AT=375.025n

.meas tran vdout0_105ck740 FIND v(dout0_105) AT=375.025n

.meas tran vdout0_106ck740 FIND v(dout0_106) AT=375.025n

.meas tran vdout0_107ck740 FIND v(dout0_107) AT=375.025n

.meas tran vdout0_108ck740 FIND v(dout0_108) AT=375.025n

.meas tran vdout0_109ck740 FIND v(dout0_109) AT=375.025n

.meas tran vdout0_110ck740 FIND v(dout0_110) AT=375.025n

.meas tran vdout0_111ck740 FIND v(dout0_111) AT=375.025n

.meas tran vdout0_112ck740 FIND v(dout0_112) AT=375.025n

.meas tran vdout0_113ck740 FIND v(dout0_113) AT=375.025n

.meas tran vdout0_114ck740 FIND v(dout0_114) AT=375.025n

.meas tran vdout0_115ck740 FIND v(dout0_115) AT=375.025n

.meas tran vdout0_116ck740 FIND v(dout0_116) AT=375.025n

.meas tran vdout0_117ck740 FIND v(dout0_117) AT=375.025n

.meas tran vdout0_118ck740 FIND v(dout0_118) AT=375.025n

.meas tran vdout0_119ck740 FIND v(dout0_119) AT=375.025n

.meas tran vdout0_120ck740 FIND v(dout0_120) AT=375.025n

.meas tran vdout0_121ck740 FIND v(dout0_121) AT=375.025n

.meas tran vdout0_122ck740 FIND v(dout0_122) AT=375.025n

.meas tran vdout0_123ck740 FIND v(dout0_123) AT=375.025n

.meas tran vdout0_124ck740 FIND v(dout0_124) AT=375.025n

.meas tran vdout0_125ck740 FIND v(dout0_125) AT=375.025n

.meas tran vdout0_126ck740 FIND v(dout0_126) AT=375.025n

.meas tran vdout0_127ck740 FIND v(dout0_127) AT=375.025n

.meas tran vdout0_128ck740 FIND v(dout0_128) AT=375.025n

.meas tran vdout0_129ck740 FIND v(dout0_129) AT=375.025n

.meas tran vdout0_130ck740 FIND v(dout0_130) AT=375.025n

.meas tran vdout0_131ck740 FIND v(dout0_131) AT=375.025n

.meas tran vdout0_132ck740 FIND v(dout0_132) AT=375.025n

.meas tran vdout0_133ck740 FIND v(dout0_133) AT=375.025n

.meas tran vdout0_134ck740 FIND v(dout0_134) AT=375.025n

.meas tran vdout0_135ck740 FIND v(dout0_135) AT=375.025n

.meas tran vdout0_136ck740 FIND v(dout0_136) AT=375.025n

.meas tran vdout0_137ck740 FIND v(dout0_137) AT=375.025n

.meas tran vdout0_138ck740 FIND v(dout0_138) AT=375.025n

.meas tran vdout0_139ck740 FIND v(dout0_139) AT=375.025n

.meas tran vdout0_140ck740 FIND v(dout0_140) AT=375.025n

.meas tran vdout0_141ck740 FIND v(dout0_141) AT=375.025n

.meas tran vdout0_142ck740 FIND v(dout0_142) AT=375.025n

.meas tran vdout0_143ck740 FIND v(dout0_143) AT=375.025n

.meas tran vdout0_144ck740 FIND v(dout0_144) AT=375.025n

.meas tran vdout0_145ck740 FIND v(dout0_145) AT=375.025n

.meas tran vdout0_146ck740 FIND v(dout0_146) AT=375.025n

.meas tran vdout0_147ck740 FIND v(dout0_147) AT=375.025n

.meas tran vdout0_148ck740 FIND v(dout0_148) AT=375.025n

.meas tran vdout0_149ck740 FIND v(dout0_149) AT=375.025n

.meas tran vdout0_0ck790 FIND v(dout0_0) AT=400.025n

.meas tran vdout0_1ck790 FIND v(dout0_1) AT=400.025n

.meas tran vdout0_2ck790 FIND v(dout0_2) AT=400.025n

.meas tran vdout0_3ck790 FIND v(dout0_3) AT=400.025n

.meas tran vdout0_4ck790 FIND v(dout0_4) AT=400.025n

.meas tran vdout0_5ck790 FIND v(dout0_5) AT=400.025n

.meas tran vdout0_6ck790 FIND v(dout0_6) AT=400.025n

.meas tran vdout0_7ck790 FIND v(dout0_7) AT=400.025n

.meas tran vdout0_8ck790 FIND v(dout0_8) AT=400.025n

.meas tran vdout0_9ck790 FIND v(dout0_9) AT=400.025n

.meas tran vdout0_10ck790 FIND v(dout0_10) AT=400.025n

.meas tran vdout0_11ck790 FIND v(dout0_11) AT=400.025n

.meas tran vdout0_12ck790 FIND v(dout0_12) AT=400.025n

.meas tran vdout0_13ck790 FIND v(dout0_13) AT=400.025n

.meas tran vdout0_14ck790 FIND v(dout0_14) AT=400.025n

.meas tran vdout0_15ck790 FIND v(dout0_15) AT=400.025n

.meas tran vdout0_16ck790 FIND v(dout0_16) AT=400.025n

.meas tran vdout0_17ck790 FIND v(dout0_17) AT=400.025n

.meas tran vdout0_18ck790 FIND v(dout0_18) AT=400.025n

.meas tran vdout0_19ck790 FIND v(dout0_19) AT=400.025n

.meas tran vdout0_20ck790 FIND v(dout0_20) AT=400.025n

.meas tran vdout0_21ck790 FIND v(dout0_21) AT=400.025n

.meas tran vdout0_22ck790 FIND v(dout0_22) AT=400.025n

.meas tran vdout0_23ck790 FIND v(dout0_23) AT=400.025n

.meas tran vdout0_24ck790 FIND v(dout0_24) AT=400.025n

.meas tran vdout0_25ck790 FIND v(dout0_25) AT=400.025n

.meas tran vdout0_26ck790 FIND v(dout0_26) AT=400.025n

.meas tran vdout0_27ck790 FIND v(dout0_27) AT=400.025n

.meas tran vdout0_28ck790 FIND v(dout0_28) AT=400.025n

.meas tran vdout0_29ck790 FIND v(dout0_29) AT=400.025n

.meas tran vdout0_30ck790 FIND v(dout0_30) AT=400.025n

.meas tran vdout0_31ck790 FIND v(dout0_31) AT=400.025n

.meas tran vdout0_32ck790 FIND v(dout0_32) AT=400.025n

.meas tran vdout0_33ck790 FIND v(dout0_33) AT=400.025n

.meas tran vdout0_34ck790 FIND v(dout0_34) AT=400.025n

.meas tran vdout0_35ck790 FIND v(dout0_35) AT=400.025n

.meas tran vdout0_36ck790 FIND v(dout0_36) AT=400.025n

.meas tran vdout0_37ck790 FIND v(dout0_37) AT=400.025n

.meas tran vdout0_38ck790 FIND v(dout0_38) AT=400.025n

.meas tran vdout0_39ck790 FIND v(dout0_39) AT=400.025n

.meas tran vdout0_40ck790 FIND v(dout0_40) AT=400.025n

.meas tran vdout0_41ck790 FIND v(dout0_41) AT=400.025n

.meas tran vdout0_42ck790 FIND v(dout0_42) AT=400.025n

.meas tran vdout0_43ck790 FIND v(dout0_43) AT=400.025n

.meas tran vdout0_44ck790 FIND v(dout0_44) AT=400.025n

.meas tran vdout0_45ck790 FIND v(dout0_45) AT=400.025n

.meas tran vdout0_46ck790 FIND v(dout0_46) AT=400.025n

.meas tran vdout0_47ck790 FIND v(dout0_47) AT=400.025n

.meas tran vdout0_48ck790 FIND v(dout0_48) AT=400.025n

.meas tran vdout0_49ck790 FIND v(dout0_49) AT=400.025n

.meas tran vdout0_50ck790 FIND v(dout0_50) AT=400.025n

.meas tran vdout0_51ck790 FIND v(dout0_51) AT=400.025n

.meas tran vdout0_52ck790 FIND v(dout0_52) AT=400.025n

.meas tran vdout0_53ck790 FIND v(dout0_53) AT=400.025n

.meas tran vdout0_54ck790 FIND v(dout0_54) AT=400.025n

.meas tran vdout0_55ck790 FIND v(dout0_55) AT=400.025n

.meas tran vdout0_56ck790 FIND v(dout0_56) AT=400.025n

.meas tran vdout0_57ck790 FIND v(dout0_57) AT=400.025n

.meas tran vdout0_58ck790 FIND v(dout0_58) AT=400.025n

.meas tran vdout0_59ck790 FIND v(dout0_59) AT=400.025n

.meas tran vdout0_60ck790 FIND v(dout0_60) AT=400.025n

.meas tran vdout0_61ck790 FIND v(dout0_61) AT=400.025n

.meas tran vdout0_62ck790 FIND v(dout0_62) AT=400.025n

.meas tran vdout0_63ck790 FIND v(dout0_63) AT=400.025n

.meas tran vdout0_64ck790 FIND v(dout0_64) AT=400.025n

.meas tran vdout0_65ck790 FIND v(dout0_65) AT=400.025n

.meas tran vdout0_66ck790 FIND v(dout0_66) AT=400.025n

.meas tran vdout0_67ck790 FIND v(dout0_67) AT=400.025n

.meas tran vdout0_68ck790 FIND v(dout0_68) AT=400.025n

.meas tran vdout0_69ck790 FIND v(dout0_69) AT=400.025n

.meas tran vdout0_70ck790 FIND v(dout0_70) AT=400.025n

.meas tran vdout0_71ck790 FIND v(dout0_71) AT=400.025n

.meas tran vdout0_72ck790 FIND v(dout0_72) AT=400.025n

.meas tran vdout0_73ck790 FIND v(dout0_73) AT=400.025n

.meas tran vdout0_74ck790 FIND v(dout0_74) AT=400.025n

.meas tran vdout0_75ck790 FIND v(dout0_75) AT=400.025n

.meas tran vdout0_76ck790 FIND v(dout0_76) AT=400.025n

.meas tran vdout0_77ck790 FIND v(dout0_77) AT=400.025n

.meas tran vdout0_78ck790 FIND v(dout0_78) AT=400.025n

.meas tran vdout0_79ck790 FIND v(dout0_79) AT=400.025n

.meas tran vdout0_80ck790 FIND v(dout0_80) AT=400.025n

.meas tran vdout0_81ck790 FIND v(dout0_81) AT=400.025n

.meas tran vdout0_82ck790 FIND v(dout0_82) AT=400.025n

.meas tran vdout0_83ck790 FIND v(dout0_83) AT=400.025n

.meas tran vdout0_84ck790 FIND v(dout0_84) AT=400.025n

.meas tran vdout0_85ck790 FIND v(dout0_85) AT=400.025n

.meas tran vdout0_86ck790 FIND v(dout0_86) AT=400.025n

.meas tran vdout0_87ck790 FIND v(dout0_87) AT=400.025n

.meas tran vdout0_88ck790 FIND v(dout0_88) AT=400.025n

.meas tran vdout0_89ck790 FIND v(dout0_89) AT=400.025n

.meas tran vdout0_90ck790 FIND v(dout0_90) AT=400.025n

.meas tran vdout0_91ck790 FIND v(dout0_91) AT=400.025n

.meas tran vdout0_92ck790 FIND v(dout0_92) AT=400.025n

.meas tran vdout0_93ck790 FIND v(dout0_93) AT=400.025n

.meas tran vdout0_94ck790 FIND v(dout0_94) AT=400.025n

.meas tran vdout0_95ck790 FIND v(dout0_95) AT=400.025n

.meas tran vdout0_96ck790 FIND v(dout0_96) AT=400.025n

.meas tran vdout0_97ck790 FIND v(dout0_97) AT=400.025n

.meas tran vdout0_98ck790 FIND v(dout0_98) AT=400.025n

.meas tran vdout0_99ck790 FIND v(dout0_99) AT=400.025n

.meas tran vdout0_100ck790 FIND v(dout0_100) AT=400.025n

.meas tran vdout0_101ck790 FIND v(dout0_101) AT=400.025n

.meas tran vdout0_102ck790 FIND v(dout0_102) AT=400.025n

.meas tran vdout0_103ck790 FIND v(dout0_103) AT=400.025n

.meas tran vdout0_104ck790 FIND v(dout0_104) AT=400.025n

.meas tran vdout0_105ck790 FIND v(dout0_105) AT=400.025n

.meas tran vdout0_106ck790 FIND v(dout0_106) AT=400.025n

.meas tran vdout0_107ck790 FIND v(dout0_107) AT=400.025n

.meas tran vdout0_108ck790 FIND v(dout0_108) AT=400.025n

.meas tran vdout0_109ck790 FIND v(dout0_109) AT=400.025n

.meas tran vdout0_110ck790 FIND v(dout0_110) AT=400.025n

.meas tran vdout0_111ck790 FIND v(dout0_111) AT=400.025n

.meas tran vdout0_112ck790 FIND v(dout0_112) AT=400.025n

.meas tran vdout0_113ck790 FIND v(dout0_113) AT=400.025n

.meas tran vdout0_114ck790 FIND v(dout0_114) AT=400.025n

.meas tran vdout0_115ck790 FIND v(dout0_115) AT=400.025n

.meas tran vdout0_116ck790 FIND v(dout0_116) AT=400.025n

.meas tran vdout0_117ck790 FIND v(dout0_117) AT=400.025n

.meas tran vdout0_118ck790 FIND v(dout0_118) AT=400.025n

.meas tran vdout0_119ck790 FIND v(dout0_119) AT=400.025n

.meas tran vdout0_120ck790 FIND v(dout0_120) AT=400.025n

.meas tran vdout0_121ck790 FIND v(dout0_121) AT=400.025n

.meas tran vdout0_122ck790 FIND v(dout0_122) AT=400.025n

.meas tran vdout0_123ck790 FIND v(dout0_123) AT=400.025n

.meas tran vdout0_124ck790 FIND v(dout0_124) AT=400.025n

.meas tran vdout0_125ck790 FIND v(dout0_125) AT=400.025n

.meas tran vdout0_126ck790 FIND v(dout0_126) AT=400.025n

.meas tran vdout0_127ck790 FIND v(dout0_127) AT=400.025n

.meas tran vdout0_128ck790 FIND v(dout0_128) AT=400.025n

.meas tran vdout0_129ck790 FIND v(dout0_129) AT=400.025n

.meas tran vdout0_130ck790 FIND v(dout0_130) AT=400.025n

.meas tran vdout0_131ck790 FIND v(dout0_131) AT=400.025n

.meas tran vdout0_132ck790 FIND v(dout0_132) AT=400.025n

.meas tran vdout0_133ck790 FIND v(dout0_133) AT=400.025n

.meas tran vdout0_134ck790 FIND v(dout0_134) AT=400.025n

.meas tran vdout0_135ck790 FIND v(dout0_135) AT=400.025n

.meas tran vdout0_136ck790 FIND v(dout0_136) AT=400.025n

.meas tran vdout0_137ck790 FIND v(dout0_137) AT=400.025n

.meas tran vdout0_138ck790 FIND v(dout0_138) AT=400.025n

.meas tran vdout0_139ck790 FIND v(dout0_139) AT=400.025n

.meas tran vdout0_140ck790 FIND v(dout0_140) AT=400.025n

.meas tran vdout0_141ck790 FIND v(dout0_141) AT=400.025n

.meas tran vdout0_142ck790 FIND v(dout0_142) AT=400.025n

.meas tran vdout0_143ck790 FIND v(dout0_143) AT=400.025n

.meas tran vdout0_144ck790 FIND v(dout0_144) AT=400.025n

.meas tran vdout0_145ck790 FIND v(dout0_145) AT=400.025n

.meas tran vdout0_146ck790 FIND v(dout0_146) AT=400.025n

.meas tran vdout0_147ck790 FIND v(dout0_147) AT=400.025n

.meas tran vdout0_148ck790 FIND v(dout0_148) AT=400.025n

.meas tran vdout0_149ck790 FIND v(dout0_149) AT=400.025n

.meas tran vdout0_0ck820 FIND v(dout0_0) AT=415.025n

.meas tran vdout0_1ck820 FIND v(dout0_1) AT=415.025n

.meas tran vdout0_2ck820 FIND v(dout0_2) AT=415.025n

.meas tran vdout0_3ck820 FIND v(dout0_3) AT=415.025n

.meas tran vdout0_4ck820 FIND v(dout0_4) AT=415.025n

.meas tran vdout0_5ck820 FIND v(dout0_5) AT=415.025n

.meas tran vdout0_6ck820 FIND v(dout0_6) AT=415.025n

.meas tran vdout0_7ck820 FIND v(dout0_7) AT=415.025n

.meas tran vdout0_8ck820 FIND v(dout0_8) AT=415.025n

.meas tran vdout0_9ck820 FIND v(dout0_9) AT=415.025n

.meas tran vdout0_10ck820 FIND v(dout0_10) AT=415.025n

.meas tran vdout0_11ck820 FIND v(dout0_11) AT=415.025n

.meas tran vdout0_12ck820 FIND v(dout0_12) AT=415.025n

.meas tran vdout0_13ck820 FIND v(dout0_13) AT=415.025n

.meas tran vdout0_14ck820 FIND v(dout0_14) AT=415.025n

.meas tran vdout0_15ck820 FIND v(dout0_15) AT=415.025n

.meas tran vdout0_16ck820 FIND v(dout0_16) AT=415.025n

.meas tran vdout0_17ck820 FIND v(dout0_17) AT=415.025n

.meas tran vdout0_18ck820 FIND v(dout0_18) AT=415.025n

.meas tran vdout0_19ck820 FIND v(dout0_19) AT=415.025n

.meas tran vdout0_20ck820 FIND v(dout0_20) AT=415.025n

.meas tran vdout0_21ck820 FIND v(dout0_21) AT=415.025n

.meas tran vdout0_22ck820 FIND v(dout0_22) AT=415.025n

.meas tran vdout0_23ck820 FIND v(dout0_23) AT=415.025n

.meas tran vdout0_24ck820 FIND v(dout0_24) AT=415.025n

.meas tran vdout0_25ck820 FIND v(dout0_25) AT=415.025n

.meas tran vdout0_26ck820 FIND v(dout0_26) AT=415.025n

.meas tran vdout0_27ck820 FIND v(dout0_27) AT=415.025n

.meas tran vdout0_28ck820 FIND v(dout0_28) AT=415.025n

.meas tran vdout0_29ck820 FIND v(dout0_29) AT=415.025n

.meas tran vdout0_30ck820 FIND v(dout0_30) AT=415.025n

.meas tran vdout0_31ck820 FIND v(dout0_31) AT=415.025n

.meas tran vdout0_32ck820 FIND v(dout0_32) AT=415.025n

.meas tran vdout0_33ck820 FIND v(dout0_33) AT=415.025n

.meas tran vdout0_34ck820 FIND v(dout0_34) AT=415.025n

.meas tran vdout0_35ck820 FIND v(dout0_35) AT=415.025n

.meas tran vdout0_36ck820 FIND v(dout0_36) AT=415.025n

.meas tran vdout0_37ck820 FIND v(dout0_37) AT=415.025n

.meas tran vdout0_38ck820 FIND v(dout0_38) AT=415.025n

.meas tran vdout0_39ck820 FIND v(dout0_39) AT=415.025n

.meas tran vdout0_40ck820 FIND v(dout0_40) AT=415.025n

.meas tran vdout0_41ck820 FIND v(dout0_41) AT=415.025n

.meas tran vdout0_42ck820 FIND v(dout0_42) AT=415.025n

.meas tran vdout0_43ck820 FIND v(dout0_43) AT=415.025n

.meas tran vdout0_44ck820 FIND v(dout0_44) AT=415.025n

.meas tran vdout0_45ck820 FIND v(dout0_45) AT=415.025n

.meas tran vdout0_46ck820 FIND v(dout0_46) AT=415.025n

.meas tran vdout0_47ck820 FIND v(dout0_47) AT=415.025n

.meas tran vdout0_48ck820 FIND v(dout0_48) AT=415.025n

.meas tran vdout0_49ck820 FIND v(dout0_49) AT=415.025n

.meas tran vdout0_50ck820 FIND v(dout0_50) AT=415.025n

.meas tran vdout0_51ck820 FIND v(dout0_51) AT=415.025n

.meas tran vdout0_52ck820 FIND v(dout0_52) AT=415.025n

.meas tran vdout0_53ck820 FIND v(dout0_53) AT=415.025n

.meas tran vdout0_54ck820 FIND v(dout0_54) AT=415.025n

.meas tran vdout0_55ck820 FIND v(dout0_55) AT=415.025n

.meas tran vdout0_56ck820 FIND v(dout0_56) AT=415.025n

.meas tran vdout0_57ck820 FIND v(dout0_57) AT=415.025n

.meas tran vdout0_58ck820 FIND v(dout0_58) AT=415.025n

.meas tran vdout0_59ck820 FIND v(dout0_59) AT=415.025n

.meas tran vdout0_60ck820 FIND v(dout0_60) AT=415.025n

.meas tran vdout0_61ck820 FIND v(dout0_61) AT=415.025n

.meas tran vdout0_62ck820 FIND v(dout0_62) AT=415.025n

.meas tran vdout0_63ck820 FIND v(dout0_63) AT=415.025n

.meas tran vdout0_64ck820 FIND v(dout0_64) AT=415.025n

.meas tran vdout0_65ck820 FIND v(dout0_65) AT=415.025n

.meas tran vdout0_66ck820 FIND v(dout0_66) AT=415.025n

.meas tran vdout0_67ck820 FIND v(dout0_67) AT=415.025n

.meas tran vdout0_68ck820 FIND v(dout0_68) AT=415.025n

.meas tran vdout0_69ck820 FIND v(dout0_69) AT=415.025n

.meas tran vdout0_70ck820 FIND v(dout0_70) AT=415.025n

.meas tran vdout0_71ck820 FIND v(dout0_71) AT=415.025n

.meas tran vdout0_72ck820 FIND v(dout0_72) AT=415.025n

.meas tran vdout0_73ck820 FIND v(dout0_73) AT=415.025n

.meas tran vdout0_74ck820 FIND v(dout0_74) AT=415.025n

.meas tran vdout0_75ck820 FIND v(dout0_75) AT=415.025n

.meas tran vdout0_76ck820 FIND v(dout0_76) AT=415.025n

.meas tran vdout0_77ck820 FIND v(dout0_77) AT=415.025n

.meas tran vdout0_78ck820 FIND v(dout0_78) AT=415.025n

.meas tran vdout0_79ck820 FIND v(dout0_79) AT=415.025n

.meas tran vdout0_80ck820 FIND v(dout0_80) AT=415.025n

.meas tran vdout0_81ck820 FIND v(dout0_81) AT=415.025n

.meas tran vdout0_82ck820 FIND v(dout0_82) AT=415.025n

.meas tran vdout0_83ck820 FIND v(dout0_83) AT=415.025n

.meas tran vdout0_84ck820 FIND v(dout0_84) AT=415.025n

.meas tran vdout0_85ck820 FIND v(dout0_85) AT=415.025n

.meas tran vdout0_86ck820 FIND v(dout0_86) AT=415.025n

.meas tran vdout0_87ck820 FIND v(dout0_87) AT=415.025n

.meas tran vdout0_88ck820 FIND v(dout0_88) AT=415.025n

.meas tran vdout0_89ck820 FIND v(dout0_89) AT=415.025n

.meas tran vdout0_90ck820 FIND v(dout0_90) AT=415.025n

.meas tran vdout0_91ck820 FIND v(dout0_91) AT=415.025n

.meas tran vdout0_92ck820 FIND v(dout0_92) AT=415.025n

.meas tran vdout0_93ck820 FIND v(dout0_93) AT=415.025n

.meas tran vdout0_94ck820 FIND v(dout0_94) AT=415.025n

.meas tran vdout0_95ck820 FIND v(dout0_95) AT=415.025n

.meas tran vdout0_96ck820 FIND v(dout0_96) AT=415.025n

.meas tran vdout0_97ck820 FIND v(dout0_97) AT=415.025n

.meas tran vdout0_98ck820 FIND v(dout0_98) AT=415.025n

.meas tran vdout0_99ck820 FIND v(dout0_99) AT=415.025n

.meas tran vdout0_100ck820 FIND v(dout0_100) AT=415.025n

.meas tran vdout0_101ck820 FIND v(dout0_101) AT=415.025n

.meas tran vdout0_102ck820 FIND v(dout0_102) AT=415.025n

.meas tran vdout0_103ck820 FIND v(dout0_103) AT=415.025n

.meas tran vdout0_104ck820 FIND v(dout0_104) AT=415.025n

.meas tran vdout0_105ck820 FIND v(dout0_105) AT=415.025n

.meas tran vdout0_106ck820 FIND v(dout0_106) AT=415.025n

.meas tran vdout0_107ck820 FIND v(dout0_107) AT=415.025n

.meas tran vdout0_108ck820 FIND v(dout0_108) AT=415.025n

.meas tran vdout0_109ck820 FIND v(dout0_109) AT=415.025n

.meas tran vdout0_110ck820 FIND v(dout0_110) AT=415.025n

.meas tran vdout0_111ck820 FIND v(dout0_111) AT=415.025n

.meas tran vdout0_112ck820 FIND v(dout0_112) AT=415.025n

.meas tran vdout0_113ck820 FIND v(dout0_113) AT=415.025n

.meas tran vdout0_114ck820 FIND v(dout0_114) AT=415.025n

.meas tran vdout0_115ck820 FIND v(dout0_115) AT=415.025n

.meas tran vdout0_116ck820 FIND v(dout0_116) AT=415.025n

.meas tran vdout0_117ck820 FIND v(dout0_117) AT=415.025n

.meas tran vdout0_118ck820 FIND v(dout0_118) AT=415.025n

.meas tran vdout0_119ck820 FIND v(dout0_119) AT=415.025n

.meas tran vdout0_120ck820 FIND v(dout0_120) AT=415.025n

.meas tran vdout0_121ck820 FIND v(dout0_121) AT=415.025n

.meas tran vdout0_122ck820 FIND v(dout0_122) AT=415.025n

.meas tran vdout0_123ck820 FIND v(dout0_123) AT=415.025n

.meas tran vdout0_124ck820 FIND v(dout0_124) AT=415.025n

.meas tran vdout0_125ck820 FIND v(dout0_125) AT=415.025n

.meas tran vdout0_126ck820 FIND v(dout0_126) AT=415.025n

.meas tran vdout0_127ck820 FIND v(dout0_127) AT=415.025n

.meas tran vdout0_128ck820 FIND v(dout0_128) AT=415.025n

.meas tran vdout0_129ck820 FIND v(dout0_129) AT=415.025n

.meas tran vdout0_130ck820 FIND v(dout0_130) AT=415.025n

.meas tran vdout0_131ck820 FIND v(dout0_131) AT=415.025n

.meas tran vdout0_132ck820 FIND v(dout0_132) AT=415.025n

.meas tran vdout0_133ck820 FIND v(dout0_133) AT=415.025n

.meas tran vdout0_134ck820 FIND v(dout0_134) AT=415.025n

.meas tran vdout0_135ck820 FIND v(dout0_135) AT=415.025n

.meas tran vdout0_136ck820 FIND v(dout0_136) AT=415.025n

.meas tran vdout0_137ck820 FIND v(dout0_137) AT=415.025n

.meas tran vdout0_138ck820 FIND v(dout0_138) AT=415.025n

.meas tran vdout0_139ck820 FIND v(dout0_139) AT=415.025n

.meas tran vdout0_140ck820 FIND v(dout0_140) AT=415.025n

.meas tran vdout0_141ck820 FIND v(dout0_141) AT=415.025n

.meas tran vdout0_142ck820 FIND v(dout0_142) AT=415.025n

.meas tran vdout0_143ck820 FIND v(dout0_143) AT=415.025n

.meas tran vdout0_144ck820 FIND v(dout0_144) AT=415.025n

.meas tran vdout0_145ck820 FIND v(dout0_145) AT=415.025n

.meas tran vdout0_146ck820 FIND v(dout0_146) AT=415.025n

.meas tran vdout0_147ck820 FIND v(dout0_147) AT=415.025n

.meas tran vdout0_148ck820 FIND v(dout0_148) AT=415.025n

.meas tran vdout0_149ck820 FIND v(dout0_149) AT=415.025n

.meas tran vdout0_0ck830 FIND v(dout0_0) AT=420.025n

.meas tran vdout0_1ck830 FIND v(dout0_1) AT=420.025n

.meas tran vdout0_2ck830 FIND v(dout0_2) AT=420.025n

.meas tran vdout0_3ck830 FIND v(dout0_3) AT=420.025n

.meas tran vdout0_4ck830 FIND v(dout0_4) AT=420.025n

.meas tran vdout0_5ck830 FIND v(dout0_5) AT=420.025n

.meas tran vdout0_6ck830 FIND v(dout0_6) AT=420.025n

.meas tran vdout0_7ck830 FIND v(dout0_7) AT=420.025n

.meas tran vdout0_8ck830 FIND v(dout0_8) AT=420.025n

.meas tran vdout0_9ck830 FIND v(dout0_9) AT=420.025n

.meas tran vdout0_10ck830 FIND v(dout0_10) AT=420.025n

.meas tran vdout0_11ck830 FIND v(dout0_11) AT=420.025n

.meas tran vdout0_12ck830 FIND v(dout0_12) AT=420.025n

.meas tran vdout0_13ck830 FIND v(dout0_13) AT=420.025n

.meas tran vdout0_14ck830 FIND v(dout0_14) AT=420.025n

.meas tran vdout0_15ck830 FIND v(dout0_15) AT=420.025n

.meas tran vdout0_16ck830 FIND v(dout0_16) AT=420.025n

.meas tran vdout0_17ck830 FIND v(dout0_17) AT=420.025n

.meas tran vdout0_18ck830 FIND v(dout0_18) AT=420.025n

.meas tran vdout0_19ck830 FIND v(dout0_19) AT=420.025n

.meas tran vdout0_20ck830 FIND v(dout0_20) AT=420.025n

.meas tran vdout0_21ck830 FIND v(dout0_21) AT=420.025n

.meas tran vdout0_22ck830 FIND v(dout0_22) AT=420.025n

.meas tran vdout0_23ck830 FIND v(dout0_23) AT=420.025n

.meas tran vdout0_24ck830 FIND v(dout0_24) AT=420.025n

.meas tran vdout0_25ck830 FIND v(dout0_25) AT=420.025n

.meas tran vdout0_26ck830 FIND v(dout0_26) AT=420.025n

.meas tran vdout0_27ck830 FIND v(dout0_27) AT=420.025n

.meas tran vdout0_28ck830 FIND v(dout0_28) AT=420.025n

.meas tran vdout0_29ck830 FIND v(dout0_29) AT=420.025n

.meas tran vdout0_30ck830 FIND v(dout0_30) AT=420.025n

.meas tran vdout0_31ck830 FIND v(dout0_31) AT=420.025n

.meas tran vdout0_32ck830 FIND v(dout0_32) AT=420.025n

.meas tran vdout0_33ck830 FIND v(dout0_33) AT=420.025n

.meas tran vdout0_34ck830 FIND v(dout0_34) AT=420.025n

.meas tran vdout0_35ck830 FIND v(dout0_35) AT=420.025n

.meas tran vdout0_36ck830 FIND v(dout0_36) AT=420.025n

.meas tran vdout0_37ck830 FIND v(dout0_37) AT=420.025n

.meas tran vdout0_38ck830 FIND v(dout0_38) AT=420.025n

.meas tran vdout0_39ck830 FIND v(dout0_39) AT=420.025n

.meas tran vdout0_40ck830 FIND v(dout0_40) AT=420.025n

.meas tran vdout0_41ck830 FIND v(dout0_41) AT=420.025n

.meas tran vdout0_42ck830 FIND v(dout0_42) AT=420.025n

.meas tran vdout0_43ck830 FIND v(dout0_43) AT=420.025n

.meas tran vdout0_44ck830 FIND v(dout0_44) AT=420.025n

.meas tran vdout0_45ck830 FIND v(dout0_45) AT=420.025n

.meas tran vdout0_46ck830 FIND v(dout0_46) AT=420.025n

.meas tran vdout0_47ck830 FIND v(dout0_47) AT=420.025n

.meas tran vdout0_48ck830 FIND v(dout0_48) AT=420.025n

.meas tran vdout0_49ck830 FIND v(dout0_49) AT=420.025n

.meas tran vdout0_50ck830 FIND v(dout0_50) AT=420.025n

.meas tran vdout0_51ck830 FIND v(dout0_51) AT=420.025n

.meas tran vdout0_52ck830 FIND v(dout0_52) AT=420.025n

.meas tran vdout0_53ck830 FIND v(dout0_53) AT=420.025n

.meas tran vdout0_54ck830 FIND v(dout0_54) AT=420.025n

.meas tran vdout0_55ck830 FIND v(dout0_55) AT=420.025n

.meas tran vdout0_56ck830 FIND v(dout0_56) AT=420.025n

.meas tran vdout0_57ck830 FIND v(dout0_57) AT=420.025n

.meas tran vdout0_58ck830 FIND v(dout0_58) AT=420.025n

.meas tran vdout0_59ck830 FIND v(dout0_59) AT=420.025n

.meas tran vdout0_60ck830 FIND v(dout0_60) AT=420.025n

.meas tran vdout0_61ck830 FIND v(dout0_61) AT=420.025n

.meas tran vdout0_62ck830 FIND v(dout0_62) AT=420.025n

.meas tran vdout0_63ck830 FIND v(dout0_63) AT=420.025n

.meas tran vdout0_64ck830 FIND v(dout0_64) AT=420.025n

.meas tran vdout0_65ck830 FIND v(dout0_65) AT=420.025n

.meas tran vdout0_66ck830 FIND v(dout0_66) AT=420.025n

.meas tran vdout0_67ck830 FIND v(dout0_67) AT=420.025n

.meas tran vdout0_68ck830 FIND v(dout0_68) AT=420.025n

.meas tran vdout0_69ck830 FIND v(dout0_69) AT=420.025n

.meas tran vdout0_70ck830 FIND v(dout0_70) AT=420.025n

.meas tran vdout0_71ck830 FIND v(dout0_71) AT=420.025n

.meas tran vdout0_72ck830 FIND v(dout0_72) AT=420.025n

.meas tran vdout0_73ck830 FIND v(dout0_73) AT=420.025n

.meas tran vdout0_74ck830 FIND v(dout0_74) AT=420.025n

.meas tran vdout0_75ck830 FIND v(dout0_75) AT=420.025n

.meas tran vdout0_76ck830 FIND v(dout0_76) AT=420.025n

.meas tran vdout0_77ck830 FIND v(dout0_77) AT=420.025n

.meas tran vdout0_78ck830 FIND v(dout0_78) AT=420.025n

.meas tran vdout0_79ck830 FIND v(dout0_79) AT=420.025n

.meas tran vdout0_80ck830 FIND v(dout0_80) AT=420.025n

.meas tran vdout0_81ck830 FIND v(dout0_81) AT=420.025n

.meas tran vdout0_82ck830 FIND v(dout0_82) AT=420.025n

.meas tran vdout0_83ck830 FIND v(dout0_83) AT=420.025n

.meas tran vdout0_84ck830 FIND v(dout0_84) AT=420.025n

.meas tran vdout0_85ck830 FIND v(dout0_85) AT=420.025n

.meas tran vdout0_86ck830 FIND v(dout0_86) AT=420.025n

.meas tran vdout0_87ck830 FIND v(dout0_87) AT=420.025n

.meas tran vdout0_88ck830 FIND v(dout0_88) AT=420.025n

.meas tran vdout0_89ck830 FIND v(dout0_89) AT=420.025n

.meas tran vdout0_90ck830 FIND v(dout0_90) AT=420.025n

.meas tran vdout0_91ck830 FIND v(dout0_91) AT=420.025n

.meas tran vdout0_92ck830 FIND v(dout0_92) AT=420.025n

.meas tran vdout0_93ck830 FIND v(dout0_93) AT=420.025n

.meas tran vdout0_94ck830 FIND v(dout0_94) AT=420.025n

.meas tran vdout0_95ck830 FIND v(dout0_95) AT=420.025n

.meas tran vdout0_96ck830 FIND v(dout0_96) AT=420.025n

.meas tran vdout0_97ck830 FIND v(dout0_97) AT=420.025n

.meas tran vdout0_98ck830 FIND v(dout0_98) AT=420.025n

.meas tran vdout0_99ck830 FIND v(dout0_99) AT=420.025n

.meas tran vdout0_100ck830 FIND v(dout0_100) AT=420.025n

.meas tran vdout0_101ck830 FIND v(dout0_101) AT=420.025n

.meas tran vdout0_102ck830 FIND v(dout0_102) AT=420.025n

.meas tran vdout0_103ck830 FIND v(dout0_103) AT=420.025n

.meas tran vdout0_104ck830 FIND v(dout0_104) AT=420.025n

.meas tran vdout0_105ck830 FIND v(dout0_105) AT=420.025n

.meas tran vdout0_106ck830 FIND v(dout0_106) AT=420.025n

.meas tran vdout0_107ck830 FIND v(dout0_107) AT=420.025n

.meas tran vdout0_108ck830 FIND v(dout0_108) AT=420.025n

.meas tran vdout0_109ck830 FIND v(dout0_109) AT=420.025n

.meas tran vdout0_110ck830 FIND v(dout0_110) AT=420.025n

.meas tran vdout0_111ck830 FIND v(dout0_111) AT=420.025n

.meas tran vdout0_112ck830 FIND v(dout0_112) AT=420.025n

.meas tran vdout0_113ck830 FIND v(dout0_113) AT=420.025n

.meas tran vdout0_114ck830 FIND v(dout0_114) AT=420.025n

.meas tran vdout0_115ck830 FIND v(dout0_115) AT=420.025n

.meas tran vdout0_116ck830 FIND v(dout0_116) AT=420.025n

.meas tran vdout0_117ck830 FIND v(dout0_117) AT=420.025n

.meas tran vdout0_118ck830 FIND v(dout0_118) AT=420.025n

.meas tran vdout0_119ck830 FIND v(dout0_119) AT=420.025n

.meas tran vdout0_120ck830 FIND v(dout0_120) AT=420.025n

.meas tran vdout0_121ck830 FIND v(dout0_121) AT=420.025n

.meas tran vdout0_122ck830 FIND v(dout0_122) AT=420.025n

.meas tran vdout0_123ck830 FIND v(dout0_123) AT=420.025n

.meas tran vdout0_124ck830 FIND v(dout0_124) AT=420.025n

.meas tran vdout0_125ck830 FIND v(dout0_125) AT=420.025n

.meas tran vdout0_126ck830 FIND v(dout0_126) AT=420.025n

.meas tran vdout0_127ck830 FIND v(dout0_127) AT=420.025n

.meas tran vdout0_128ck830 FIND v(dout0_128) AT=420.025n

.meas tran vdout0_129ck830 FIND v(dout0_129) AT=420.025n

.meas tran vdout0_130ck830 FIND v(dout0_130) AT=420.025n

.meas tran vdout0_131ck830 FIND v(dout0_131) AT=420.025n

.meas tran vdout0_132ck830 FIND v(dout0_132) AT=420.025n

.meas tran vdout0_133ck830 FIND v(dout0_133) AT=420.025n

.meas tran vdout0_134ck830 FIND v(dout0_134) AT=420.025n

.meas tran vdout0_135ck830 FIND v(dout0_135) AT=420.025n

.meas tran vdout0_136ck830 FIND v(dout0_136) AT=420.025n

.meas tran vdout0_137ck830 FIND v(dout0_137) AT=420.025n

.meas tran vdout0_138ck830 FIND v(dout0_138) AT=420.025n

.meas tran vdout0_139ck830 FIND v(dout0_139) AT=420.025n

.meas tran vdout0_140ck830 FIND v(dout0_140) AT=420.025n

.meas tran vdout0_141ck830 FIND v(dout0_141) AT=420.025n

.meas tran vdout0_142ck830 FIND v(dout0_142) AT=420.025n

.meas tran vdout0_143ck830 FIND v(dout0_143) AT=420.025n

.meas tran vdout0_144ck830 FIND v(dout0_144) AT=420.025n

.meas tran vdout0_145ck830 FIND v(dout0_145) AT=420.025n

.meas tran vdout0_146ck830 FIND v(dout0_146) AT=420.025n

.meas tran vdout0_147ck830 FIND v(dout0_147) AT=420.025n

.meas tran vdout0_148ck830 FIND v(dout0_148) AT=420.025n

.meas tran vdout0_149ck830 FIND v(dout0_149) AT=420.025n

.meas tran vdout0_0ck840 FIND v(dout0_0) AT=425.025n

.meas tran vdout0_1ck840 FIND v(dout0_1) AT=425.025n

.meas tran vdout0_2ck840 FIND v(dout0_2) AT=425.025n

.meas tran vdout0_3ck840 FIND v(dout0_3) AT=425.025n

.meas tran vdout0_4ck840 FIND v(dout0_4) AT=425.025n

.meas tran vdout0_5ck840 FIND v(dout0_5) AT=425.025n

.meas tran vdout0_6ck840 FIND v(dout0_6) AT=425.025n

.meas tran vdout0_7ck840 FIND v(dout0_7) AT=425.025n

.meas tran vdout0_8ck840 FIND v(dout0_8) AT=425.025n

.meas tran vdout0_9ck840 FIND v(dout0_9) AT=425.025n

.meas tran vdout0_10ck840 FIND v(dout0_10) AT=425.025n

.meas tran vdout0_11ck840 FIND v(dout0_11) AT=425.025n

.meas tran vdout0_12ck840 FIND v(dout0_12) AT=425.025n

.meas tran vdout0_13ck840 FIND v(dout0_13) AT=425.025n

.meas tran vdout0_14ck840 FIND v(dout0_14) AT=425.025n

.meas tran vdout0_15ck840 FIND v(dout0_15) AT=425.025n

.meas tran vdout0_16ck840 FIND v(dout0_16) AT=425.025n

.meas tran vdout0_17ck840 FIND v(dout0_17) AT=425.025n

.meas tran vdout0_18ck840 FIND v(dout0_18) AT=425.025n

.meas tran vdout0_19ck840 FIND v(dout0_19) AT=425.025n

.meas tran vdout0_20ck840 FIND v(dout0_20) AT=425.025n

.meas tran vdout0_21ck840 FIND v(dout0_21) AT=425.025n

.meas tran vdout0_22ck840 FIND v(dout0_22) AT=425.025n

.meas tran vdout0_23ck840 FIND v(dout0_23) AT=425.025n

.meas tran vdout0_24ck840 FIND v(dout0_24) AT=425.025n

.meas tran vdout0_25ck840 FIND v(dout0_25) AT=425.025n

.meas tran vdout0_26ck840 FIND v(dout0_26) AT=425.025n

.meas tran vdout0_27ck840 FIND v(dout0_27) AT=425.025n

.meas tran vdout0_28ck840 FIND v(dout0_28) AT=425.025n

.meas tran vdout0_29ck840 FIND v(dout0_29) AT=425.025n

.meas tran vdout0_30ck840 FIND v(dout0_30) AT=425.025n

.meas tran vdout0_31ck840 FIND v(dout0_31) AT=425.025n

.meas tran vdout0_32ck840 FIND v(dout0_32) AT=425.025n

.meas tran vdout0_33ck840 FIND v(dout0_33) AT=425.025n

.meas tran vdout0_34ck840 FIND v(dout0_34) AT=425.025n

.meas tran vdout0_35ck840 FIND v(dout0_35) AT=425.025n

.meas tran vdout0_36ck840 FIND v(dout0_36) AT=425.025n

.meas tran vdout0_37ck840 FIND v(dout0_37) AT=425.025n

.meas tran vdout0_38ck840 FIND v(dout0_38) AT=425.025n

.meas tran vdout0_39ck840 FIND v(dout0_39) AT=425.025n

.meas tran vdout0_40ck840 FIND v(dout0_40) AT=425.025n

.meas tran vdout0_41ck840 FIND v(dout0_41) AT=425.025n

.meas tran vdout0_42ck840 FIND v(dout0_42) AT=425.025n

.meas tran vdout0_43ck840 FIND v(dout0_43) AT=425.025n

.meas tran vdout0_44ck840 FIND v(dout0_44) AT=425.025n

.meas tran vdout0_45ck840 FIND v(dout0_45) AT=425.025n

.meas tran vdout0_46ck840 FIND v(dout0_46) AT=425.025n

.meas tran vdout0_47ck840 FIND v(dout0_47) AT=425.025n

.meas tran vdout0_48ck840 FIND v(dout0_48) AT=425.025n

.meas tran vdout0_49ck840 FIND v(dout0_49) AT=425.025n

.meas tran vdout0_50ck840 FIND v(dout0_50) AT=425.025n

.meas tran vdout0_51ck840 FIND v(dout0_51) AT=425.025n

.meas tran vdout0_52ck840 FIND v(dout0_52) AT=425.025n

.meas tran vdout0_53ck840 FIND v(dout0_53) AT=425.025n

.meas tran vdout0_54ck840 FIND v(dout0_54) AT=425.025n

.meas tran vdout0_55ck840 FIND v(dout0_55) AT=425.025n

.meas tran vdout0_56ck840 FIND v(dout0_56) AT=425.025n

.meas tran vdout0_57ck840 FIND v(dout0_57) AT=425.025n

.meas tran vdout0_58ck840 FIND v(dout0_58) AT=425.025n

.meas tran vdout0_59ck840 FIND v(dout0_59) AT=425.025n

.meas tran vdout0_60ck840 FIND v(dout0_60) AT=425.025n

.meas tran vdout0_61ck840 FIND v(dout0_61) AT=425.025n

.meas tran vdout0_62ck840 FIND v(dout0_62) AT=425.025n

.meas tran vdout0_63ck840 FIND v(dout0_63) AT=425.025n

.meas tran vdout0_64ck840 FIND v(dout0_64) AT=425.025n

.meas tran vdout0_65ck840 FIND v(dout0_65) AT=425.025n

.meas tran vdout0_66ck840 FIND v(dout0_66) AT=425.025n

.meas tran vdout0_67ck840 FIND v(dout0_67) AT=425.025n

.meas tran vdout0_68ck840 FIND v(dout0_68) AT=425.025n

.meas tran vdout0_69ck840 FIND v(dout0_69) AT=425.025n

.meas tran vdout0_70ck840 FIND v(dout0_70) AT=425.025n

.meas tran vdout0_71ck840 FIND v(dout0_71) AT=425.025n

.meas tran vdout0_72ck840 FIND v(dout0_72) AT=425.025n

.meas tran vdout0_73ck840 FIND v(dout0_73) AT=425.025n

.meas tran vdout0_74ck840 FIND v(dout0_74) AT=425.025n

.meas tran vdout0_75ck840 FIND v(dout0_75) AT=425.025n

.meas tran vdout0_76ck840 FIND v(dout0_76) AT=425.025n

.meas tran vdout0_77ck840 FIND v(dout0_77) AT=425.025n

.meas tran vdout0_78ck840 FIND v(dout0_78) AT=425.025n

.meas tran vdout0_79ck840 FIND v(dout0_79) AT=425.025n

.meas tran vdout0_80ck840 FIND v(dout0_80) AT=425.025n

.meas tran vdout0_81ck840 FIND v(dout0_81) AT=425.025n

.meas tran vdout0_82ck840 FIND v(dout0_82) AT=425.025n

.meas tran vdout0_83ck840 FIND v(dout0_83) AT=425.025n

.meas tran vdout0_84ck840 FIND v(dout0_84) AT=425.025n

.meas tran vdout0_85ck840 FIND v(dout0_85) AT=425.025n

.meas tran vdout0_86ck840 FIND v(dout0_86) AT=425.025n

.meas tran vdout0_87ck840 FIND v(dout0_87) AT=425.025n

.meas tran vdout0_88ck840 FIND v(dout0_88) AT=425.025n

.meas tran vdout0_89ck840 FIND v(dout0_89) AT=425.025n

.meas tran vdout0_90ck840 FIND v(dout0_90) AT=425.025n

.meas tran vdout0_91ck840 FIND v(dout0_91) AT=425.025n

.meas tran vdout0_92ck840 FIND v(dout0_92) AT=425.025n

.meas tran vdout0_93ck840 FIND v(dout0_93) AT=425.025n

.meas tran vdout0_94ck840 FIND v(dout0_94) AT=425.025n

.meas tran vdout0_95ck840 FIND v(dout0_95) AT=425.025n

.meas tran vdout0_96ck840 FIND v(dout0_96) AT=425.025n

.meas tran vdout0_97ck840 FIND v(dout0_97) AT=425.025n

.meas tran vdout0_98ck840 FIND v(dout0_98) AT=425.025n

.meas tran vdout0_99ck840 FIND v(dout0_99) AT=425.025n

.meas tran vdout0_100ck840 FIND v(dout0_100) AT=425.025n

.meas tran vdout0_101ck840 FIND v(dout0_101) AT=425.025n

.meas tran vdout0_102ck840 FIND v(dout0_102) AT=425.025n

.meas tran vdout0_103ck840 FIND v(dout0_103) AT=425.025n

.meas tran vdout0_104ck840 FIND v(dout0_104) AT=425.025n

.meas tran vdout0_105ck840 FIND v(dout0_105) AT=425.025n

.meas tran vdout0_106ck840 FIND v(dout0_106) AT=425.025n

.meas tran vdout0_107ck840 FIND v(dout0_107) AT=425.025n

.meas tran vdout0_108ck840 FIND v(dout0_108) AT=425.025n

.meas tran vdout0_109ck840 FIND v(dout0_109) AT=425.025n

.meas tran vdout0_110ck840 FIND v(dout0_110) AT=425.025n

.meas tran vdout0_111ck840 FIND v(dout0_111) AT=425.025n

.meas tran vdout0_112ck840 FIND v(dout0_112) AT=425.025n

.meas tran vdout0_113ck840 FIND v(dout0_113) AT=425.025n

.meas tran vdout0_114ck840 FIND v(dout0_114) AT=425.025n

.meas tran vdout0_115ck840 FIND v(dout0_115) AT=425.025n

.meas tran vdout0_116ck840 FIND v(dout0_116) AT=425.025n

.meas tran vdout0_117ck840 FIND v(dout0_117) AT=425.025n

.meas tran vdout0_118ck840 FIND v(dout0_118) AT=425.025n

.meas tran vdout0_119ck840 FIND v(dout0_119) AT=425.025n

.meas tran vdout0_120ck840 FIND v(dout0_120) AT=425.025n

.meas tran vdout0_121ck840 FIND v(dout0_121) AT=425.025n

.meas tran vdout0_122ck840 FIND v(dout0_122) AT=425.025n

.meas tran vdout0_123ck840 FIND v(dout0_123) AT=425.025n

.meas tran vdout0_124ck840 FIND v(dout0_124) AT=425.025n

.meas tran vdout0_125ck840 FIND v(dout0_125) AT=425.025n

.meas tran vdout0_126ck840 FIND v(dout0_126) AT=425.025n

.meas tran vdout0_127ck840 FIND v(dout0_127) AT=425.025n

.meas tran vdout0_128ck840 FIND v(dout0_128) AT=425.025n

.meas tran vdout0_129ck840 FIND v(dout0_129) AT=425.025n

.meas tran vdout0_130ck840 FIND v(dout0_130) AT=425.025n

.meas tran vdout0_131ck840 FIND v(dout0_131) AT=425.025n

.meas tran vdout0_132ck840 FIND v(dout0_132) AT=425.025n

.meas tran vdout0_133ck840 FIND v(dout0_133) AT=425.025n

.meas tran vdout0_134ck840 FIND v(dout0_134) AT=425.025n

.meas tran vdout0_135ck840 FIND v(dout0_135) AT=425.025n

.meas tran vdout0_136ck840 FIND v(dout0_136) AT=425.025n

.meas tran vdout0_137ck840 FIND v(dout0_137) AT=425.025n

.meas tran vdout0_138ck840 FIND v(dout0_138) AT=425.025n

.meas tran vdout0_139ck840 FIND v(dout0_139) AT=425.025n

.meas tran vdout0_140ck840 FIND v(dout0_140) AT=425.025n

.meas tran vdout0_141ck840 FIND v(dout0_141) AT=425.025n

.meas tran vdout0_142ck840 FIND v(dout0_142) AT=425.025n

.meas tran vdout0_143ck840 FIND v(dout0_143) AT=425.025n

.meas tran vdout0_144ck840 FIND v(dout0_144) AT=425.025n

.meas tran vdout0_145ck840 FIND v(dout0_145) AT=425.025n

.meas tran vdout0_146ck840 FIND v(dout0_146) AT=425.025n

.meas tran vdout0_147ck840 FIND v(dout0_147) AT=425.025n

.meas tran vdout0_148ck840 FIND v(dout0_148) AT=425.025n

.meas tran vdout0_149ck840 FIND v(dout0_149) AT=425.025n

.meas tran vdout0_0ck850 FIND v(dout0_0) AT=430.025n

.meas tran vdout0_1ck850 FIND v(dout0_1) AT=430.025n

.meas tran vdout0_2ck850 FIND v(dout0_2) AT=430.025n

.meas tran vdout0_3ck850 FIND v(dout0_3) AT=430.025n

.meas tran vdout0_4ck850 FIND v(dout0_4) AT=430.025n

.meas tran vdout0_5ck850 FIND v(dout0_5) AT=430.025n

.meas tran vdout0_6ck850 FIND v(dout0_6) AT=430.025n

.meas tran vdout0_7ck850 FIND v(dout0_7) AT=430.025n

.meas tran vdout0_8ck850 FIND v(dout0_8) AT=430.025n

.meas tran vdout0_9ck850 FIND v(dout0_9) AT=430.025n

.meas tran vdout0_10ck850 FIND v(dout0_10) AT=430.025n

.meas tran vdout0_11ck850 FIND v(dout0_11) AT=430.025n

.meas tran vdout0_12ck850 FIND v(dout0_12) AT=430.025n

.meas tran vdout0_13ck850 FIND v(dout0_13) AT=430.025n

.meas tran vdout0_14ck850 FIND v(dout0_14) AT=430.025n

.meas tran vdout0_15ck850 FIND v(dout0_15) AT=430.025n

.meas tran vdout0_16ck850 FIND v(dout0_16) AT=430.025n

.meas tran vdout0_17ck850 FIND v(dout0_17) AT=430.025n

.meas tran vdout0_18ck850 FIND v(dout0_18) AT=430.025n

.meas tran vdout0_19ck850 FIND v(dout0_19) AT=430.025n

.meas tran vdout0_20ck850 FIND v(dout0_20) AT=430.025n

.meas tran vdout0_21ck850 FIND v(dout0_21) AT=430.025n

.meas tran vdout0_22ck850 FIND v(dout0_22) AT=430.025n

.meas tran vdout0_23ck850 FIND v(dout0_23) AT=430.025n

.meas tran vdout0_24ck850 FIND v(dout0_24) AT=430.025n

.meas tran vdout0_25ck850 FIND v(dout0_25) AT=430.025n

.meas tran vdout0_26ck850 FIND v(dout0_26) AT=430.025n

.meas tran vdout0_27ck850 FIND v(dout0_27) AT=430.025n

.meas tran vdout0_28ck850 FIND v(dout0_28) AT=430.025n

.meas tran vdout0_29ck850 FIND v(dout0_29) AT=430.025n

.meas tran vdout0_30ck850 FIND v(dout0_30) AT=430.025n

.meas tran vdout0_31ck850 FIND v(dout0_31) AT=430.025n

.meas tran vdout0_32ck850 FIND v(dout0_32) AT=430.025n

.meas tran vdout0_33ck850 FIND v(dout0_33) AT=430.025n

.meas tran vdout0_34ck850 FIND v(dout0_34) AT=430.025n

.meas tran vdout0_35ck850 FIND v(dout0_35) AT=430.025n

.meas tran vdout0_36ck850 FIND v(dout0_36) AT=430.025n

.meas tran vdout0_37ck850 FIND v(dout0_37) AT=430.025n

.meas tran vdout0_38ck850 FIND v(dout0_38) AT=430.025n

.meas tran vdout0_39ck850 FIND v(dout0_39) AT=430.025n

.meas tran vdout0_40ck850 FIND v(dout0_40) AT=430.025n

.meas tran vdout0_41ck850 FIND v(dout0_41) AT=430.025n

.meas tran vdout0_42ck850 FIND v(dout0_42) AT=430.025n

.meas tran vdout0_43ck850 FIND v(dout0_43) AT=430.025n

.meas tran vdout0_44ck850 FIND v(dout0_44) AT=430.025n

.meas tran vdout0_45ck850 FIND v(dout0_45) AT=430.025n

.meas tran vdout0_46ck850 FIND v(dout0_46) AT=430.025n

.meas tran vdout0_47ck850 FIND v(dout0_47) AT=430.025n

.meas tran vdout0_48ck850 FIND v(dout0_48) AT=430.025n

.meas tran vdout0_49ck850 FIND v(dout0_49) AT=430.025n

.meas tran vdout0_50ck850 FIND v(dout0_50) AT=430.025n

.meas tran vdout0_51ck850 FIND v(dout0_51) AT=430.025n

.meas tran vdout0_52ck850 FIND v(dout0_52) AT=430.025n

.meas tran vdout0_53ck850 FIND v(dout0_53) AT=430.025n

.meas tran vdout0_54ck850 FIND v(dout0_54) AT=430.025n

.meas tran vdout0_55ck850 FIND v(dout0_55) AT=430.025n

.meas tran vdout0_56ck850 FIND v(dout0_56) AT=430.025n

.meas tran vdout0_57ck850 FIND v(dout0_57) AT=430.025n

.meas tran vdout0_58ck850 FIND v(dout0_58) AT=430.025n

.meas tran vdout0_59ck850 FIND v(dout0_59) AT=430.025n

.meas tran vdout0_60ck850 FIND v(dout0_60) AT=430.025n

.meas tran vdout0_61ck850 FIND v(dout0_61) AT=430.025n

.meas tran vdout0_62ck850 FIND v(dout0_62) AT=430.025n

.meas tran vdout0_63ck850 FIND v(dout0_63) AT=430.025n

.meas tran vdout0_64ck850 FIND v(dout0_64) AT=430.025n

.meas tran vdout0_65ck850 FIND v(dout0_65) AT=430.025n

.meas tran vdout0_66ck850 FIND v(dout0_66) AT=430.025n

.meas tran vdout0_67ck850 FIND v(dout0_67) AT=430.025n

.meas tran vdout0_68ck850 FIND v(dout0_68) AT=430.025n

.meas tran vdout0_69ck850 FIND v(dout0_69) AT=430.025n

.meas tran vdout0_70ck850 FIND v(dout0_70) AT=430.025n

.meas tran vdout0_71ck850 FIND v(dout0_71) AT=430.025n

.meas tran vdout0_72ck850 FIND v(dout0_72) AT=430.025n

.meas tran vdout0_73ck850 FIND v(dout0_73) AT=430.025n

.meas tran vdout0_74ck850 FIND v(dout0_74) AT=430.025n

.meas tran vdout0_75ck850 FIND v(dout0_75) AT=430.025n

.meas tran vdout0_76ck850 FIND v(dout0_76) AT=430.025n

.meas tran vdout0_77ck850 FIND v(dout0_77) AT=430.025n

.meas tran vdout0_78ck850 FIND v(dout0_78) AT=430.025n

.meas tran vdout0_79ck850 FIND v(dout0_79) AT=430.025n

.meas tran vdout0_80ck850 FIND v(dout0_80) AT=430.025n

.meas tran vdout0_81ck850 FIND v(dout0_81) AT=430.025n

.meas tran vdout0_82ck850 FIND v(dout0_82) AT=430.025n

.meas tran vdout0_83ck850 FIND v(dout0_83) AT=430.025n

.meas tran vdout0_84ck850 FIND v(dout0_84) AT=430.025n

.meas tran vdout0_85ck850 FIND v(dout0_85) AT=430.025n

.meas tran vdout0_86ck850 FIND v(dout0_86) AT=430.025n

.meas tran vdout0_87ck850 FIND v(dout0_87) AT=430.025n

.meas tran vdout0_88ck850 FIND v(dout0_88) AT=430.025n

.meas tran vdout0_89ck850 FIND v(dout0_89) AT=430.025n

.meas tran vdout0_90ck850 FIND v(dout0_90) AT=430.025n

.meas tran vdout0_91ck850 FIND v(dout0_91) AT=430.025n

.meas tran vdout0_92ck850 FIND v(dout0_92) AT=430.025n

.meas tran vdout0_93ck850 FIND v(dout0_93) AT=430.025n

.meas tran vdout0_94ck850 FIND v(dout0_94) AT=430.025n

.meas tran vdout0_95ck850 FIND v(dout0_95) AT=430.025n

.meas tran vdout0_96ck850 FIND v(dout0_96) AT=430.025n

.meas tran vdout0_97ck850 FIND v(dout0_97) AT=430.025n

.meas tran vdout0_98ck850 FIND v(dout0_98) AT=430.025n

.meas tran vdout0_99ck850 FIND v(dout0_99) AT=430.025n

.meas tran vdout0_100ck850 FIND v(dout0_100) AT=430.025n

.meas tran vdout0_101ck850 FIND v(dout0_101) AT=430.025n

.meas tran vdout0_102ck850 FIND v(dout0_102) AT=430.025n

.meas tran vdout0_103ck850 FIND v(dout0_103) AT=430.025n

.meas tran vdout0_104ck850 FIND v(dout0_104) AT=430.025n

.meas tran vdout0_105ck850 FIND v(dout0_105) AT=430.025n

.meas tran vdout0_106ck850 FIND v(dout0_106) AT=430.025n

.meas tran vdout0_107ck850 FIND v(dout0_107) AT=430.025n

.meas tran vdout0_108ck850 FIND v(dout0_108) AT=430.025n

.meas tran vdout0_109ck850 FIND v(dout0_109) AT=430.025n

.meas tran vdout0_110ck850 FIND v(dout0_110) AT=430.025n

.meas tran vdout0_111ck850 FIND v(dout0_111) AT=430.025n

.meas tran vdout0_112ck850 FIND v(dout0_112) AT=430.025n

.meas tran vdout0_113ck850 FIND v(dout0_113) AT=430.025n

.meas tran vdout0_114ck850 FIND v(dout0_114) AT=430.025n

.meas tran vdout0_115ck850 FIND v(dout0_115) AT=430.025n

.meas tran vdout0_116ck850 FIND v(dout0_116) AT=430.025n

.meas tran vdout0_117ck850 FIND v(dout0_117) AT=430.025n

.meas tran vdout0_118ck850 FIND v(dout0_118) AT=430.025n

.meas tran vdout0_119ck850 FIND v(dout0_119) AT=430.025n

.meas tran vdout0_120ck850 FIND v(dout0_120) AT=430.025n

.meas tran vdout0_121ck850 FIND v(dout0_121) AT=430.025n

.meas tran vdout0_122ck850 FIND v(dout0_122) AT=430.025n

.meas tran vdout0_123ck850 FIND v(dout0_123) AT=430.025n

.meas tran vdout0_124ck850 FIND v(dout0_124) AT=430.025n

.meas tran vdout0_125ck850 FIND v(dout0_125) AT=430.025n

.meas tran vdout0_126ck850 FIND v(dout0_126) AT=430.025n

.meas tran vdout0_127ck850 FIND v(dout0_127) AT=430.025n

.meas tran vdout0_128ck850 FIND v(dout0_128) AT=430.025n

.meas tran vdout0_129ck850 FIND v(dout0_129) AT=430.025n

.meas tran vdout0_130ck850 FIND v(dout0_130) AT=430.025n

.meas tran vdout0_131ck850 FIND v(dout0_131) AT=430.025n

.meas tran vdout0_132ck850 FIND v(dout0_132) AT=430.025n

.meas tran vdout0_133ck850 FIND v(dout0_133) AT=430.025n

.meas tran vdout0_134ck850 FIND v(dout0_134) AT=430.025n

.meas tran vdout0_135ck850 FIND v(dout0_135) AT=430.025n

.meas tran vdout0_136ck850 FIND v(dout0_136) AT=430.025n

.meas tran vdout0_137ck850 FIND v(dout0_137) AT=430.025n

.meas tran vdout0_138ck850 FIND v(dout0_138) AT=430.025n

.meas tran vdout0_139ck850 FIND v(dout0_139) AT=430.025n

.meas tran vdout0_140ck850 FIND v(dout0_140) AT=430.025n

.meas tran vdout0_141ck850 FIND v(dout0_141) AT=430.025n

.meas tran vdout0_142ck850 FIND v(dout0_142) AT=430.025n

.meas tran vdout0_143ck850 FIND v(dout0_143) AT=430.025n

.meas tran vdout0_144ck850 FIND v(dout0_144) AT=430.025n

.meas tran vdout0_145ck850 FIND v(dout0_145) AT=430.025n

.meas tran vdout0_146ck850 FIND v(dout0_146) AT=430.025n

.meas tran vdout0_147ck850 FIND v(dout0_147) AT=430.025n

.meas tran vdout0_148ck850 FIND v(dout0_148) AT=430.025n

.meas tran vdout0_149ck850 FIND v(dout0_149) AT=430.025n

.meas tran vdout0_0ck860 FIND v(dout0_0) AT=435.025n

.meas tran vdout0_1ck860 FIND v(dout0_1) AT=435.025n

.meas tran vdout0_2ck860 FIND v(dout0_2) AT=435.025n

.meas tran vdout0_3ck860 FIND v(dout0_3) AT=435.025n

.meas tran vdout0_4ck860 FIND v(dout0_4) AT=435.025n

.meas tran vdout0_5ck860 FIND v(dout0_5) AT=435.025n

.meas tran vdout0_6ck860 FIND v(dout0_6) AT=435.025n

.meas tran vdout0_7ck860 FIND v(dout0_7) AT=435.025n

.meas tran vdout0_8ck860 FIND v(dout0_8) AT=435.025n

.meas tran vdout0_9ck860 FIND v(dout0_9) AT=435.025n

.meas tran vdout0_10ck860 FIND v(dout0_10) AT=435.025n

.meas tran vdout0_11ck860 FIND v(dout0_11) AT=435.025n

.meas tran vdout0_12ck860 FIND v(dout0_12) AT=435.025n

.meas tran vdout0_13ck860 FIND v(dout0_13) AT=435.025n

.meas tran vdout0_14ck860 FIND v(dout0_14) AT=435.025n

.meas tran vdout0_15ck860 FIND v(dout0_15) AT=435.025n

.meas tran vdout0_16ck860 FIND v(dout0_16) AT=435.025n

.meas tran vdout0_17ck860 FIND v(dout0_17) AT=435.025n

.meas tran vdout0_18ck860 FIND v(dout0_18) AT=435.025n

.meas tran vdout0_19ck860 FIND v(dout0_19) AT=435.025n

.meas tran vdout0_20ck860 FIND v(dout0_20) AT=435.025n

.meas tran vdout0_21ck860 FIND v(dout0_21) AT=435.025n

.meas tran vdout0_22ck860 FIND v(dout0_22) AT=435.025n

.meas tran vdout0_23ck860 FIND v(dout0_23) AT=435.025n

.meas tran vdout0_24ck860 FIND v(dout0_24) AT=435.025n

.meas tran vdout0_25ck860 FIND v(dout0_25) AT=435.025n

.meas tran vdout0_26ck860 FIND v(dout0_26) AT=435.025n

.meas tran vdout0_27ck860 FIND v(dout0_27) AT=435.025n

.meas tran vdout0_28ck860 FIND v(dout0_28) AT=435.025n

.meas tran vdout0_29ck860 FIND v(dout0_29) AT=435.025n

.meas tran vdout0_30ck860 FIND v(dout0_30) AT=435.025n

.meas tran vdout0_31ck860 FIND v(dout0_31) AT=435.025n

.meas tran vdout0_32ck860 FIND v(dout0_32) AT=435.025n

.meas tran vdout0_33ck860 FIND v(dout0_33) AT=435.025n

.meas tran vdout0_34ck860 FIND v(dout0_34) AT=435.025n

.meas tran vdout0_35ck860 FIND v(dout0_35) AT=435.025n

.meas tran vdout0_36ck860 FIND v(dout0_36) AT=435.025n

.meas tran vdout0_37ck860 FIND v(dout0_37) AT=435.025n

.meas tran vdout0_38ck860 FIND v(dout0_38) AT=435.025n

.meas tran vdout0_39ck860 FIND v(dout0_39) AT=435.025n

.meas tran vdout0_40ck860 FIND v(dout0_40) AT=435.025n

.meas tran vdout0_41ck860 FIND v(dout0_41) AT=435.025n

.meas tran vdout0_42ck860 FIND v(dout0_42) AT=435.025n

.meas tran vdout0_43ck860 FIND v(dout0_43) AT=435.025n

.meas tran vdout0_44ck860 FIND v(dout0_44) AT=435.025n

.meas tran vdout0_45ck860 FIND v(dout0_45) AT=435.025n

.meas tran vdout0_46ck860 FIND v(dout0_46) AT=435.025n

.meas tran vdout0_47ck860 FIND v(dout0_47) AT=435.025n

.meas tran vdout0_48ck860 FIND v(dout0_48) AT=435.025n

.meas tran vdout0_49ck860 FIND v(dout0_49) AT=435.025n

.meas tran vdout0_50ck860 FIND v(dout0_50) AT=435.025n

.meas tran vdout0_51ck860 FIND v(dout0_51) AT=435.025n

.meas tran vdout0_52ck860 FIND v(dout0_52) AT=435.025n

.meas tran vdout0_53ck860 FIND v(dout0_53) AT=435.025n

.meas tran vdout0_54ck860 FIND v(dout0_54) AT=435.025n

.meas tran vdout0_55ck860 FIND v(dout0_55) AT=435.025n

.meas tran vdout0_56ck860 FIND v(dout0_56) AT=435.025n

.meas tran vdout0_57ck860 FIND v(dout0_57) AT=435.025n

.meas tran vdout0_58ck860 FIND v(dout0_58) AT=435.025n

.meas tran vdout0_59ck860 FIND v(dout0_59) AT=435.025n

.meas tran vdout0_60ck860 FIND v(dout0_60) AT=435.025n

.meas tran vdout0_61ck860 FIND v(dout0_61) AT=435.025n

.meas tran vdout0_62ck860 FIND v(dout0_62) AT=435.025n

.meas tran vdout0_63ck860 FIND v(dout0_63) AT=435.025n

.meas tran vdout0_64ck860 FIND v(dout0_64) AT=435.025n

.meas tran vdout0_65ck860 FIND v(dout0_65) AT=435.025n

.meas tran vdout0_66ck860 FIND v(dout0_66) AT=435.025n

.meas tran vdout0_67ck860 FIND v(dout0_67) AT=435.025n

.meas tran vdout0_68ck860 FIND v(dout0_68) AT=435.025n

.meas tran vdout0_69ck860 FIND v(dout0_69) AT=435.025n

.meas tran vdout0_70ck860 FIND v(dout0_70) AT=435.025n

.meas tran vdout0_71ck860 FIND v(dout0_71) AT=435.025n

.meas tran vdout0_72ck860 FIND v(dout0_72) AT=435.025n

.meas tran vdout0_73ck860 FIND v(dout0_73) AT=435.025n

.meas tran vdout0_74ck860 FIND v(dout0_74) AT=435.025n

.meas tran vdout0_75ck860 FIND v(dout0_75) AT=435.025n

.meas tran vdout0_76ck860 FIND v(dout0_76) AT=435.025n

.meas tran vdout0_77ck860 FIND v(dout0_77) AT=435.025n

.meas tran vdout0_78ck860 FIND v(dout0_78) AT=435.025n

.meas tran vdout0_79ck860 FIND v(dout0_79) AT=435.025n

.meas tran vdout0_80ck860 FIND v(dout0_80) AT=435.025n

.meas tran vdout0_81ck860 FIND v(dout0_81) AT=435.025n

.meas tran vdout0_82ck860 FIND v(dout0_82) AT=435.025n

.meas tran vdout0_83ck860 FIND v(dout0_83) AT=435.025n

.meas tran vdout0_84ck860 FIND v(dout0_84) AT=435.025n

.meas tran vdout0_85ck860 FIND v(dout0_85) AT=435.025n

.meas tran vdout0_86ck860 FIND v(dout0_86) AT=435.025n

.meas tran vdout0_87ck860 FIND v(dout0_87) AT=435.025n

.meas tran vdout0_88ck860 FIND v(dout0_88) AT=435.025n

.meas tran vdout0_89ck860 FIND v(dout0_89) AT=435.025n

.meas tran vdout0_90ck860 FIND v(dout0_90) AT=435.025n

.meas tran vdout0_91ck860 FIND v(dout0_91) AT=435.025n

.meas tran vdout0_92ck860 FIND v(dout0_92) AT=435.025n

.meas tran vdout0_93ck860 FIND v(dout0_93) AT=435.025n

.meas tran vdout0_94ck860 FIND v(dout0_94) AT=435.025n

.meas tran vdout0_95ck860 FIND v(dout0_95) AT=435.025n

.meas tran vdout0_96ck860 FIND v(dout0_96) AT=435.025n

.meas tran vdout0_97ck860 FIND v(dout0_97) AT=435.025n

.meas tran vdout0_98ck860 FIND v(dout0_98) AT=435.025n

.meas tran vdout0_99ck860 FIND v(dout0_99) AT=435.025n

.meas tran vdout0_100ck860 FIND v(dout0_100) AT=435.025n

.meas tran vdout0_101ck860 FIND v(dout0_101) AT=435.025n

.meas tran vdout0_102ck860 FIND v(dout0_102) AT=435.025n

.meas tran vdout0_103ck860 FIND v(dout0_103) AT=435.025n

.meas tran vdout0_104ck860 FIND v(dout0_104) AT=435.025n

.meas tran vdout0_105ck860 FIND v(dout0_105) AT=435.025n

.meas tran vdout0_106ck860 FIND v(dout0_106) AT=435.025n

.meas tran vdout0_107ck860 FIND v(dout0_107) AT=435.025n

.meas tran vdout0_108ck860 FIND v(dout0_108) AT=435.025n

.meas tran vdout0_109ck860 FIND v(dout0_109) AT=435.025n

.meas tran vdout0_110ck860 FIND v(dout0_110) AT=435.025n

.meas tran vdout0_111ck860 FIND v(dout0_111) AT=435.025n

.meas tran vdout0_112ck860 FIND v(dout0_112) AT=435.025n

.meas tran vdout0_113ck860 FIND v(dout0_113) AT=435.025n

.meas tran vdout0_114ck860 FIND v(dout0_114) AT=435.025n

.meas tran vdout0_115ck860 FIND v(dout0_115) AT=435.025n

.meas tran vdout0_116ck860 FIND v(dout0_116) AT=435.025n

.meas tran vdout0_117ck860 FIND v(dout0_117) AT=435.025n

.meas tran vdout0_118ck860 FIND v(dout0_118) AT=435.025n

.meas tran vdout0_119ck860 FIND v(dout0_119) AT=435.025n

.meas tran vdout0_120ck860 FIND v(dout0_120) AT=435.025n

.meas tran vdout0_121ck860 FIND v(dout0_121) AT=435.025n

.meas tran vdout0_122ck860 FIND v(dout0_122) AT=435.025n

.meas tran vdout0_123ck860 FIND v(dout0_123) AT=435.025n

.meas tran vdout0_124ck860 FIND v(dout0_124) AT=435.025n

.meas tran vdout0_125ck860 FIND v(dout0_125) AT=435.025n

.meas tran vdout0_126ck860 FIND v(dout0_126) AT=435.025n

.meas tran vdout0_127ck860 FIND v(dout0_127) AT=435.025n

.meas tran vdout0_128ck860 FIND v(dout0_128) AT=435.025n

.meas tran vdout0_129ck860 FIND v(dout0_129) AT=435.025n

.meas tran vdout0_130ck860 FIND v(dout0_130) AT=435.025n

.meas tran vdout0_131ck860 FIND v(dout0_131) AT=435.025n

.meas tran vdout0_132ck860 FIND v(dout0_132) AT=435.025n

.meas tran vdout0_133ck860 FIND v(dout0_133) AT=435.025n

.meas tran vdout0_134ck860 FIND v(dout0_134) AT=435.025n

.meas tran vdout0_135ck860 FIND v(dout0_135) AT=435.025n

.meas tran vdout0_136ck860 FIND v(dout0_136) AT=435.025n

.meas tran vdout0_137ck860 FIND v(dout0_137) AT=435.025n

.meas tran vdout0_138ck860 FIND v(dout0_138) AT=435.025n

.meas tran vdout0_139ck860 FIND v(dout0_139) AT=435.025n

.meas tran vdout0_140ck860 FIND v(dout0_140) AT=435.025n

.meas tran vdout0_141ck860 FIND v(dout0_141) AT=435.025n

.meas tran vdout0_142ck860 FIND v(dout0_142) AT=435.025n

.meas tran vdout0_143ck860 FIND v(dout0_143) AT=435.025n

.meas tran vdout0_144ck860 FIND v(dout0_144) AT=435.025n

.meas tran vdout0_145ck860 FIND v(dout0_145) AT=435.025n

.meas tran vdout0_146ck860 FIND v(dout0_146) AT=435.025n

.meas tran vdout0_147ck860 FIND v(dout0_147) AT=435.025n

.meas tran vdout0_148ck860 FIND v(dout0_148) AT=435.025n

.meas tran vdout0_149ck860 FIND v(dout0_149) AT=435.025n

.meas tran vdout0_0ck870 FIND v(dout0_0) AT=440.025n

.meas tran vdout0_1ck870 FIND v(dout0_1) AT=440.025n

.meas tran vdout0_2ck870 FIND v(dout0_2) AT=440.025n

.meas tran vdout0_3ck870 FIND v(dout0_3) AT=440.025n

.meas tran vdout0_4ck870 FIND v(dout0_4) AT=440.025n

.meas tran vdout0_5ck870 FIND v(dout0_5) AT=440.025n

.meas tran vdout0_6ck870 FIND v(dout0_6) AT=440.025n

.meas tran vdout0_7ck870 FIND v(dout0_7) AT=440.025n

.meas tran vdout0_8ck870 FIND v(dout0_8) AT=440.025n

.meas tran vdout0_9ck870 FIND v(dout0_9) AT=440.025n

.meas tran vdout0_10ck870 FIND v(dout0_10) AT=440.025n

.meas tran vdout0_11ck870 FIND v(dout0_11) AT=440.025n

.meas tran vdout0_12ck870 FIND v(dout0_12) AT=440.025n

.meas tran vdout0_13ck870 FIND v(dout0_13) AT=440.025n

.meas tran vdout0_14ck870 FIND v(dout0_14) AT=440.025n

.meas tran vdout0_15ck870 FIND v(dout0_15) AT=440.025n

.meas tran vdout0_16ck870 FIND v(dout0_16) AT=440.025n

.meas tran vdout0_17ck870 FIND v(dout0_17) AT=440.025n

.meas tran vdout0_18ck870 FIND v(dout0_18) AT=440.025n

.meas tran vdout0_19ck870 FIND v(dout0_19) AT=440.025n

.meas tran vdout0_20ck870 FIND v(dout0_20) AT=440.025n

.meas tran vdout0_21ck870 FIND v(dout0_21) AT=440.025n

.meas tran vdout0_22ck870 FIND v(dout0_22) AT=440.025n

.meas tran vdout0_23ck870 FIND v(dout0_23) AT=440.025n

.meas tran vdout0_24ck870 FIND v(dout0_24) AT=440.025n

.meas tran vdout0_25ck870 FIND v(dout0_25) AT=440.025n

.meas tran vdout0_26ck870 FIND v(dout0_26) AT=440.025n

.meas tran vdout0_27ck870 FIND v(dout0_27) AT=440.025n

.meas tran vdout0_28ck870 FIND v(dout0_28) AT=440.025n

.meas tran vdout0_29ck870 FIND v(dout0_29) AT=440.025n

.meas tran vdout0_30ck870 FIND v(dout0_30) AT=440.025n

.meas tran vdout0_31ck870 FIND v(dout0_31) AT=440.025n

.meas tran vdout0_32ck870 FIND v(dout0_32) AT=440.025n

.meas tran vdout0_33ck870 FIND v(dout0_33) AT=440.025n

.meas tran vdout0_34ck870 FIND v(dout0_34) AT=440.025n

.meas tran vdout0_35ck870 FIND v(dout0_35) AT=440.025n

.meas tran vdout0_36ck870 FIND v(dout0_36) AT=440.025n

.meas tran vdout0_37ck870 FIND v(dout0_37) AT=440.025n

.meas tran vdout0_38ck870 FIND v(dout0_38) AT=440.025n

.meas tran vdout0_39ck870 FIND v(dout0_39) AT=440.025n

.meas tran vdout0_40ck870 FIND v(dout0_40) AT=440.025n

.meas tran vdout0_41ck870 FIND v(dout0_41) AT=440.025n

.meas tran vdout0_42ck870 FIND v(dout0_42) AT=440.025n

.meas tran vdout0_43ck870 FIND v(dout0_43) AT=440.025n

.meas tran vdout0_44ck870 FIND v(dout0_44) AT=440.025n

.meas tran vdout0_45ck870 FIND v(dout0_45) AT=440.025n

.meas tran vdout0_46ck870 FIND v(dout0_46) AT=440.025n

.meas tran vdout0_47ck870 FIND v(dout0_47) AT=440.025n

.meas tran vdout0_48ck870 FIND v(dout0_48) AT=440.025n

.meas tran vdout0_49ck870 FIND v(dout0_49) AT=440.025n

.meas tran vdout0_50ck870 FIND v(dout0_50) AT=440.025n

.meas tran vdout0_51ck870 FIND v(dout0_51) AT=440.025n

.meas tran vdout0_52ck870 FIND v(dout0_52) AT=440.025n

.meas tran vdout0_53ck870 FIND v(dout0_53) AT=440.025n

.meas tran vdout0_54ck870 FIND v(dout0_54) AT=440.025n

.meas tran vdout0_55ck870 FIND v(dout0_55) AT=440.025n

.meas tran vdout0_56ck870 FIND v(dout0_56) AT=440.025n

.meas tran vdout0_57ck870 FIND v(dout0_57) AT=440.025n

.meas tran vdout0_58ck870 FIND v(dout0_58) AT=440.025n

.meas tran vdout0_59ck870 FIND v(dout0_59) AT=440.025n

.meas tran vdout0_60ck870 FIND v(dout0_60) AT=440.025n

.meas tran vdout0_61ck870 FIND v(dout0_61) AT=440.025n

.meas tran vdout0_62ck870 FIND v(dout0_62) AT=440.025n

.meas tran vdout0_63ck870 FIND v(dout0_63) AT=440.025n

.meas tran vdout0_64ck870 FIND v(dout0_64) AT=440.025n

.meas tran vdout0_65ck870 FIND v(dout0_65) AT=440.025n

.meas tran vdout0_66ck870 FIND v(dout0_66) AT=440.025n

.meas tran vdout0_67ck870 FIND v(dout0_67) AT=440.025n

.meas tran vdout0_68ck870 FIND v(dout0_68) AT=440.025n

.meas tran vdout0_69ck870 FIND v(dout0_69) AT=440.025n

.meas tran vdout0_70ck870 FIND v(dout0_70) AT=440.025n

.meas tran vdout0_71ck870 FIND v(dout0_71) AT=440.025n

.meas tran vdout0_72ck870 FIND v(dout0_72) AT=440.025n

.meas tran vdout0_73ck870 FIND v(dout0_73) AT=440.025n

.meas tran vdout0_74ck870 FIND v(dout0_74) AT=440.025n

.meas tran vdout0_75ck870 FIND v(dout0_75) AT=440.025n

.meas tran vdout0_76ck870 FIND v(dout0_76) AT=440.025n

.meas tran vdout0_77ck870 FIND v(dout0_77) AT=440.025n

.meas tran vdout0_78ck870 FIND v(dout0_78) AT=440.025n

.meas tran vdout0_79ck870 FIND v(dout0_79) AT=440.025n

.meas tran vdout0_80ck870 FIND v(dout0_80) AT=440.025n

.meas tran vdout0_81ck870 FIND v(dout0_81) AT=440.025n

.meas tran vdout0_82ck870 FIND v(dout0_82) AT=440.025n

.meas tran vdout0_83ck870 FIND v(dout0_83) AT=440.025n

.meas tran vdout0_84ck870 FIND v(dout0_84) AT=440.025n

.meas tran vdout0_85ck870 FIND v(dout0_85) AT=440.025n

.meas tran vdout0_86ck870 FIND v(dout0_86) AT=440.025n

.meas tran vdout0_87ck870 FIND v(dout0_87) AT=440.025n

.meas tran vdout0_88ck870 FIND v(dout0_88) AT=440.025n

.meas tran vdout0_89ck870 FIND v(dout0_89) AT=440.025n

.meas tran vdout0_90ck870 FIND v(dout0_90) AT=440.025n

.meas tran vdout0_91ck870 FIND v(dout0_91) AT=440.025n

.meas tran vdout0_92ck870 FIND v(dout0_92) AT=440.025n

.meas tran vdout0_93ck870 FIND v(dout0_93) AT=440.025n

.meas tran vdout0_94ck870 FIND v(dout0_94) AT=440.025n

.meas tran vdout0_95ck870 FIND v(dout0_95) AT=440.025n

.meas tran vdout0_96ck870 FIND v(dout0_96) AT=440.025n

.meas tran vdout0_97ck870 FIND v(dout0_97) AT=440.025n

.meas tran vdout0_98ck870 FIND v(dout0_98) AT=440.025n

.meas tran vdout0_99ck870 FIND v(dout0_99) AT=440.025n

.meas tran vdout0_100ck870 FIND v(dout0_100) AT=440.025n

.meas tran vdout0_101ck870 FIND v(dout0_101) AT=440.025n

.meas tran vdout0_102ck870 FIND v(dout0_102) AT=440.025n

.meas tran vdout0_103ck870 FIND v(dout0_103) AT=440.025n

.meas tran vdout0_104ck870 FIND v(dout0_104) AT=440.025n

.meas tran vdout0_105ck870 FIND v(dout0_105) AT=440.025n

.meas tran vdout0_106ck870 FIND v(dout0_106) AT=440.025n

.meas tran vdout0_107ck870 FIND v(dout0_107) AT=440.025n

.meas tran vdout0_108ck870 FIND v(dout0_108) AT=440.025n

.meas tran vdout0_109ck870 FIND v(dout0_109) AT=440.025n

.meas tran vdout0_110ck870 FIND v(dout0_110) AT=440.025n

.meas tran vdout0_111ck870 FIND v(dout0_111) AT=440.025n

.meas tran vdout0_112ck870 FIND v(dout0_112) AT=440.025n

.meas tran vdout0_113ck870 FIND v(dout0_113) AT=440.025n

.meas tran vdout0_114ck870 FIND v(dout0_114) AT=440.025n

.meas tran vdout0_115ck870 FIND v(dout0_115) AT=440.025n

.meas tran vdout0_116ck870 FIND v(dout0_116) AT=440.025n

.meas tran vdout0_117ck870 FIND v(dout0_117) AT=440.025n

.meas tran vdout0_118ck870 FIND v(dout0_118) AT=440.025n

.meas tran vdout0_119ck870 FIND v(dout0_119) AT=440.025n

.meas tran vdout0_120ck870 FIND v(dout0_120) AT=440.025n

.meas tran vdout0_121ck870 FIND v(dout0_121) AT=440.025n

.meas tran vdout0_122ck870 FIND v(dout0_122) AT=440.025n

.meas tran vdout0_123ck870 FIND v(dout0_123) AT=440.025n

.meas tran vdout0_124ck870 FIND v(dout0_124) AT=440.025n

.meas tran vdout0_125ck870 FIND v(dout0_125) AT=440.025n

.meas tran vdout0_126ck870 FIND v(dout0_126) AT=440.025n

.meas tran vdout0_127ck870 FIND v(dout0_127) AT=440.025n

.meas tran vdout0_128ck870 FIND v(dout0_128) AT=440.025n

.meas tran vdout0_129ck870 FIND v(dout0_129) AT=440.025n

.meas tran vdout0_130ck870 FIND v(dout0_130) AT=440.025n

.meas tran vdout0_131ck870 FIND v(dout0_131) AT=440.025n

.meas tran vdout0_132ck870 FIND v(dout0_132) AT=440.025n

.meas tran vdout0_133ck870 FIND v(dout0_133) AT=440.025n

.meas tran vdout0_134ck870 FIND v(dout0_134) AT=440.025n

.meas tran vdout0_135ck870 FIND v(dout0_135) AT=440.025n

.meas tran vdout0_136ck870 FIND v(dout0_136) AT=440.025n

.meas tran vdout0_137ck870 FIND v(dout0_137) AT=440.025n

.meas tran vdout0_138ck870 FIND v(dout0_138) AT=440.025n

.meas tran vdout0_139ck870 FIND v(dout0_139) AT=440.025n

.meas tran vdout0_140ck870 FIND v(dout0_140) AT=440.025n

.meas tran vdout0_141ck870 FIND v(dout0_141) AT=440.025n

.meas tran vdout0_142ck870 FIND v(dout0_142) AT=440.025n

.meas tran vdout0_143ck870 FIND v(dout0_143) AT=440.025n

.meas tran vdout0_144ck870 FIND v(dout0_144) AT=440.025n

.meas tran vdout0_145ck870 FIND v(dout0_145) AT=440.025n

.meas tran vdout0_146ck870 FIND v(dout0_146) AT=440.025n

.meas tran vdout0_147ck870 FIND v(dout0_147) AT=440.025n

.meas tran vdout0_148ck870 FIND v(dout0_148) AT=440.025n

.meas tran vdout0_149ck870 FIND v(dout0_149) AT=440.025n

.meas tran vdout0_0ck900 FIND v(dout0_0) AT=455.025n

.meas tran vdout0_1ck900 FIND v(dout0_1) AT=455.025n

.meas tran vdout0_2ck900 FIND v(dout0_2) AT=455.025n

.meas tran vdout0_3ck900 FIND v(dout0_3) AT=455.025n

.meas tran vdout0_4ck900 FIND v(dout0_4) AT=455.025n

.meas tran vdout0_5ck900 FIND v(dout0_5) AT=455.025n

.meas tran vdout0_6ck900 FIND v(dout0_6) AT=455.025n

.meas tran vdout0_7ck900 FIND v(dout0_7) AT=455.025n

.meas tran vdout0_8ck900 FIND v(dout0_8) AT=455.025n

.meas tran vdout0_9ck900 FIND v(dout0_9) AT=455.025n

.meas tran vdout0_10ck900 FIND v(dout0_10) AT=455.025n

.meas tran vdout0_11ck900 FIND v(dout0_11) AT=455.025n

.meas tran vdout0_12ck900 FIND v(dout0_12) AT=455.025n

.meas tran vdout0_13ck900 FIND v(dout0_13) AT=455.025n

.meas tran vdout0_14ck900 FIND v(dout0_14) AT=455.025n

.meas tran vdout0_15ck900 FIND v(dout0_15) AT=455.025n

.meas tran vdout0_16ck900 FIND v(dout0_16) AT=455.025n

.meas tran vdout0_17ck900 FIND v(dout0_17) AT=455.025n

.meas tran vdout0_18ck900 FIND v(dout0_18) AT=455.025n

.meas tran vdout0_19ck900 FIND v(dout0_19) AT=455.025n

.meas tran vdout0_20ck900 FIND v(dout0_20) AT=455.025n

.meas tran vdout0_21ck900 FIND v(dout0_21) AT=455.025n

.meas tran vdout0_22ck900 FIND v(dout0_22) AT=455.025n

.meas tran vdout0_23ck900 FIND v(dout0_23) AT=455.025n

.meas tran vdout0_24ck900 FIND v(dout0_24) AT=455.025n

.meas tran vdout0_25ck900 FIND v(dout0_25) AT=455.025n

.meas tran vdout0_26ck900 FIND v(dout0_26) AT=455.025n

.meas tran vdout0_27ck900 FIND v(dout0_27) AT=455.025n

.meas tran vdout0_28ck900 FIND v(dout0_28) AT=455.025n

.meas tran vdout0_29ck900 FIND v(dout0_29) AT=455.025n

.meas tran vdout0_30ck900 FIND v(dout0_30) AT=455.025n

.meas tran vdout0_31ck900 FIND v(dout0_31) AT=455.025n

.meas tran vdout0_32ck900 FIND v(dout0_32) AT=455.025n

.meas tran vdout0_33ck900 FIND v(dout0_33) AT=455.025n

.meas tran vdout0_34ck900 FIND v(dout0_34) AT=455.025n

.meas tran vdout0_35ck900 FIND v(dout0_35) AT=455.025n

.meas tran vdout0_36ck900 FIND v(dout0_36) AT=455.025n

.meas tran vdout0_37ck900 FIND v(dout0_37) AT=455.025n

.meas tran vdout0_38ck900 FIND v(dout0_38) AT=455.025n

.meas tran vdout0_39ck900 FIND v(dout0_39) AT=455.025n

.meas tran vdout0_40ck900 FIND v(dout0_40) AT=455.025n

.meas tran vdout0_41ck900 FIND v(dout0_41) AT=455.025n

.meas tran vdout0_42ck900 FIND v(dout0_42) AT=455.025n

.meas tran vdout0_43ck900 FIND v(dout0_43) AT=455.025n

.meas tran vdout0_44ck900 FIND v(dout0_44) AT=455.025n

.meas tran vdout0_45ck900 FIND v(dout0_45) AT=455.025n

.meas tran vdout0_46ck900 FIND v(dout0_46) AT=455.025n

.meas tran vdout0_47ck900 FIND v(dout0_47) AT=455.025n

.meas tran vdout0_48ck900 FIND v(dout0_48) AT=455.025n

.meas tran vdout0_49ck900 FIND v(dout0_49) AT=455.025n

.meas tran vdout0_50ck900 FIND v(dout0_50) AT=455.025n

.meas tran vdout0_51ck900 FIND v(dout0_51) AT=455.025n

.meas tran vdout0_52ck900 FIND v(dout0_52) AT=455.025n

.meas tran vdout0_53ck900 FIND v(dout0_53) AT=455.025n

.meas tran vdout0_54ck900 FIND v(dout0_54) AT=455.025n

.meas tran vdout0_55ck900 FIND v(dout0_55) AT=455.025n

.meas tran vdout0_56ck900 FIND v(dout0_56) AT=455.025n

.meas tran vdout0_57ck900 FIND v(dout0_57) AT=455.025n

.meas tran vdout0_58ck900 FIND v(dout0_58) AT=455.025n

.meas tran vdout0_59ck900 FIND v(dout0_59) AT=455.025n

.meas tran vdout0_60ck900 FIND v(dout0_60) AT=455.025n

.meas tran vdout0_61ck900 FIND v(dout0_61) AT=455.025n

.meas tran vdout0_62ck900 FIND v(dout0_62) AT=455.025n

.meas tran vdout0_63ck900 FIND v(dout0_63) AT=455.025n

.meas tran vdout0_64ck900 FIND v(dout0_64) AT=455.025n

.meas tran vdout0_65ck900 FIND v(dout0_65) AT=455.025n

.meas tran vdout0_66ck900 FIND v(dout0_66) AT=455.025n

.meas tran vdout0_67ck900 FIND v(dout0_67) AT=455.025n

.meas tran vdout0_68ck900 FIND v(dout0_68) AT=455.025n

.meas tran vdout0_69ck900 FIND v(dout0_69) AT=455.025n

.meas tran vdout0_70ck900 FIND v(dout0_70) AT=455.025n

.meas tran vdout0_71ck900 FIND v(dout0_71) AT=455.025n

.meas tran vdout0_72ck900 FIND v(dout0_72) AT=455.025n

.meas tran vdout0_73ck900 FIND v(dout0_73) AT=455.025n

.meas tran vdout0_74ck900 FIND v(dout0_74) AT=455.025n

.meas tran vdout0_75ck900 FIND v(dout0_75) AT=455.025n

.meas tran vdout0_76ck900 FIND v(dout0_76) AT=455.025n

.meas tran vdout0_77ck900 FIND v(dout0_77) AT=455.025n

.meas tran vdout0_78ck900 FIND v(dout0_78) AT=455.025n

.meas tran vdout0_79ck900 FIND v(dout0_79) AT=455.025n

.meas tran vdout0_80ck900 FIND v(dout0_80) AT=455.025n

.meas tran vdout0_81ck900 FIND v(dout0_81) AT=455.025n

.meas tran vdout0_82ck900 FIND v(dout0_82) AT=455.025n

.meas tran vdout0_83ck900 FIND v(dout0_83) AT=455.025n

.meas tran vdout0_84ck900 FIND v(dout0_84) AT=455.025n

.meas tran vdout0_85ck900 FIND v(dout0_85) AT=455.025n

.meas tran vdout0_86ck900 FIND v(dout0_86) AT=455.025n

.meas tran vdout0_87ck900 FIND v(dout0_87) AT=455.025n

.meas tran vdout0_88ck900 FIND v(dout0_88) AT=455.025n

.meas tran vdout0_89ck900 FIND v(dout0_89) AT=455.025n

.meas tran vdout0_90ck900 FIND v(dout0_90) AT=455.025n

.meas tran vdout0_91ck900 FIND v(dout0_91) AT=455.025n

.meas tran vdout0_92ck900 FIND v(dout0_92) AT=455.025n

.meas tran vdout0_93ck900 FIND v(dout0_93) AT=455.025n

.meas tran vdout0_94ck900 FIND v(dout0_94) AT=455.025n

.meas tran vdout0_95ck900 FIND v(dout0_95) AT=455.025n

.meas tran vdout0_96ck900 FIND v(dout0_96) AT=455.025n

.meas tran vdout0_97ck900 FIND v(dout0_97) AT=455.025n

.meas tran vdout0_98ck900 FIND v(dout0_98) AT=455.025n

.meas tran vdout0_99ck900 FIND v(dout0_99) AT=455.025n

.meas tran vdout0_100ck900 FIND v(dout0_100) AT=455.025n

.meas tran vdout0_101ck900 FIND v(dout0_101) AT=455.025n

.meas tran vdout0_102ck900 FIND v(dout0_102) AT=455.025n

.meas tran vdout0_103ck900 FIND v(dout0_103) AT=455.025n

.meas tran vdout0_104ck900 FIND v(dout0_104) AT=455.025n

.meas tran vdout0_105ck900 FIND v(dout0_105) AT=455.025n

.meas tran vdout0_106ck900 FIND v(dout0_106) AT=455.025n

.meas tran vdout0_107ck900 FIND v(dout0_107) AT=455.025n

.meas tran vdout0_108ck900 FIND v(dout0_108) AT=455.025n

.meas tran vdout0_109ck900 FIND v(dout0_109) AT=455.025n

.meas tran vdout0_110ck900 FIND v(dout0_110) AT=455.025n

.meas tran vdout0_111ck900 FIND v(dout0_111) AT=455.025n

.meas tran vdout0_112ck900 FIND v(dout0_112) AT=455.025n

.meas tran vdout0_113ck900 FIND v(dout0_113) AT=455.025n

.meas tran vdout0_114ck900 FIND v(dout0_114) AT=455.025n

.meas tran vdout0_115ck900 FIND v(dout0_115) AT=455.025n

.meas tran vdout0_116ck900 FIND v(dout0_116) AT=455.025n

.meas tran vdout0_117ck900 FIND v(dout0_117) AT=455.025n

.meas tran vdout0_118ck900 FIND v(dout0_118) AT=455.025n

.meas tran vdout0_119ck900 FIND v(dout0_119) AT=455.025n

.meas tran vdout0_120ck900 FIND v(dout0_120) AT=455.025n

.meas tran vdout0_121ck900 FIND v(dout0_121) AT=455.025n

.meas tran vdout0_122ck900 FIND v(dout0_122) AT=455.025n

.meas tran vdout0_123ck900 FIND v(dout0_123) AT=455.025n

.meas tran vdout0_124ck900 FIND v(dout0_124) AT=455.025n

.meas tran vdout0_125ck900 FIND v(dout0_125) AT=455.025n

.meas tran vdout0_126ck900 FIND v(dout0_126) AT=455.025n

.meas tran vdout0_127ck900 FIND v(dout0_127) AT=455.025n

.meas tran vdout0_128ck900 FIND v(dout0_128) AT=455.025n

.meas tran vdout0_129ck900 FIND v(dout0_129) AT=455.025n

.meas tran vdout0_130ck900 FIND v(dout0_130) AT=455.025n

.meas tran vdout0_131ck900 FIND v(dout0_131) AT=455.025n

.meas tran vdout0_132ck900 FIND v(dout0_132) AT=455.025n

.meas tran vdout0_133ck900 FIND v(dout0_133) AT=455.025n

.meas tran vdout0_134ck900 FIND v(dout0_134) AT=455.025n

.meas tran vdout0_135ck900 FIND v(dout0_135) AT=455.025n

.meas tran vdout0_136ck900 FIND v(dout0_136) AT=455.025n

.meas tran vdout0_137ck900 FIND v(dout0_137) AT=455.025n

.meas tran vdout0_138ck900 FIND v(dout0_138) AT=455.025n

.meas tran vdout0_139ck900 FIND v(dout0_139) AT=455.025n

.meas tran vdout0_140ck900 FIND v(dout0_140) AT=455.025n

.meas tran vdout0_141ck900 FIND v(dout0_141) AT=455.025n

.meas tran vdout0_142ck900 FIND v(dout0_142) AT=455.025n

.meas tran vdout0_143ck900 FIND v(dout0_143) AT=455.025n

.meas tran vdout0_144ck900 FIND v(dout0_144) AT=455.025n

.meas tran vdout0_145ck900 FIND v(dout0_145) AT=455.025n

.meas tran vdout0_146ck900 FIND v(dout0_146) AT=455.025n

.meas tran vdout0_147ck900 FIND v(dout0_147) AT=455.025n

.meas tran vdout0_148ck900 FIND v(dout0_148) AT=455.025n

.meas tran vdout0_149ck900 FIND v(dout0_149) AT=455.025n

.meas tran vdout0_0ck920 FIND v(dout0_0) AT=465.025n

.meas tran vdout0_1ck920 FIND v(dout0_1) AT=465.025n

.meas tran vdout0_2ck920 FIND v(dout0_2) AT=465.025n

.meas tran vdout0_3ck920 FIND v(dout0_3) AT=465.025n

.meas tran vdout0_4ck920 FIND v(dout0_4) AT=465.025n

.meas tran vdout0_5ck920 FIND v(dout0_5) AT=465.025n

.meas tran vdout0_6ck920 FIND v(dout0_6) AT=465.025n

.meas tran vdout0_7ck920 FIND v(dout0_7) AT=465.025n

.meas tran vdout0_8ck920 FIND v(dout0_8) AT=465.025n

.meas tran vdout0_9ck920 FIND v(dout0_9) AT=465.025n

.meas tran vdout0_10ck920 FIND v(dout0_10) AT=465.025n

.meas tran vdout0_11ck920 FIND v(dout0_11) AT=465.025n

.meas tran vdout0_12ck920 FIND v(dout0_12) AT=465.025n

.meas tran vdout0_13ck920 FIND v(dout0_13) AT=465.025n

.meas tran vdout0_14ck920 FIND v(dout0_14) AT=465.025n

.meas tran vdout0_15ck920 FIND v(dout0_15) AT=465.025n

.meas tran vdout0_16ck920 FIND v(dout0_16) AT=465.025n

.meas tran vdout0_17ck920 FIND v(dout0_17) AT=465.025n

.meas tran vdout0_18ck920 FIND v(dout0_18) AT=465.025n

.meas tran vdout0_19ck920 FIND v(dout0_19) AT=465.025n

.meas tran vdout0_20ck920 FIND v(dout0_20) AT=465.025n

.meas tran vdout0_21ck920 FIND v(dout0_21) AT=465.025n

.meas tran vdout0_22ck920 FIND v(dout0_22) AT=465.025n

.meas tran vdout0_23ck920 FIND v(dout0_23) AT=465.025n

.meas tran vdout0_24ck920 FIND v(dout0_24) AT=465.025n

.meas tran vdout0_25ck920 FIND v(dout0_25) AT=465.025n

.meas tran vdout0_26ck920 FIND v(dout0_26) AT=465.025n

.meas tran vdout0_27ck920 FIND v(dout0_27) AT=465.025n

.meas tran vdout0_28ck920 FIND v(dout0_28) AT=465.025n

.meas tran vdout0_29ck920 FIND v(dout0_29) AT=465.025n

.meas tran vdout0_30ck920 FIND v(dout0_30) AT=465.025n

.meas tran vdout0_31ck920 FIND v(dout0_31) AT=465.025n

.meas tran vdout0_32ck920 FIND v(dout0_32) AT=465.025n

.meas tran vdout0_33ck920 FIND v(dout0_33) AT=465.025n

.meas tran vdout0_34ck920 FIND v(dout0_34) AT=465.025n

.meas tran vdout0_35ck920 FIND v(dout0_35) AT=465.025n

.meas tran vdout0_36ck920 FIND v(dout0_36) AT=465.025n

.meas tran vdout0_37ck920 FIND v(dout0_37) AT=465.025n

.meas tran vdout0_38ck920 FIND v(dout0_38) AT=465.025n

.meas tran vdout0_39ck920 FIND v(dout0_39) AT=465.025n

.meas tran vdout0_40ck920 FIND v(dout0_40) AT=465.025n

.meas tran vdout0_41ck920 FIND v(dout0_41) AT=465.025n

.meas tran vdout0_42ck920 FIND v(dout0_42) AT=465.025n

.meas tran vdout0_43ck920 FIND v(dout0_43) AT=465.025n

.meas tran vdout0_44ck920 FIND v(dout0_44) AT=465.025n

.meas tran vdout0_45ck920 FIND v(dout0_45) AT=465.025n

.meas tran vdout0_46ck920 FIND v(dout0_46) AT=465.025n

.meas tran vdout0_47ck920 FIND v(dout0_47) AT=465.025n

.meas tran vdout0_48ck920 FIND v(dout0_48) AT=465.025n

.meas tran vdout0_49ck920 FIND v(dout0_49) AT=465.025n

.meas tran vdout0_50ck920 FIND v(dout0_50) AT=465.025n

.meas tran vdout0_51ck920 FIND v(dout0_51) AT=465.025n

.meas tran vdout0_52ck920 FIND v(dout0_52) AT=465.025n

.meas tran vdout0_53ck920 FIND v(dout0_53) AT=465.025n

.meas tran vdout0_54ck920 FIND v(dout0_54) AT=465.025n

.meas tran vdout0_55ck920 FIND v(dout0_55) AT=465.025n

.meas tran vdout0_56ck920 FIND v(dout0_56) AT=465.025n

.meas tran vdout0_57ck920 FIND v(dout0_57) AT=465.025n

.meas tran vdout0_58ck920 FIND v(dout0_58) AT=465.025n

.meas tran vdout0_59ck920 FIND v(dout0_59) AT=465.025n

.meas tran vdout0_60ck920 FIND v(dout0_60) AT=465.025n

.meas tran vdout0_61ck920 FIND v(dout0_61) AT=465.025n

.meas tran vdout0_62ck920 FIND v(dout0_62) AT=465.025n

.meas tran vdout0_63ck920 FIND v(dout0_63) AT=465.025n

.meas tran vdout0_64ck920 FIND v(dout0_64) AT=465.025n

.meas tran vdout0_65ck920 FIND v(dout0_65) AT=465.025n

.meas tran vdout0_66ck920 FIND v(dout0_66) AT=465.025n

.meas tran vdout0_67ck920 FIND v(dout0_67) AT=465.025n

.meas tran vdout0_68ck920 FIND v(dout0_68) AT=465.025n

.meas tran vdout0_69ck920 FIND v(dout0_69) AT=465.025n

.meas tran vdout0_70ck920 FIND v(dout0_70) AT=465.025n

.meas tran vdout0_71ck920 FIND v(dout0_71) AT=465.025n

.meas tran vdout0_72ck920 FIND v(dout0_72) AT=465.025n

.meas tran vdout0_73ck920 FIND v(dout0_73) AT=465.025n

.meas tran vdout0_74ck920 FIND v(dout0_74) AT=465.025n

.meas tran vdout0_75ck920 FIND v(dout0_75) AT=465.025n

.meas tran vdout0_76ck920 FIND v(dout0_76) AT=465.025n

.meas tran vdout0_77ck920 FIND v(dout0_77) AT=465.025n

.meas tran vdout0_78ck920 FIND v(dout0_78) AT=465.025n

.meas tran vdout0_79ck920 FIND v(dout0_79) AT=465.025n

.meas tran vdout0_80ck920 FIND v(dout0_80) AT=465.025n

.meas tran vdout0_81ck920 FIND v(dout0_81) AT=465.025n

.meas tran vdout0_82ck920 FIND v(dout0_82) AT=465.025n

.meas tran vdout0_83ck920 FIND v(dout0_83) AT=465.025n

.meas tran vdout0_84ck920 FIND v(dout0_84) AT=465.025n

.meas tran vdout0_85ck920 FIND v(dout0_85) AT=465.025n

.meas tran vdout0_86ck920 FIND v(dout0_86) AT=465.025n

.meas tran vdout0_87ck920 FIND v(dout0_87) AT=465.025n

.meas tran vdout0_88ck920 FIND v(dout0_88) AT=465.025n

.meas tran vdout0_89ck920 FIND v(dout0_89) AT=465.025n

.meas tran vdout0_90ck920 FIND v(dout0_90) AT=465.025n

.meas tran vdout0_91ck920 FIND v(dout0_91) AT=465.025n

.meas tran vdout0_92ck920 FIND v(dout0_92) AT=465.025n

.meas tran vdout0_93ck920 FIND v(dout0_93) AT=465.025n

.meas tran vdout0_94ck920 FIND v(dout0_94) AT=465.025n

.meas tran vdout0_95ck920 FIND v(dout0_95) AT=465.025n

.meas tran vdout0_96ck920 FIND v(dout0_96) AT=465.025n

.meas tran vdout0_97ck920 FIND v(dout0_97) AT=465.025n

.meas tran vdout0_98ck920 FIND v(dout0_98) AT=465.025n

.meas tran vdout0_99ck920 FIND v(dout0_99) AT=465.025n

.meas tran vdout0_100ck920 FIND v(dout0_100) AT=465.025n

.meas tran vdout0_101ck920 FIND v(dout0_101) AT=465.025n

.meas tran vdout0_102ck920 FIND v(dout0_102) AT=465.025n

.meas tran vdout0_103ck920 FIND v(dout0_103) AT=465.025n

.meas tran vdout0_104ck920 FIND v(dout0_104) AT=465.025n

.meas tran vdout0_105ck920 FIND v(dout0_105) AT=465.025n

.meas tran vdout0_106ck920 FIND v(dout0_106) AT=465.025n

.meas tran vdout0_107ck920 FIND v(dout0_107) AT=465.025n

.meas tran vdout0_108ck920 FIND v(dout0_108) AT=465.025n

.meas tran vdout0_109ck920 FIND v(dout0_109) AT=465.025n

.meas tran vdout0_110ck920 FIND v(dout0_110) AT=465.025n

.meas tran vdout0_111ck920 FIND v(dout0_111) AT=465.025n

.meas tran vdout0_112ck920 FIND v(dout0_112) AT=465.025n

.meas tran vdout0_113ck920 FIND v(dout0_113) AT=465.025n

.meas tran vdout0_114ck920 FIND v(dout0_114) AT=465.025n

.meas tran vdout0_115ck920 FIND v(dout0_115) AT=465.025n

.meas tran vdout0_116ck920 FIND v(dout0_116) AT=465.025n

.meas tran vdout0_117ck920 FIND v(dout0_117) AT=465.025n

.meas tran vdout0_118ck920 FIND v(dout0_118) AT=465.025n

.meas tran vdout0_119ck920 FIND v(dout0_119) AT=465.025n

.meas tran vdout0_120ck920 FIND v(dout0_120) AT=465.025n

.meas tran vdout0_121ck920 FIND v(dout0_121) AT=465.025n

.meas tran vdout0_122ck920 FIND v(dout0_122) AT=465.025n

.meas tran vdout0_123ck920 FIND v(dout0_123) AT=465.025n

.meas tran vdout0_124ck920 FIND v(dout0_124) AT=465.025n

.meas tran vdout0_125ck920 FIND v(dout0_125) AT=465.025n

.meas tran vdout0_126ck920 FIND v(dout0_126) AT=465.025n

.meas tran vdout0_127ck920 FIND v(dout0_127) AT=465.025n

.meas tran vdout0_128ck920 FIND v(dout0_128) AT=465.025n

.meas tran vdout0_129ck920 FIND v(dout0_129) AT=465.025n

.meas tran vdout0_130ck920 FIND v(dout0_130) AT=465.025n

.meas tran vdout0_131ck920 FIND v(dout0_131) AT=465.025n

.meas tran vdout0_132ck920 FIND v(dout0_132) AT=465.025n

.meas tran vdout0_133ck920 FIND v(dout0_133) AT=465.025n

.meas tran vdout0_134ck920 FIND v(dout0_134) AT=465.025n

.meas tran vdout0_135ck920 FIND v(dout0_135) AT=465.025n

.meas tran vdout0_136ck920 FIND v(dout0_136) AT=465.025n

.meas tran vdout0_137ck920 FIND v(dout0_137) AT=465.025n

.meas tran vdout0_138ck920 FIND v(dout0_138) AT=465.025n

.meas tran vdout0_139ck920 FIND v(dout0_139) AT=465.025n

.meas tran vdout0_140ck920 FIND v(dout0_140) AT=465.025n

.meas tran vdout0_141ck920 FIND v(dout0_141) AT=465.025n

.meas tran vdout0_142ck920 FIND v(dout0_142) AT=465.025n

.meas tran vdout0_143ck920 FIND v(dout0_143) AT=465.025n

.meas tran vdout0_144ck920 FIND v(dout0_144) AT=465.025n

.meas tran vdout0_145ck920 FIND v(dout0_145) AT=465.025n

.meas tran vdout0_146ck920 FIND v(dout0_146) AT=465.025n

.meas tran vdout0_147ck920 FIND v(dout0_147) AT=465.025n

.meas tran vdout0_148ck920 FIND v(dout0_148) AT=465.025n

.meas tran vdout0_149ck920 FIND v(dout0_149) AT=465.025n

.meas tran vdout0_0ck940 FIND v(dout0_0) AT=475.025n

.meas tran vdout0_1ck940 FIND v(dout0_1) AT=475.025n

.meas tran vdout0_2ck940 FIND v(dout0_2) AT=475.025n

.meas tran vdout0_3ck940 FIND v(dout0_3) AT=475.025n

.meas tran vdout0_4ck940 FIND v(dout0_4) AT=475.025n

.meas tran vdout0_5ck940 FIND v(dout0_5) AT=475.025n

.meas tran vdout0_6ck940 FIND v(dout0_6) AT=475.025n

.meas tran vdout0_7ck940 FIND v(dout0_7) AT=475.025n

.meas tran vdout0_8ck940 FIND v(dout0_8) AT=475.025n

.meas tran vdout0_9ck940 FIND v(dout0_9) AT=475.025n

.meas tran vdout0_10ck940 FIND v(dout0_10) AT=475.025n

.meas tran vdout0_11ck940 FIND v(dout0_11) AT=475.025n

.meas tran vdout0_12ck940 FIND v(dout0_12) AT=475.025n

.meas tran vdout0_13ck940 FIND v(dout0_13) AT=475.025n

.meas tran vdout0_14ck940 FIND v(dout0_14) AT=475.025n

.meas tran vdout0_15ck940 FIND v(dout0_15) AT=475.025n

.meas tran vdout0_16ck940 FIND v(dout0_16) AT=475.025n

.meas tran vdout0_17ck940 FIND v(dout0_17) AT=475.025n

.meas tran vdout0_18ck940 FIND v(dout0_18) AT=475.025n

.meas tran vdout0_19ck940 FIND v(dout0_19) AT=475.025n

.meas tran vdout0_20ck940 FIND v(dout0_20) AT=475.025n

.meas tran vdout0_21ck940 FIND v(dout0_21) AT=475.025n

.meas tran vdout0_22ck940 FIND v(dout0_22) AT=475.025n

.meas tran vdout0_23ck940 FIND v(dout0_23) AT=475.025n

.meas tran vdout0_24ck940 FIND v(dout0_24) AT=475.025n

.meas tran vdout0_25ck940 FIND v(dout0_25) AT=475.025n

.meas tran vdout0_26ck940 FIND v(dout0_26) AT=475.025n

.meas tran vdout0_27ck940 FIND v(dout0_27) AT=475.025n

.meas tran vdout0_28ck940 FIND v(dout0_28) AT=475.025n

.meas tran vdout0_29ck940 FIND v(dout0_29) AT=475.025n

.meas tran vdout0_30ck940 FIND v(dout0_30) AT=475.025n

.meas tran vdout0_31ck940 FIND v(dout0_31) AT=475.025n

.meas tran vdout0_32ck940 FIND v(dout0_32) AT=475.025n

.meas tran vdout0_33ck940 FIND v(dout0_33) AT=475.025n

.meas tran vdout0_34ck940 FIND v(dout0_34) AT=475.025n

.meas tran vdout0_35ck940 FIND v(dout0_35) AT=475.025n

.meas tran vdout0_36ck940 FIND v(dout0_36) AT=475.025n

.meas tran vdout0_37ck940 FIND v(dout0_37) AT=475.025n

.meas tran vdout0_38ck940 FIND v(dout0_38) AT=475.025n

.meas tran vdout0_39ck940 FIND v(dout0_39) AT=475.025n

.meas tran vdout0_40ck940 FIND v(dout0_40) AT=475.025n

.meas tran vdout0_41ck940 FIND v(dout0_41) AT=475.025n

.meas tran vdout0_42ck940 FIND v(dout0_42) AT=475.025n

.meas tran vdout0_43ck940 FIND v(dout0_43) AT=475.025n

.meas tran vdout0_44ck940 FIND v(dout0_44) AT=475.025n

.meas tran vdout0_45ck940 FIND v(dout0_45) AT=475.025n

.meas tran vdout0_46ck940 FIND v(dout0_46) AT=475.025n

.meas tran vdout0_47ck940 FIND v(dout0_47) AT=475.025n

.meas tran vdout0_48ck940 FIND v(dout0_48) AT=475.025n

.meas tran vdout0_49ck940 FIND v(dout0_49) AT=475.025n

.meas tran vdout0_50ck940 FIND v(dout0_50) AT=475.025n

.meas tran vdout0_51ck940 FIND v(dout0_51) AT=475.025n

.meas tran vdout0_52ck940 FIND v(dout0_52) AT=475.025n

.meas tran vdout0_53ck940 FIND v(dout0_53) AT=475.025n

.meas tran vdout0_54ck940 FIND v(dout0_54) AT=475.025n

.meas tran vdout0_55ck940 FIND v(dout0_55) AT=475.025n

.meas tran vdout0_56ck940 FIND v(dout0_56) AT=475.025n

.meas tran vdout0_57ck940 FIND v(dout0_57) AT=475.025n

.meas tran vdout0_58ck940 FIND v(dout0_58) AT=475.025n

.meas tran vdout0_59ck940 FIND v(dout0_59) AT=475.025n

.meas tran vdout0_60ck940 FIND v(dout0_60) AT=475.025n

.meas tran vdout0_61ck940 FIND v(dout0_61) AT=475.025n

.meas tran vdout0_62ck940 FIND v(dout0_62) AT=475.025n

.meas tran vdout0_63ck940 FIND v(dout0_63) AT=475.025n

.meas tran vdout0_64ck940 FIND v(dout0_64) AT=475.025n

.meas tran vdout0_65ck940 FIND v(dout0_65) AT=475.025n

.meas tran vdout0_66ck940 FIND v(dout0_66) AT=475.025n

.meas tran vdout0_67ck940 FIND v(dout0_67) AT=475.025n

.meas tran vdout0_68ck940 FIND v(dout0_68) AT=475.025n

.meas tran vdout0_69ck940 FIND v(dout0_69) AT=475.025n

.meas tran vdout0_70ck940 FIND v(dout0_70) AT=475.025n

.meas tran vdout0_71ck940 FIND v(dout0_71) AT=475.025n

.meas tran vdout0_72ck940 FIND v(dout0_72) AT=475.025n

.meas tran vdout0_73ck940 FIND v(dout0_73) AT=475.025n

.meas tran vdout0_74ck940 FIND v(dout0_74) AT=475.025n

.meas tran vdout0_75ck940 FIND v(dout0_75) AT=475.025n

.meas tran vdout0_76ck940 FIND v(dout0_76) AT=475.025n

.meas tran vdout0_77ck940 FIND v(dout0_77) AT=475.025n

.meas tran vdout0_78ck940 FIND v(dout0_78) AT=475.025n

.meas tran vdout0_79ck940 FIND v(dout0_79) AT=475.025n

.meas tran vdout0_80ck940 FIND v(dout0_80) AT=475.025n

.meas tran vdout0_81ck940 FIND v(dout0_81) AT=475.025n

.meas tran vdout0_82ck940 FIND v(dout0_82) AT=475.025n

.meas tran vdout0_83ck940 FIND v(dout0_83) AT=475.025n

.meas tran vdout0_84ck940 FIND v(dout0_84) AT=475.025n

.meas tran vdout0_85ck940 FIND v(dout0_85) AT=475.025n

.meas tran vdout0_86ck940 FIND v(dout0_86) AT=475.025n

.meas tran vdout0_87ck940 FIND v(dout0_87) AT=475.025n

.meas tran vdout0_88ck940 FIND v(dout0_88) AT=475.025n

.meas tran vdout0_89ck940 FIND v(dout0_89) AT=475.025n

.meas tran vdout0_90ck940 FIND v(dout0_90) AT=475.025n

.meas tran vdout0_91ck940 FIND v(dout0_91) AT=475.025n

.meas tran vdout0_92ck940 FIND v(dout0_92) AT=475.025n

.meas tran vdout0_93ck940 FIND v(dout0_93) AT=475.025n

.meas tran vdout0_94ck940 FIND v(dout0_94) AT=475.025n

.meas tran vdout0_95ck940 FIND v(dout0_95) AT=475.025n

.meas tran vdout0_96ck940 FIND v(dout0_96) AT=475.025n

.meas tran vdout0_97ck940 FIND v(dout0_97) AT=475.025n

.meas tran vdout0_98ck940 FIND v(dout0_98) AT=475.025n

.meas tran vdout0_99ck940 FIND v(dout0_99) AT=475.025n

.meas tran vdout0_100ck940 FIND v(dout0_100) AT=475.025n

.meas tran vdout0_101ck940 FIND v(dout0_101) AT=475.025n

.meas tran vdout0_102ck940 FIND v(dout0_102) AT=475.025n

.meas tran vdout0_103ck940 FIND v(dout0_103) AT=475.025n

.meas tran vdout0_104ck940 FIND v(dout0_104) AT=475.025n

.meas tran vdout0_105ck940 FIND v(dout0_105) AT=475.025n

.meas tran vdout0_106ck940 FIND v(dout0_106) AT=475.025n

.meas tran vdout0_107ck940 FIND v(dout0_107) AT=475.025n

.meas tran vdout0_108ck940 FIND v(dout0_108) AT=475.025n

.meas tran vdout0_109ck940 FIND v(dout0_109) AT=475.025n

.meas tran vdout0_110ck940 FIND v(dout0_110) AT=475.025n

.meas tran vdout0_111ck940 FIND v(dout0_111) AT=475.025n

.meas tran vdout0_112ck940 FIND v(dout0_112) AT=475.025n

.meas tran vdout0_113ck940 FIND v(dout0_113) AT=475.025n

.meas tran vdout0_114ck940 FIND v(dout0_114) AT=475.025n

.meas tran vdout0_115ck940 FIND v(dout0_115) AT=475.025n

.meas tran vdout0_116ck940 FIND v(dout0_116) AT=475.025n

.meas tran vdout0_117ck940 FIND v(dout0_117) AT=475.025n

.meas tran vdout0_118ck940 FIND v(dout0_118) AT=475.025n

.meas tran vdout0_119ck940 FIND v(dout0_119) AT=475.025n

.meas tran vdout0_120ck940 FIND v(dout0_120) AT=475.025n

.meas tran vdout0_121ck940 FIND v(dout0_121) AT=475.025n

.meas tran vdout0_122ck940 FIND v(dout0_122) AT=475.025n

.meas tran vdout0_123ck940 FIND v(dout0_123) AT=475.025n

.meas tran vdout0_124ck940 FIND v(dout0_124) AT=475.025n

.meas tran vdout0_125ck940 FIND v(dout0_125) AT=475.025n

.meas tran vdout0_126ck940 FIND v(dout0_126) AT=475.025n

.meas tran vdout0_127ck940 FIND v(dout0_127) AT=475.025n

.meas tran vdout0_128ck940 FIND v(dout0_128) AT=475.025n

.meas tran vdout0_129ck940 FIND v(dout0_129) AT=475.025n

.meas tran vdout0_130ck940 FIND v(dout0_130) AT=475.025n

.meas tran vdout0_131ck940 FIND v(dout0_131) AT=475.025n

.meas tran vdout0_132ck940 FIND v(dout0_132) AT=475.025n

.meas tran vdout0_133ck940 FIND v(dout0_133) AT=475.025n

.meas tran vdout0_134ck940 FIND v(dout0_134) AT=475.025n

.meas tran vdout0_135ck940 FIND v(dout0_135) AT=475.025n

.meas tran vdout0_136ck940 FIND v(dout0_136) AT=475.025n

.meas tran vdout0_137ck940 FIND v(dout0_137) AT=475.025n

.meas tran vdout0_138ck940 FIND v(dout0_138) AT=475.025n

.meas tran vdout0_139ck940 FIND v(dout0_139) AT=475.025n

.meas tran vdout0_140ck940 FIND v(dout0_140) AT=475.025n

.meas tran vdout0_141ck940 FIND v(dout0_141) AT=475.025n

.meas tran vdout0_142ck940 FIND v(dout0_142) AT=475.025n

.meas tran vdout0_143ck940 FIND v(dout0_143) AT=475.025n

.meas tran vdout0_144ck940 FIND v(dout0_144) AT=475.025n

.meas tran vdout0_145ck940 FIND v(dout0_145) AT=475.025n

.meas tran vdout0_146ck940 FIND v(dout0_146) AT=475.025n

.meas tran vdout0_147ck940 FIND v(dout0_147) AT=475.025n

.meas tran vdout0_148ck940 FIND v(dout0_148) AT=475.025n

.meas tran vdout0_149ck940 FIND v(dout0_149) AT=475.025n

.meas tran vdout0_0ck950 FIND v(dout0_0) AT=480.025n

.meas tran vdout0_1ck950 FIND v(dout0_1) AT=480.025n

.meas tran vdout0_2ck950 FIND v(dout0_2) AT=480.025n

.meas tran vdout0_3ck950 FIND v(dout0_3) AT=480.025n

.meas tran vdout0_4ck950 FIND v(dout0_4) AT=480.025n

.meas tran vdout0_5ck950 FIND v(dout0_5) AT=480.025n

.meas tran vdout0_6ck950 FIND v(dout0_6) AT=480.025n

.meas tran vdout0_7ck950 FIND v(dout0_7) AT=480.025n

.meas tran vdout0_8ck950 FIND v(dout0_8) AT=480.025n

.meas tran vdout0_9ck950 FIND v(dout0_9) AT=480.025n

.meas tran vdout0_10ck950 FIND v(dout0_10) AT=480.025n

.meas tran vdout0_11ck950 FIND v(dout0_11) AT=480.025n

.meas tran vdout0_12ck950 FIND v(dout0_12) AT=480.025n

.meas tran vdout0_13ck950 FIND v(dout0_13) AT=480.025n

.meas tran vdout0_14ck950 FIND v(dout0_14) AT=480.025n

.meas tran vdout0_15ck950 FIND v(dout0_15) AT=480.025n

.meas tran vdout0_16ck950 FIND v(dout0_16) AT=480.025n

.meas tran vdout0_17ck950 FIND v(dout0_17) AT=480.025n

.meas tran vdout0_18ck950 FIND v(dout0_18) AT=480.025n

.meas tran vdout0_19ck950 FIND v(dout0_19) AT=480.025n

.meas tran vdout0_20ck950 FIND v(dout0_20) AT=480.025n

.meas tran vdout0_21ck950 FIND v(dout0_21) AT=480.025n

.meas tran vdout0_22ck950 FIND v(dout0_22) AT=480.025n

.meas tran vdout0_23ck950 FIND v(dout0_23) AT=480.025n

.meas tran vdout0_24ck950 FIND v(dout0_24) AT=480.025n

.meas tran vdout0_25ck950 FIND v(dout0_25) AT=480.025n

.meas tran vdout0_26ck950 FIND v(dout0_26) AT=480.025n

.meas tran vdout0_27ck950 FIND v(dout0_27) AT=480.025n

.meas tran vdout0_28ck950 FIND v(dout0_28) AT=480.025n

.meas tran vdout0_29ck950 FIND v(dout0_29) AT=480.025n

.meas tran vdout0_30ck950 FIND v(dout0_30) AT=480.025n

.meas tran vdout0_31ck950 FIND v(dout0_31) AT=480.025n

.meas tran vdout0_32ck950 FIND v(dout0_32) AT=480.025n

.meas tran vdout0_33ck950 FIND v(dout0_33) AT=480.025n

.meas tran vdout0_34ck950 FIND v(dout0_34) AT=480.025n

.meas tran vdout0_35ck950 FIND v(dout0_35) AT=480.025n

.meas tran vdout0_36ck950 FIND v(dout0_36) AT=480.025n

.meas tran vdout0_37ck950 FIND v(dout0_37) AT=480.025n

.meas tran vdout0_38ck950 FIND v(dout0_38) AT=480.025n

.meas tran vdout0_39ck950 FIND v(dout0_39) AT=480.025n

.meas tran vdout0_40ck950 FIND v(dout0_40) AT=480.025n

.meas tran vdout0_41ck950 FIND v(dout0_41) AT=480.025n

.meas tran vdout0_42ck950 FIND v(dout0_42) AT=480.025n

.meas tran vdout0_43ck950 FIND v(dout0_43) AT=480.025n

.meas tran vdout0_44ck950 FIND v(dout0_44) AT=480.025n

.meas tran vdout0_45ck950 FIND v(dout0_45) AT=480.025n

.meas tran vdout0_46ck950 FIND v(dout0_46) AT=480.025n

.meas tran vdout0_47ck950 FIND v(dout0_47) AT=480.025n

.meas tran vdout0_48ck950 FIND v(dout0_48) AT=480.025n

.meas tran vdout0_49ck950 FIND v(dout0_49) AT=480.025n

.meas tran vdout0_50ck950 FIND v(dout0_50) AT=480.025n

.meas tran vdout0_51ck950 FIND v(dout0_51) AT=480.025n

.meas tran vdout0_52ck950 FIND v(dout0_52) AT=480.025n

.meas tran vdout0_53ck950 FIND v(dout0_53) AT=480.025n

.meas tran vdout0_54ck950 FIND v(dout0_54) AT=480.025n

.meas tran vdout0_55ck950 FIND v(dout0_55) AT=480.025n

.meas tran vdout0_56ck950 FIND v(dout0_56) AT=480.025n

.meas tran vdout0_57ck950 FIND v(dout0_57) AT=480.025n

.meas tran vdout0_58ck950 FIND v(dout0_58) AT=480.025n

.meas tran vdout0_59ck950 FIND v(dout0_59) AT=480.025n

.meas tran vdout0_60ck950 FIND v(dout0_60) AT=480.025n

.meas tran vdout0_61ck950 FIND v(dout0_61) AT=480.025n

.meas tran vdout0_62ck950 FIND v(dout0_62) AT=480.025n

.meas tran vdout0_63ck950 FIND v(dout0_63) AT=480.025n

.meas tran vdout0_64ck950 FIND v(dout0_64) AT=480.025n

.meas tran vdout0_65ck950 FIND v(dout0_65) AT=480.025n

.meas tran vdout0_66ck950 FIND v(dout0_66) AT=480.025n

.meas tran vdout0_67ck950 FIND v(dout0_67) AT=480.025n

.meas tran vdout0_68ck950 FIND v(dout0_68) AT=480.025n

.meas tran vdout0_69ck950 FIND v(dout0_69) AT=480.025n

.meas tran vdout0_70ck950 FIND v(dout0_70) AT=480.025n

.meas tran vdout0_71ck950 FIND v(dout0_71) AT=480.025n

.meas tran vdout0_72ck950 FIND v(dout0_72) AT=480.025n

.meas tran vdout0_73ck950 FIND v(dout0_73) AT=480.025n

.meas tran vdout0_74ck950 FIND v(dout0_74) AT=480.025n

.meas tran vdout0_75ck950 FIND v(dout0_75) AT=480.025n

.meas tran vdout0_76ck950 FIND v(dout0_76) AT=480.025n

.meas tran vdout0_77ck950 FIND v(dout0_77) AT=480.025n

.meas tran vdout0_78ck950 FIND v(dout0_78) AT=480.025n

.meas tran vdout0_79ck950 FIND v(dout0_79) AT=480.025n

.meas tran vdout0_80ck950 FIND v(dout0_80) AT=480.025n

.meas tran vdout0_81ck950 FIND v(dout0_81) AT=480.025n

.meas tran vdout0_82ck950 FIND v(dout0_82) AT=480.025n

.meas tran vdout0_83ck950 FIND v(dout0_83) AT=480.025n

.meas tran vdout0_84ck950 FIND v(dout0_84) AT=480.025n

.meas tran vdout0_85ck950 FIND v(dout0_85) AT=480.025n

.meas tran vdout0_86ck950 FIND v(dout0_86) AT=480.025n

.meas tran vdout0_87ck950 FIND v(dout0_87) AT=480.025n

.meas tran vdout0_88ck950 FIND v(dout0_88) AT=480.025n

.meas tran vdout0_89ck950 FIND v(dout0_89) AT=480.025n

.meas tran vdout0_90ck950 FIND v(dout0_90) AT=480.025n

.meas tran vdout0_91ck950 FIND v(dout0_91) AT=480.025n

.meas tran vdout0_92ck950 FIND v(dout0_92) AT=480.025n

.meas tran vdout0_93ck950 FIND v(dout0_93) AT=480.025n

.meas tran vdout0_94ck950 FIND v(dout0_94) AT=480.025n

.meas tran vdout0_95ck950 FIND v(dout0_95) AT=480.025n

.meas tran vdout0_96ck950 FIND v(dout0_96) AT=480.025n

.meas tran vdout0_97ck950 FIND v(dout0_97) AT=480.025n

.meas tran vdout0_98ck950 FIND v(dout0_98) AT=480.025n

.meas tran vdout0_99ck950 FIND v(dout0_99) AT=480.025n

.meas tran vdout0_100ck950 FIND v(dout0_100) AT=480.025n

.meas tran vdout0_101ck950 FIND v(dout0_101) AT=480.025n

.meas tran vdout0_102ck950 FIND v(dout0_102) AT=480.025n

.meas tran vdout0_103ck950 FIND v(dout0_103) AT=480.025n

.meas tran vdout0_104ck950 FIND v(dout0_104) AT=480.025n

.meas tran vdout0_105ck950 FIND v(dout0_105) AT=480.025n

.meas tran vdout0_106ck950 FIND v(dout0_106) AT=480.025n

.meas tran vdout0_107ck950 FIND v(dout0_107) AT=480.025n

.meas tran vdout0_108ck950 FIND v(dout0_108) AT=480.025n

.meas tran vdout0_109ck950 FIND v(dout0_109) AT=480.025n

.meas tran vdout0_110ck950 FIND v(dout0_110) AT=480.025n

.meas tran vdout0_111ck950 FIND v(dout0_111) AT=480.025n

.meas tran vdout0_112ck950 FIND v(dout0_112) AT=480.025n

.meas tran vdout0_113ck950 FIND v(dout0_113) AT=480.025n

.meas tran vdout0_114ck950 FIND v(dout0_114) AT=480.025n

.meas tran vdout0_115ck950 FIND v(dout0_115) AT=480.025n

.meas tran vdout0_116ck950 FIND v(dout0_116) AT=480.025n

.meas tran vdout0_117ck950 FIND v(dout0_117) AT=480.025n

.meas tran vdout0_118ck950 FIND v(dout0_118) AT=480.025n

.meas tran vdout0_119ck950 FIND v(dout0_119) AT=480.025n

.meas tran vdout0_120ck950 FIND v(dout0_120) AT=480.025n

.meas tran vdout0_121ck950 FIND v(dout0_121) AT=480.025n

.meas tran vdout0_122ck950 FIND v(dout0_122) AT=480.025n

.meas tran vdout0_123ck950 FIND v(dout0_123) AT=480.025n

.meas tran vdout0_124ck950 FIND v(dout0_124) AT=480.025n

.meas tran vdout0_125ck950 FIND v(dout0_125) AT=480.025n

.meas tran vdout0_126ck950 FIND v(dout0_126) AT=480.025n

.meas tran vdout0_127ck950 FIND v(dout0_127) AT=480.025n

.meas tran vdout0_128ck950 FIND v(dout0_128) AT=480.025n

.meas tran vdout0_129ck950 FIND v(dout0_129) AT=480.025n

.meas tran vdout0_130ck950 FIND v(dout0_130) AT=480.025n

.meas tran vdout0_131ck950 FIND v(dout0_131) AT=480.025n

.meas tran vdout0_132ck950 FIND v(dout0_132) AT=480.025n

.meas tran vdout0_133ck950 FIND v(dout0_133) AT=480.025n

.meas tran vdout0_134ck950 FIND v(dout0_134) AT=480.025n

.meas tran vdout0_135ck950 FIND v(dout0_135) AT=480.025n

.meas tran vdout0_136ck950 FIND v(dout0_136) AT=480.025n

.meas tran vdout0_137ck950 FIND v(dout0_137) AT=480.025n

.meas tran vdout0_138ck950 FIND v(dout0_138) AT=480.025n

.meas tran vdout0_139ck950 FIND v(dout0_139) AT=480.025n

.meas tran vdout0_140ck950 FIND v(dout0_140) AT=480.025n

.meas tran vdout0_141ck950 FIND v(dout0_141) AT=480.025n

.meas tran vdout0_142ck950 FIND v(dout0_142) AT=480.025n

.meas tran vdout0_143ck950 FIND v(dout0_143) AT=480.025n

.meas tran vdout0_144ck950 FIND v(dout0_144) AT=480.025n

.meas tran vdout0_145ck950 FIND v(dout0_145) AT=480.025n

.meas tran vdout0_146ck950 FIND v(dout0_146) AT=480.025n

.meas tran vdout0_147ck950 FIND v(dout0_147) AT=480.025n

.meas tran vdout0_148ck950 FIND v(dout0_148) AT=480.025n

.meas tran vdout0_149ck950 FIND v(dout0_149) AT=480.025n

.meas tran vdout0_0ck970 FIND v(dout0_0) AT=490.025n

.meas tran vdout0_1ck970 FIND v(dout0_1) AT=490.025n

.meas tran vdout0_2ck970 FIND v(dout0_2) AT=490.025n

.meas tran vdout0_3ck970 FIND v(dout0_3) AT=490.025n

.meas tran vdout0_4ck970 FIND v(dout0_4) AT=490.025n

.meas tran vdout0_5ck970 FIND v(dout0_5) AT=490.025n

.meas tran vdout0_6ck970 FIND v(dout0_6) AT=490.025n

.meas tran vdout0_7ck970 FIND v(dout0_7) AT=490.025n

.meas tran vdout0_8ck970 FIND v(dout0_8) AT=490.025n

.meas tran vdout0_9ck970 FIND v(dout0_9) AT=490.025n

.meas tran vdout0_10ck970 FIND v(dout0_10) AT=490.025n

.meas tran vdout0_11ck970 FIND v(dout0_11) AT=490.025n

.meas tran vdout0_12ck970 FIND v(dout0_12) AT=490.025n

.meas tran vdout0_13ck970 FIND v(dout0_13) AT=490.025n

.meas tran vdout0_14ck970 FIND v(dout0_14) AT=490.025n

.meas tran vdout0_15ck970 FIND v(dout0_15) AT=490.025n

.meas tran vdout0_16ck970 FIND v(dout0_16) AT=490.025n

.meas tran vdout0_17ck970 FIND v(dout0_17) AT=490.025n

.meas tran vdout0_18ck970 FIND v(dout0_18) AT=490.025n

.meas tran vdout0_19ck970 FIND v(dout0_19) AT=490.025n

.meas tran vdout0_20ck970 FIND v(dout0_20) AT=490.025n

.meas tran vdout0_21ck970 FIND v(dout0_21) AT=490.025n

.meas tran vdout0_22ck970 FIND v(dout0_22) AT=490.025n

.meas tran vdout0_23ck970 FIND v(dout0_23) AT=490.025n

.meas tran vdout0_24ck970 FIND v(dout0_24) AT=490.025n

.meas tran vdout0_25ck970 FIND v(dout0_25) AT=490.025n

.meas tran vdout0_26ck970 FIND v(dout0_26) AT=490.025n

.meas tran vdout0_27ck970 FIND v(dout0_27) AT=490.025n

.meas tran vdout0_28ck970 FIND v(dout0_28) AT=490.025n

.meas tran vdout0_29ck970 FIND v(dout0_29) AT=490.025n

.meas tran vdout0_30ck970 FIND v(dout0_30) AT=490.025n

.meas tran vdout0_31ck970 FIND v(dout0_31) AT=490.025n

.meas tran vdout0_32ck970 FIND v(dout0_32) AT=490.025n

.meas tran vdout0_33ck970 FIND v(dout0_33) AT=490.025n

.meas tran vdout0_34ck970 FIND v(dout0_34) AT=490.025n

.meas tran vdout0_35ck970 FIND v(dout0_35) AT=490.025n

.meas tran vdout0_36ck970 FIND v(dout0_36) AT=490.025n

.meas tran vdout0_37ck970 FIND v(dout0_37) AT=490.025n

.meas tran vdout0_38ck970 FIND v(dout0_38) AT=490.025n

.meas tran vdout0_39ck970 FIND v(dout0_39) AT=490.025n

.meas tran vdout0_40ck970 FIND v(dout0_40) AT=490.025n

.meas tran vdout0_41ck970 FIND v(dout0_41) AT=490.025n

.meas tran vdout0_42ck970 FIND v(dout0_42) AT=490.025n

.meas tran vdout0_43ck970 FIND v(dout0_43) AT=490.025n

.meas tran vdout0_44ck970 FIND v(dout0_44) AT=490.025n

.meas tran vdout0_45ck970 FIND v(dout0_45) AT=490.025n

.meas tran vdout0_46ck970 FIND v(dout0_46) AT=490.025n

.meas tran vdout0_47ck970 FIND v(dout0_47) AT=490.025n

.meas tran vdout0_48ck970 FIND v(dout0_48) AT=490.025n

.meas tran vdout0_49ck970 FIND v(dout0_49) AT=490.025n

.meas tran vdout0_50ck970 FIND v(dout0_50) AT=490.025n

.meas tran vdout0_51ck970 FIND v(dout0_51) AT=490.025n

.meas tran vdout0_52ck970 FIND v(dout0_52) AT=490.025n

.meas tran vdout0_53ck970 FIND v(dout0_53) AT=490.025n

.meas tran vdout0_54ck970 FIND v(dout0_54) AT=490.025n

.meas tran vdout0_55ck970 FIND v(dout0_55) AT=490.025n

.meas tran vdout0_56ck970 FIND v(dout0_56) AT=490.025n

.meas tran vdout0_57ck970 FIND v(dout0_57) AT=490.025n

.meas tran vdout0_58ck970 FIND v(dout0_58) AT=490.025n

.meas tran vdout0_59ck970 FIND v(dout0_59) AT=490.025n

.meas tran vdout0_60ck970 FIND v(dout0_60) AT=490.025n

.meas tran vdout0_61ck970 FIND v(dout0_61) AT=490.025n

.meas tran vdout0_62ck970 FIND v(dout0_62) AT=490.025n

.meas tran vdout0_63ck970 FIND v(dout0_63) AT=490.025n

.meas tran vdout0_64ck970 FIND v(dout0_64) AT=490.025n

.meas tran vdout0_65ck970 FIND v(dout0_65) AT=490.025n

.meas tran vdout0_66ck970 FIND v(dout0_66) AT=490.025n

.meas tran vdout0_67ck970 FIND v(dout0_67) AT=490.025n

.meas tran vdout0_68ck970 FIND v(dout0_68) AT=490.025n

.meas tran vdout0_69ck970 FIND v(dout0_69) AT=490.025n

.meas tran vdout0_70ck970 FIND v(dout0_70) AT=490.025n

.meas tran vdout0_71ck970 FIND v(dout0_71) AT=490.025n

.meas tran vdout0_72ck970 FIND v(dout0_72) AT=490.025n

.meas tran vdout0_73ck970 FIND v(dout0_73) AT=490.025n

.meas tran vdout0_74ck970 FIND v(dout0_74) AT=490.025n

.meas tran vdout0_75ck970 FIND v(dout0_75) AT=490.025n

.meas tran vdout0_76ck970 FIND v(dout0_76) AT=490.025n

.meas tran vdout0_77ck970 FIND v(dout0_77) AT=490.025n

.meas tran vdout0_78ck970 FIND v(dout0_78) AT=490.025n

.meas tran vdout0_79ck970 FIND v(dout0_79) AT=490.025n

.meas tran vdout0_80ck970 FIND v(dout0_80) AT=490.025n

.meas tran vdout0_81ck970 FIND v(dout0_81) AT=490.025n

.meas tran vdout0_82ck970 FIND v(dout0_82) AT=490.025n

.meas tran vdout0_83ck970 FIND v(dout0_83) AT=490.025n

.meas tran vdout0_84ck970 FIND v(dout0_84) AT=490.025n

.meas tran vdout0_85ck970 FIND v(dout0_85) AT=490.025n

.meas tran vdout0_86ck970 FIND v(dout0_86) AT=490.025n

.meas tran vdout0_87ck970 FIND v(dout0_87) AT=490.025n

.meas tran vdout0_88ck970 FIND v(dout0_88) AT=490.025n

.meas tran vdout0_89ck970 FIND v(dout0_89) AT=490.025n

.meas tran vdout0_90ck970 FIND v(dout0_90) AT=490.025n

.meas tran vdout0_91ck970 FIND v(dout0_91) AT=490.025n

.meas tran vdout0_92ck970 FIND v(dout0_92) AT=490.025n

.meas tran vdout0_93ck970 FIND v(dout0_93) AT=490.025n

.meas tran vdout0_94ck970 FIND v(dout0_94) AT=490.025n

.meas tran vdout0_95ck970 FIND v(dout0_95) AT=490.025n

.meas tran vdout0_96ck970 FIND v(dout0_96) AT=490.025n

.meas tran vdout0_97ck970 FIND v(dout0_97) AT=490.025n

.meas tran vdout0_98ck970 FIND v(dout0_98) AT=490.025n

.meas tran vdout0_99ck970 FIND v(dout0_99) AT=490.025n

.meas tran vdout0_100ck970 FIND v(dout0_100) AT=490.025n

.meas tran vdout0_101ck970 FIND v(dout0_101) AT=490.025n

.meas tran vdout0_102ck970 FIND v(dout0_102) AT=490.025n

.meas tran vdout0_103ck970 FIND v(dout0_103) AT=490.025n

.meas tran vdout0_104ck970 FIND v(dout0_104) AT=490.025n

.meas tran vdout0_105ck970 FIND v(dout0_105) AT=490.025n

.meas tran vdout0_106ck970 FIND v(dout0_106) AT=490.025n

.meas tran vdout0_107ck970 FIND v(dout0_107) AT=490.025n

.meas tran vdout0_108ck970 FIND v(dout0_108) AT=490.025n

.meas tran vdout0_109ck970 FIND v(dout0_109) AT=490.025n

.meas tran vdout0_110ck970 FIND v(dout0_110) AT=490.025n

.meas tran vdout0_111ck970 FIND v(dout0_111) AT=490.025n

.meas tran vdout0_112ck970 FIND v(dout0_112) AT=490.025n

.meas tran vdout0_113ck970 FIND v(dout0_113) AT=490.025n

.meas tran vdout0_114ck970 FIND v(dout0_114) AT=490.025n

.meas tran vdout0_115ck970 FIND v(dout0_115) AT=490.025n

.meas tran vdout0_116ck970 FIND v(dout0_116) AT=490.025n

.meas tran vdout0_117ck970 FIND v(dout0_117) AT=490.025n

.meas tran vdout0_118ck970 FIND v(dout0_118) AT=490.025n

.meas tran vdout0_119ck970 FIND v(dout0_119) AT=490.025n

.meas tran vdout0_120ck970 FIND v(dout0_120) AT=490.025n

.meas tran vdout0_121ck970 FIND v(dout0_121) AT=490.025n

.meas tran vdout0_122ck970 FIND v(dout0_122) AT=490.025n

.meas tran vdout0_123ck970 FIND v(dout0_123) AT=490.025n

.meas tran vdout0_124ck970 FIND v(dout0_124) AT=490.025n

.meas tran vdout0_125ck970 FIND v(dout0_125) AT=490.025n

.meas tran vdout0_126ck970 FIND v(dout0_126) AT=490.025n

.meas tran vdout0_127ck970 FIND v(dout0_127) AT=490.025n

.meas tran vdout0_128ck970 FIND v(dout0_128) AT=490.025n

.meas tran vdout0_129ck970 FIND v(dout0_129) AT=490.025n

.meas tran vdout0_130ck970 FIND v(dout0_130) AT=490.025n

.meas tran vdout0_131ck970 FIND v(dout0_131) AT=490.025n

.meas tran vdout0_132ck970 FIND v(dout0_132) AT=490.025n

.meas tran vdout0_133ck970 FIND v(dout0_133) AT=490.025n

.meas tran vdout0_134ck970 FIND v(dout0_134) AT=490.025n

.meas tran vdout0_135ck970 FIND v(dout0_135) AT=490.025n

.meas tran vdout0_136ck970 FIND v(dout0_136) AT=490.025n

.meas tran vdout0_137ck970 FIND v(dout0_137) AT=490.025n

.meas tran vdout0_138ck970 FIND v(dout0_138) AT=490.025n

.meas tran vdout0_139ck970 FIND v(dout0_139) AT=490.025n

.meas tran vdout0_140ck970 FIND v(dout0_140) AT=490.025n

.meas tran vdout0_141ck970 FIND v(dout0_141) AT=490.025n

.meas tran vdout0_142ck970 FIND v(dout0_142) AT=490.025n

.meas tran vdout0_143ck970 FIND v(dout0_143) AT=490.025n

.meas tran vdout0_144ck970 FIND v(dout0_144) AT=490.025n

.meas tran vdout0_145ck970 FIND v(dout0_145) AT=490.025n

.meas tran vdout0_146ck970 FIND v(dout0_146) AT=490.025n

.meas tran vdout0_147ck970 FIND v(dout0_147) AT=490.025n

.meas tran vdout0_148ck970 FIND v(dout0_148) AT=490.025n

.meas tran vdout0_149ck970 FIND v(dout0_149) AT=490.025n

.meas tran vdout0_0ck980 FIND v(dout0_0) AT=495.025n

.meas tran vdout0_1ck980 FIND v(dout0_1) AT=495.025n

.meas tran vdout0_2ck980 FIND v(dout0_2) AT=495.025n

.meas tran vdout0_3ck980 FIND v(dout0_3) AT=495.025n

.meas tran vdout0_4ck980 FIND v(dout0_4) AT=495.025n

.meas tran vdout0_5ck980 FIND v(dout0_5) AT=495.025n

.meas tran vdout0_6ck980 FIND v(dout0_6) AT=495.025n

.meas tran vdout0_7ck980 FIND v(dout0_7) AT=495.025n

.meas tran vdout0_8ck980 FIND v(dout0_8) AT=495.025n

.meas tran vdout0_9ck980 FIND v(dout0_9) AT=495.025n

.meas tran vdout0_10ck980 FIND v(dout0_10) AT=495.025n

.meas tran vdout0_11ck980 FIND v(dout0_11) AT=495.025n

.meas tran vdout0_12ck980 FIND v(dout0_12) AT=495.025n

.meas tran vdout0_13ck980 FIND v(dout0_13) AT=495.025n

.meas tran vdout0_14ck980 FIND v(dout0_14) AT=495.025n

.meas tran vdout0_15ck980 FIND v(dout0_15) AT=495.025n

.meas tran vdout0_16ck980 FIND v(dout0_16) AT=495.025n

.meas tran vdout0_17ck980 FIND v(dout0_17) AT=495.025n

.meas tran vdout0_18ck980 FIND v(dout0_18) AT=495.025n

.meas tran vdout0_19ck980 FIND v(dout0_19) AT=495.025n

.meas tran vdout0_20ck980 FIND v(dout0_20) AT=495.025n

.meas tran vdout0_21ck980 FIND v(dout0_21) AT=495.025n

.meas tran vdout0_22ck980 FIND v(dout0_22) AT=495.025n

.meas tran vdout0_23ck980 FIND v(dout0_23) AT=495.025n

.meas tran vdout0_24ck980 FIND v(dout0_24) AT=495.025n

.meas tran vdout0_25ck980 FIND v(dout0_25) AT=495.025n

.meas tran vdout0_26ck980 FIND v(dout0_26) AT=495.025n

.meas tran vdout0_27ck980 FIND v(dout0_27) AT=495.025n

.meas tran vdout0_28ck980 FIND v(dout0_28) AT=495.025n

.meas tran vdout0_29ck980 FIND v(dout0_29) AT=495.025n

.meas tran vdout0_30ck980 FIND v(dout0_30) AT=495.025n

.meas tran vdout0_31ck980 FIND v(dout0_31) AT=495.025n

.meas tran vdout0_32ck980 FIND v(dout0_32) AT=495.025n

.meas tran vdout0_33ck980 FIND v(dout0_33) AT=495.025n

.meas tran vdout0_34ck980 FIND v(dout0_34) AT=495.025n

.meas tran vdout0_35ck980 FIND v(dout0_35) AT=495.025n

.meas tran vdout0_36ck980 FIND v(dout0_36) AT=495.025n

.meas tran vdout0_37ck980 FIND v(dout0_37) AT=495.025n

.meas tran vdout0_38ck980 FIND v(dout0_38) AT=495.025n

.meas tran vdout0_39ck980 FIND v(dout0_39) AT=495.025n

.meas tran vdout0_40ck980 FIND v(dout0_40) AT=495.025n

.meas tran vdout0_41ck980 FIND v(dout0_41) AT=495.025n

.meas tran vdout0_42ck980 FIND v(dout0_42) AT=495.025n

.meas tran vdout0_43ck980 FIND v(dout0_43) AT=495.025n

.meas tran vdout0_44ck980 FIND v(dout0_44) AT=495.025n

.meas tran vdout0_45ck980 FIND v(dout0_45) AT=495.025n

.meas tran vdout0_46ck980 FIND v(dout0_46) AT=495.025n

.meas tran vdout0_47ck980 FIND v(dout0_47) AT=495.025n

.meas tran vdout0_48ck980 FIND v(dout0_48) AT=495.025n

.meas tran vdout0_49ck980 FIND v(dout0_49) AT=495.025n

.meas tran vdout0_50ck980 FIND v(dout0_50) AT=495.025n

.meas tran vdout0_51ck980 FIND v(dout0_51) AT=495.025n

.meas tran vdout0_52ck980 FIND v(dout0_52) AT=495.025n

.meas tran vdout0_53ck980 FIND v(dout0_53) AT=495.025n

.meas tran vdout0_54ck980 FIND v(dout0_54) AT=495.025n

.meas tran vdout0_55ck980 FIND v(dout0_55) AT=495.025n

.meas tran vdout0_56ck980 FIND v(dout0_56) AT=495.025n

.meas tran vdout0_57ck980 FIND v(dout0_57) AT=495.025n

.meas tran vdout0_58ck980 FIND v(dout0_58) AT=495.025n

.meas tran vdout0_59ck980 FIND v(dout0_59) AT=495.025n

.meas tran vdout0_60ck980 FIND v(dout0_60) AT=495.025n

.meas tran vdout0_61ck980 FIND v(dout0_61) AT=495.025n

.meas tran vdout0_62ck980 FIND v(dout0_62) AT=495.025n

.meas tran vdout0_63ck980 FIND v(dout0_63) AT=495.025n

.meas tran vdout0_64ck980 FIND v(dout0_64) AT=495.025n

.meas tran vdout0_65ck980 FIND v(dout0_65) AT=495.025n

.meas tran vdout0_66ck980 FIND v(dout0_66) AT=495.025n

.meas tran vdout0_67ck980 FIND v(dout0_67) AT=495.025n

.meas tran vdout0_68ck980 FIND v(dout0_68) AT=495.025n

.meas tran vdout0_69ck980 FIND v(dout0_69) AT=495.025n

.meas tran vdout0_70ck980 FIND v(dout0_70) AT=495.025n

.meas tran vdout0_71ck980 FIND v(dout0_71) AT=495.025n

.meas tran vdout0_72ck980 FIND v(dout0_72) AT=495.025n

.meas tran vdout0_73ck980 FIND v(dout0_73) AT=495.025n

.meas tran vdout0_74ck980 FIND v(dout0_74) AT=495.025n

.meas tran vdout0_75ck980 FIND v(dout0_75) AT=495.025n

.meas tran vdout0_76ck980 FIND v(dout0_76) AT=495.025n

.meas tran vdout0_77ck980 FIND v(dout0_77) AT=495.025n

.meas tran vdout0_78ck980 FIND v(dout0_78) AT=495.025n

.meas tran vdout0_79ck980 FIND v(dout0_79) AT=495.025n

.meas tran vdout0_80ck980 FIND v(dout0_80) AT=495.025n

.meas tran vdout0_81ck980 FIND v(dout0_81) AT=495.025n

.meas tran vdout0_82ck980 FIND v(dout0_82) AT=495.025n

.meas tran vdout0_83ck980 FIND v(dout0_83) AT=495.025n

.meas tran vdout0_84ck980 FIND v(dout0_84) AT=495.025n

.meas tran vdout0_85ck980 FIND v(dout0_85) AT=495.025n

.meas tran vdout0_86ck980 FIND v(dout0_86) AT=495.025n

.meas tran vdout0_87ck980 FIND v(dout0_87) AT=495.025n

.meas tran vdout0_88ck980 FIND v(dout0_88) AT=495.025n

.meas tran vdout0_89ck980 FIND v(dout0_89) AT=495.025n

.meas tran vdout0_90ck980 FIND v(dout0_90) AT=495.025n

.meas tran vdout0_91ck980 FIND v(dout0_91) AT=495.025n

.meas tran vdout0_92ck980 FIND v(dout0_92) AT=495.025n

.meas tran vdout0_93ck980 FIND v(dout0_93) AT=495.025n

.meas tran vdout0_94ck980 FIND v(dout0_94) AT=495.025n

.meas tran vdout0_95ck980 FIND v(dout0_95) AT=495.025n

.meas tran vdout0_96ck980 FIND v(dout0_96) AT=495.025n

.meas tran vdout0_97ck980 FIND v(dout0_97) AT=495.025n

.meas tran vdout0_98ck980 FIND v(dout0_98) AT=495.025n

.meas tran vdout0_99ck980 FIND v(dout0_99) AT=495.025n

.meas tran vdout0_100ck980 FIND v(dout0_100) AT=495.025n

.meas tran vdout0_101ck980 FIND v(dout0_101) AT=495.025n

.meas tran vdout0_102ck980 FIND v(dout0_102) AT=495.025n

.meas tran vdout0_103ck980 FIND v(dout0_103) AT=495.025n

.meas tran vdout0_104ck980 FIND v(dout0_104) AT=495.025n

.meas tran vdout0_105ck980 FIND v(dout0_105) AT=495.025n

.meas tran vdout0_106ck980 FIND v(dout0_106) AT=495.025n

.meas tran vdout0_107ck980 FIND v(dout0_107) AT=495.025n

.meas tran vdout0_108ck980 FIND v(dout0_108) AT=495.025n

.meas tran vdout0_109ck980 FIND v(dout0_109) AT=495.025n

.meas tran vdout0_110ck980 FIND v(dout0_110) AT=495.025n

.meas tran vdout0_111ck980 FIND v(dout0_111) AT=495.025n

.meas tran vdout0_112ck980 FIND v(dout0_112) AT=495.025n

.meas tran vdout0_113ck980 FIND v(dout0_113) AT=495.025n

.meas tran vdout0_114ck980 FIND v(dout0_114) AT=495.025n

.meas tran vdout0_115ck980 FIND v(dout0_115) AT=495.025n

.meas tran vdout0_116ck980 FIND v(dout0_116) AT=495.025n

.meas tran vdout0_117ck980 FIND v(dout0_117) AT=495.025n

.meas tran vdout0_118ck980 FIND v(dout0_118) AT=495.025n

.meas tran vdout0_119ck980 FIND v(dout0_119) AT=495.025n

.meas tran vdout0_120ck980 FIND v(dout0_120) AT=495.025n

.meas tran vdout0_121ck980 FIND v(dout0_121) AT=495.025n

.meas tran vdout0_122ck980 FIND v(dout0_122) AT=495.025n

.meas tran vdout0_123ck980 FIND v(dout0_123) AT=495.025n

.meas tran vdout0_124ck980 FIND v(dout0_124) AT=495.025n

.meas tran vdout0_125ck980 FIND v(dout0_125) AT=495.025n

.meas tran vdout0_126ck980 FIND v(dout0_126) AT=495.025n

.meas tran vdout0_127ck980 FIND v(dout0_127) AT=495.025n

.meas tran vdout0_128ck980 FIND v(dout0_128) AT=495.025n

.meas tran vdout0_129ck980 FIND v(dout0_129) AT=495.025n

.meas tran vdout0_130ck980 FIND v(dout0_130) AT=495.025n

.meas tran vdout0_131ck980 FIND v(dout0_131) AT=495.025n

.meas tran vdout0_132ck980 FIND v(dout0_132) AT=495.025n

.meas tran vdout0_133ck980 FIND v(dout0_133) AT=495.025n

.meas tran vdout0_134ck980 FIND v(dout0_134) AT=495.025n

.meas tran vdout0_135ck980 FIND v(dout0_135) AT=495.025n

.meas tran vdout0_136ck980 FIND v(dout0_136) AT=495.025n

.meas tran vdout0_137ck980 FIND v(dout0_137) AT=495.025n

.meas tran vdout0_138ck980 FIND v(dout0_138) AT=495.025n

.meas tran vdout0_139ck980 FIND v(dout0_139) AT=495.025n

.meas tran vdout0_140ck980 FIND v(dout0_140) AT=495.025n

.meas tran vdout0_141ck980 FIND v(dout0_141) AT=495.025n

.meas tran vdout0_142ck980 FIND v(dout0_142) AT=495.025n

.meas tran vdout0_143ck980 FIND v(dout0_143) AT=495.025n

.meas tran vdout0_144ck980 FIND v(dout0_144) AT=495.025n

.meas tran vdout0_145ck980 FIND v(dout0_145) AT=495.025n

.meas tran vdout0_146ck980 FIND v(dout0_146) AT=495.025n

.meas tran vdout0_147ck980 FIND v(dout0_147) AT=495.025n

.meas tran vdout0_148ck980 FIND v(dout0_148) AT=495.025n

.meas tran vdout0_149ck980 FIND v(dout0_149) AT=495.025n

.meas tran vdout0_0ck1000 FIND v(dout0_0) AT=505.025n

.meas tran vdout0_1ck1000 FIND v(dout0_1) AT=505.025n

.meas tran vdout0_2ck1000 FIND v(dout0_2) AT=505.025n

.meas tran vdout0_3ck1000 FIND v(dout0_3) AT=505.025n

.meas tran vdout0_4ck1000 FIND v(dout0_4) AT=505.025n

.meas tran vdout0_5ck1000 FIND v(dout0_5) AT=505.025n

.meas tran vdout0_6ck1000 FIND v(dout0_6) AT=505.025n

.meas tran vdout0_7ck1000 FIND v(dout0_7) AT=505.025n

.meas tran vdout0_8ck1000 FIND v(dout0_8) AT=505.025n

.meas tran vdout0_9ck1000 FIND v(dout0_9) AT=505.025n

.meas tran vdout0_10ck1000 FIND v(dout0_10) AT=505.025n

.meas tran vdout0_11ck1000 FIND v(dout0_11) AT=505.025n

.meas tran vdout0_12ck1000 FIND v(dout0_12) AT=505.025n

.meas tran vdout0_13ck1000 FIND v(dout0_13) AT=505.025n

.meas tran vdout0_14ck1000 FIND v(dout0_14) AT=505.025n

.meas tran vdout0_15ck1000 FIND v(dout0_15) AT=505.025n

.meas tran vdout0_16ck1000 FIND v(dout0_16) AT=505.025n

.meas tran vdout0_17ck1000 FIND v(dout0_17) AT=505.025n

.meas tran vdout0_18ck1000 FIND v(dout0_18) AT=505.025n

.meas tran vdout0_19ck1000 FIND v(dout0_19) AT=505.025n

.meas tran vdout0_20ck1000 FIND v(dout0_20) AT=505.025n

.meas tran vdout0_21ck1000 FIND v(dout0_21) AT=505.025n

.meas tran vdout0_22ck1000 FIND v(dout0_22) AT=505.025n

.meas tran vdout0_23ck1000 FIND v(dout0_23) AT=505.025n

.meas tran vdout0_24ck1000 FIND v(dout0_24) AT=505.025n

.meas tran vdout0_25ck1000 FIND v(dout0_25) AT=505.025n

.meas tran vdout0_26ck1000 FIND v(dout0_26) AT=505.025n

.meas tran vdout0_27ck1000 FIND v(dout0_27) AT=505.025n

.meas tran vdout0_28ck1000 FIND v(dout0_28) AT=505.025n

.meas tran vdout0_29ck1000 FIND v(dout0_29) AT=505.025n

.meas tran vdout0_30ck1000 FIND v(dout0_30) AT=505.025n

.meas tran vdout0_31ck1000 FIND v(dout0_31) AT=505.025n

.meas tran vdout0_32ck1000 FIND v(dout0_32) AT=505.025n

.meas tran vdout0_33ck1000 FIND v(dout0_33) AT=505.025n

.meas tran vdout0_34ck1000 FIND v(dout0_34) AT=505.025n

.meas tran vdout0_35ck1000 FIND v(dout0_35) AT=505.025n

.meas tran vdout0_36ck1000 FIND v(dout0_36) AT=505.025n

.meas tran vdout0_37ck1000 FIND v(dout0_37) AT=505.025n

.meas tran vdout0_38ck1000 FIND v(dout0_38) AT=505.025n

.meas tran vdout0_39ck1000 FIND v(dout0_39) AT=505.025n

.meas tran vdout0_40ck1000 FIND v(dout0_40) AT=505.025n

.meas tran vdout0_41ck1000 FIND v(dout0_41) AT=505.025n

.meas tran vdout0_42ck1000 FIND v(dout0_42) AT=505.025n

.meas tran vdout0_43ck1000 FIND v(dout0_43) AT=505.025n

.meas tran vdout0_44ck1000 FIND v(dout0_44) AT=505.025n

.meas tran vdout0_45ck1000 FIND v(dout0_45) AT=505.025n

.meas tran vdout0_46ck1000 FIND v(dout0_46) AT=505.025n

.meas tran vdout0_47ck1000 FIND v(dout0_47) AT=505.025n

.meas tran vdout0_48ck1000 FIND v(dout0_48) AT=505.025n

.meas tran vdout0_49ck1000 FIND v(dout0_49) AT=505.025n

.meas tran vdout0_50ck1000 FIND v(dout0_50) AT=505.025n

.meas tran vdout0_51ck1000 FIND v(dout0_51) AT=505.025n

.meas tran vdout0_52ck1000 FIND v(dout0_52) AT=505.025n

.meas tran vdout0_53ck1000 FIND v(dout0_53) AT=505.025n

.meas tran vdout0_54ck1000 FIND v(dout0_54) AT=505.025n

.meas tran vdout0_55ck1000 FIND v(dout0_55) AT=505.025n

.meas tran vdout0_56ck1000 FIND v(dout0_56) AT=505.025n

.meas tran vdout0_57ck1000 FIND v(dout0_57) AT=505.025n

.meas tran vdout0_58ck1000 FIND v(dout0_58) AT=505.025n

.meas tran vdout0_59ck1000 FIND v(dout0_59) AT=505.025n

.meas tran vdout0_60ck1000 FIND v(dout0_60) AT=505.025n

.meas tran vdout0_61ck1000 FIND v(dout0_61) AT=505.025n

.meas tran vdout0_62ck1000 FIND v(dout0_62) AT=505.025n

.meas tran vdout0_63ck1000 FIND v(dout0_63) AT=505.025n

.meas tran vdout0_64ck1000 FIND v(dout0_64) AT=505.025n

.meas tran vdout0_65ck1000 FIND v(dout0_65) AT=505.025n

.meas tran vdout0_66ck1000 FIND v(dout0_66) AT=505.025n

.meas tran vdout0_67ck1000 FIND v(dout0_67) AT=505.025n

.meas tran vdout0_68ck1000 FIND v(dout0_68) AT=505.025n

.meas tran vdout0_69ck1000 FIND v(dout0_69) AT=505.025n

.meas tran vdout0_70ck1000 FIND v(dout0_70) AT=505.025n

.meas tran vdout0_71ck1000 FIND v(dout0_71) AT=505.025n

.meas tran vdout0_72ck1000 FIND v(dout0_72) AT=505.025n

.meas tran vdout0_73ck1000 FIND v(dout0_73) AT=505.025n

.meas tran vdout0_74ck1000 FIND v(dout0_74) AT=505.025n

.meas tran vdout0_75ck1000 FIND v(dout0_75) AT=505.025n

.meas tran vdout0_76ck1000 FIND v(dout0_76) AT=505.025n

.meas tran vdout0_77ck1000 FIND v(dout0_77) AT=505.025n

.meas tran vdout0_78ck1000 FIND v(dout0_78) AT=505.025n

.meas tran vdout0_79ck1000 FIND v(dout0_79) AT=505.025n

.meas tran vdout0_80ck1000 FIND v(dout0_80) AT=505.025n

.meas tran vdout0_81ck1000 FIND v(dout0_81) AT=505.025n

.meas tran vdout0_82ck1000 FIND v(dout0_82) AT=505.025n

.meas tran vdout0_83ck1000 FIND v(dout0_83) AT=505.025n

.meas tran vdout0_84ck1000 FIND v(dout0_84) AT=505.025n

.meas tran vdout0_85ck1000 FIND v(dout0_85) AT=505.025n

.meas tran vdout0_86ck1000 FIND v(dout0_86) AT=505.025n

.meas tran vdout0_87ck1000 FIND v(dout0_87) AT=505.025n

.meas tran vdout0_88ck1000 FIND v(dout0_88) AT=505.025n

.meas tran vdout0_89ck1000 FIND v(dout0_89) AT=505.025n

.meas tran vdout0_90ck1000 FIND v(dout0_90) AT=505.025n

.meas tran vdout0_91ck1000 FIND v(dout0_91) AT=505.025n

.meas tran vdout0_92ck1000 FIND v(dout0_92) AT=505.025n

.meas tran vdout0_93ck1000 FIND v(dout0_93) AT=505.025n

.meas tran vdout0_94ck1000 FIND v(dout0_94) AT=505.025n

.meas tran vdout0_95ck1000 FIND v(dout0_95) AT=505.025n

.meas tran vdout0_96ck1000 FIND v(dout0_96) AT=505.025n

.meas tran vdout0_97ck1000 FIND v(dout0_97) AT=505.025n

.meas tran vdout0_98ck1000 FIND v(dout0_98) AT=505.025n

.meas tran vdout0_99ck1000 FIND v(dout0_99) AT=505.025n

.meas tran vdout0_100ck1000 FIND v(dout0_100) AT=505.025n

.meas tran vdout0_101ck1000 FIND v(dout0_101) AT=505.025n

.meas tran vdout0_102ck1000 FIND v(dout0_102) AT=505.025n

.meas tran vdout0_103ck1000 FIND v(dout0_103) AT=505.025n

.meas tran vdout0_104ck1000 FIND v(dout0_104) AT=505.025n

.meas tran vdout0_105ck1000 FIND v(dout0_105) AT=505.025n

.meas tran vdout0_106ck1000 FIND v(dout0_106) AT=505.025n

.meas tran vdout0_107ck1000 FIND v(dout0_107) AT=505.025n

.meas tran vdout0_108ck1000 FIND v(dout0_108) AT=505.025n

.meas tran vdout0_109ck1000 FIND v(dout0_109) AT=505.025n

.meas tran vdout0_110ck1000 FIND v(dout0_110) AT=505.025n

.meas tran vdout0_111ck1000 FIND v(dout0_111) AT=505.025n

.meas tran vdout0_112ck1000 FIND v(dout0_112) AT=505.025n

.meas tran vdout0_113ck1000 FIND v(dout0_113) AT=505.025n

.meas tran vdout0_114ck1000 FIND v(dout0_114) AT=505.025n

.meas tran vdout0_115ck1000 FIND v(dout0_115) AT=505.025n

.meas tran vdout0_116ck1000 FIND v(dout0_116) AT=505.025n

.meas tran vdout0_117ck1000 FIND v(dout0_117) AT=505.025n

.meas tran vdout0_118ck1000 FIND v(dout0_118) AT=505.025n

.meas tran vdout0_119ck1000 FIND v(dout0_119) AT=505.025n

.meas tran vdout0_120ck1000 FIND v(dout0_120) AT=505.025n

.meas tran vdout0_121ck1000 FIND v(dout0_121) AT=505.025n

.meas tran vdout0_122ck1000 FIND v(dout0_122) AT=505.025n

.meas tran vdout0_123ck1000 FIND v(dout0_123) AT=505.025n

.meas tran vdout0_124ck1000 FIND v(dout0_124) AT=505.025n

.meas tran vdout0_125ck1000 FIND v(dout0_125) AT=505.025n

.meas tran vdout0_126ck1000 FIND v(dout0_126) AT=505.025n

.meas tran vdout0_127ck1000 FIND v(dout0_127) AT=505.025n

.meas tran vdout0_128ck1000 FIND v(dout0_128) AT=505.025n

.meas tran vdout0_129ck1000 FIND v(dout0_129) AT=505.025n

.meas tran vdout0_130ck1000 FIND v(dout0_130) AT=505.025n

.meas tran vdout0_131ck1000 FIND v(dout0_131) AT=505.025n

.meas tran vdout0_132ck1000 FIND v(dout0_132) AT=505.025n

.meas tran vdout0_133ck1000 FIND v(dout0_133) AT=505.025n

.meas tran vdout0_134ck1000 FIND v(dout0_134) AT=505.025n

.meas tran vdout0_135ck1000 FIND v(dout0_135) AT=505.025n

.meas tran vdout0_136ck1000 FIND v(dout0_136) AT=505.025n

.meas tran vdout0_137ck1000 FIND v(dout0_137) AT=505.025n

.meas tran vdout0_138ck1000 FIND v(dout0_138) AT=505.025n

.meas tran vdout0_139ck1000 FIND v(dout0_139) AT=505.025n

.meas tran vdout0_140ck1000 FIND v(dout0_140) AT=505.025n

.meas tran vdout0_141ck1000 FIND v(dout0_141) AT=505.025n

.meas tran vdout0_142ck1000 FIND v(dout0_142) AT=505.025n

.meas tran vdout0_143ck1000 FIND v(dout0_143) AT=505.025n

.meas tran vdout0_144ck1000 FIND v(dout0_144) AT=505.025n

.meas tran vdout0_145ck1000 FIND v(dout0_145) AT=505.025n

.meas tran vdout0_146ck1000 FIND v(dout0_146) AT=505.025n

.meas tran vdout0_147ck1000 FIND v(dout0_147) AT=505.025n

.meas tran vdout0_148ck1000 FIND v(dout0_148) AT=505.025n

.meas tran vdout0_149ck1000 FIND v(dout0_149) AT=505.025n

.meas tran vdout0_0ck1040 FIND v(dout0_0) AT=525.025n

.meas tran vdout0_1ck1040 FIND v(dout0_1) AT=525.025n

.meas tran vdout0_2ck1040 FIND v(dout0_2) AT=525.025n

.meas tran vdout0_3ck1040 FIND v(dout0_3) AT=525.025n

.meas tran vdout0_4ck1040 FIND v(dout0_4) AT=525.025n

.meas tran vdout0_5ck1040 FIND v(dout0_5) AT=525.025n

.meas tran vdout0_6ck1040 FIND v(dout0_6) AT=525.025n

.meas tran vdout0_7ck1040 FIND v(dout0_7) AT=525.025n

.meas tran vdout0_8ck1040 FIND v(dout0_8) AT=525.025n

.meas tran vdout0_9ck1040 FIND v(dout0_9) AT=525.025n

.meas tran vdout0_10ck1040 FIND v(dout0_10) AT=525.025n

.meas tran vdout0_11ck1040 FIND v(dout0_11) AT=525.025n

.meas tran vdout0_12ck1040 FIND v(dout0_12) AT=525.025n

.meas tran vdout0_13ck1040 FIND v(dout0_13) AT=525.025n

.meas tran vdout0_14ck1040 FIND v(dout0_14) AT=525.025n

.meas tran vdout0_15ck1040 FIND v(dout0_15) AT=525.025n

.meas tran vdout0_16ck1040 FIND v(dout0_16) AT=525.025n

.meas tran vdout0_17ck1040 FIND v(dout0_17) AT=525.025n

.meas tran vdout0_18ck1040 FIND v(dout0_18) AT=525.025n

.meas tran vdout0_19ck1040 FIND v(dout0_19) AT=525.025n

.meas tran vdout0_20ck1040 FIND v(dout0_20) AT=525.025n

.meas tran vdout0_21ck1040 FIND v(dout0_21) AT=525.025n

.meas tran vdout0_22ck1040 FIND v(dout0_22) AT=525.025n

.meas tran vdout0_23ck1040 FIND v(dout0_23) AT=525.025n

.meas tran vdout0_24ck1040 FIND v(dout0_24) AT=525.025n

.meas tran vdout0_25ck1040 FIND v(dout0_25) AT=525.025n

.meas tran vdout0_26ck1040 FIND v(dout0_26) AT=525.025n

.meas tran vdout0_27ck1040 FIND v(dout0_27) AT=525.025n

.meas tran vdout0_28ck1040 FIND v(dout0_28) AT=525.025n

.meas tran vdout0_29ck1040 FIND v(dout0_29) AT=525.025n

.meas tran vdout0_30ck1040 FIND v(dout0_30) AT=525.025n

.meas tran vdout0_31ck1040 FIND v(dout0_31) AT=525.025n

.meas tran vdout0_32ck1040 FIND v(dout0_32) AT=525.025n

.meas tran vdout0_33ck1040 FIND v(dout0_33) AT=525.025n

.meas tran vdout0_34ck1040 FIND v(dout0_34) AT=525.025n

.meas tran vdout0_35ck1040 FIND v(dout0_35) AT=525.025n

.meas tran vdout0_36ck1040 FIND v(dout0_36) AT=525.025n

.meas tran vdout0_37ck1040 FIND v(dout0_37) AT=525.025n

.meas tran vdout0_38ck1040 FIND v(dout0_38) AT=525.025n

.meas tran vdout0_39ck1040 FIND v(dout0_39) AT=525.025n

.meas tran vdout0_40ck1040 FIND v(dout0_40) AT=525.025n

.meas tran vdout0_41ck1040 FIND v(dout0_41) AT=525.025n

.meas tran vdout0_42ck1040 FIND v(dout0_42) AT=525.025n

.meas tran vdout0_43ck1040 FIND v(dout0_43) AT=525.025n

.meas tran vdout0_44ck1040 FIND v(dout0_44) AT=525.025n

.meas tran vdout0_45ck1040 FIND v(dout0_45) AT=525.025n

.meas tran vdout0_46ck1040 FIND v(dout0_46) AT=525.025n

.meas tran vdout0_47ck1040 FIND v(dout0_47) AT=525.025n

.meas tran vdout0_48ck1040 FIND v(dout0_48) AT=525.025n

.meas tran vdout0_49ck1040 FIND v(dout0_49) AT=525.025n

.meas tran vdout0_50ck1040 FIND v(dout0_50) AT=525.025n

.meas tran vdout0_51ck1040 FIND v(dout0_51) AT=525.025n

.meas tran vdout0_52ck1040 FIND v(dout0_52) AT=525.025n

.meas tran vdout0_53ck1040 FIND v(dout0_53) AT=525.025n

.meas tran vdout0_54ck1040 FIND v(dout0_54) AT=525.025n

.meas tran vdout0_55ck1040 FIND v(dout0_55) AT=525.025n

.meas tran vdout0_56ck1040 FIND v(dout0_56) AT=525.025n

.meas tran vdout0_57ck1040 FIND v(dout0_57) AT=525.025n

.meas tran vdout0_58ck1040 FIND v(dout0_58) AT=525.025n

.meas tran vdout0_59ck1040 FIND v(dout0_59) AT=525.025n

.meas tran vdout0_60ck1040 FIND v(dout0_60) AT=525.025n

.meas tran vdout0_61ck1040 FIND v(dout0_61) AT=525.025n

.meas tran vdout0_62ck1040 FIND v(dout0_62) AT=525.025n

.meas tran vdout0_63ck1040 FIND v(dout0_63) AT=525.025n

.meas tran vdout0_64ck1040 FIND v(dout0_64) AT=525.025n

.meas tran vdout0_65ck1040 FIND v(dout0_65) AT=525.025n

.meas tran vdout0_66ck1040 FIND v(dout0_66) AT=525.025n

.meas tran vdout0_67ck1040 FIND v(dout0_67) AT=525.025n

.meas tran vdout0_68ck1040 FIND v(dout0_68) AT=525.025n

.meas tran vdout0_69ck1040 FIND v(dout0_69) AT=525.025n

.meas tran vdout0_70ck1040 FIND v(dout0_70) AT=525.025n

.meas tran vdout0_71ck1040 FIND v(dout0_71) AT=525.025n

.meas tran vdout0_72ck1040 FIND v(dout0_72) AT=525.025n

.meas tran vdout0_73ck1040 FIND v(dout0_73) AT=525.025n

.meas tran vdout0_74ck1040 FIND v(dout0_74) AT=525.025n

.meas tran vdout0_75ck1040 FIND v(dout0_75) AT=525.025n

.meas tran vdout0_76ck1040 FIND v(dout0_76) AT=525.025n

.meas tran vdout0_77ck1040 FIND v(dout0_77) AT=525.025n

.meas tran vdout0_78ck1040 FIND v(dout0_78) AT=525.025n

.meas tran vdout0_79ck1040 FIND v(dout0_79) AT=525.025n

.meas tran vdout0_80ck1040 FIND v(dout0_80) AT=525.025n

.meas tran vdout0_81ck1040 FIND v(dout0_81) AT=525.025n

.meas tran vdout0_82ck1040 FIND v(dout0_82) AT=525.025n

.meas tran vdout0_83ck1040 FIND v(dout0_83) AT=525.025n

.meas tran vdout0_84ck1040 FIND v(dout0_84) AT=525.025n

.meas tran vdout0_85ck1040 FIND v(dout0_85) AT=525.025n

.meas tran vdout0_86ck1040 FIND v(dout0_86) AT=525.025n

.meas tran vdout0_87ck1040 FIND v(dout0_87) AT=525.025n

.meas tran vdout0_88ck1040 FIND v(dout0_88) AT=525.025n

.meas tran vdout0_89ck1040 FIND v(dout0_89) AT=525.025n

.meas tran vdout0_90ck1040 FIND v(dout0_90) AT=525.025n

.meas tran vdout0_91ck1040 FIND v(dout0_91) AT=525.025n

.meas tran vdout0_92ck1040 FIND v(dout0_92) AT=525.025n

.meas tran vdout0_93ck1040 FIND v(dout0_93) AT=525.025n

.meas tran vdout0_94ck1040 FIND v(dout0_94) AT=525.025n

.meas tran vdout0_95ck1040 FIND v(dout0_95) AT=525.025n

.meas tran vdout0_96ck1040 FIND v(dout0_96) AT=525.025n

.meas tran vdout0_97ck1040 FIND v(dout0_97) AT=525.025n

.meas tran vdout0_98ck1040 FIND v(dout0_98) AT=525.025n

.meas tran vdout0_99ck1040 FIND v(dout0_99) AT=525.025n

.meas tran vdout0_100ck1040 FIND v(dout0_100) AT=525.025n

.meas tran vdout0_101ck1040 FIND v(dout0_101) AT=525.025n

.meas tran vdout0_102ck1040 FIND v(dout0_102) AT=525.025n

.meas tran vdout0_103ck1040 FIND v(dout0_103) AT=525.025n

.meas tran vdout0_104ck1040 FIND v(dout0_104) AT=525.025n

.meas tran vdout0_105ck1040 FIND v(dout0_105) AT=525.025n

.meas tran vdout0_106ck1040 FIND v(dout0_106) AT=525.025n

.meas tran vdout0_107ck1040 FIND v(dout0_107) AT=525.025n

.meas tran vdout0_108ck1040 FIND v(dout0_108) AT=525.025n

.meas tran vdout0_109ck1040 FIND v(dout0_109) AT=525.025n

.meas tran vdout0_110ck1040 FIND v(dout0_110) AT=525.025n

.meas tran vdout0_111ck1040 FIND v(dout0_111) AT=525.025n

.meas tran vdout0_112ck1040 FIND v(dout0_112) AT=525.025n

.meas tran vdout0_113ck1040 FIND v(dout0_113) AT=525.025n

.meas tran vdout0_114ck1040 FIND v(dout0_114) AT=525.025n

.meas tran vdout0_115ck1040 FIND v(dout0_115) AT=525.025n

.meas tran vdout0_116ck1040 FIND v(dout0_116) AT=525.025n

.meas tran vdout0_117ck1040 FIND v(dout0_117) AT=525.025n

.meas tran vdout0_118ck1040 FIND v(dout0_118) AT=525.025n

.meas tran vdout0_119ck1040 FIND v(dout0_119) AT=525.025n

.meas tran vdout0_120ck1040 FIND v(dout0_120) AT=525.025n

.meas tran vdout0_121ck1040 FIND v(dout0_121) AT=525.025n

.meas tran vdout0_122ck1040 FIND v(dout0_122) AT=525.025n

.meas tran vdout0_123ck1040 FIND v(dout0_123) AT=525.025n

.meas tran vdout0_124ck1040 FIND v(dout0_124) AT=525.025n

.meas tran vdout0_125ck1040 FIND v(dout0_125) AT=525.025n

.meas tran vdout0_126ck1040 FIND v(dout0_126) AT=525.025n

.meas tran vdout0_127ck1040 FIND v(dout0_127) AT=525.025n

.meas tran vdout0_128ck1040 FIND v(dout0_128) AT=525.025n

.meas tran vdout0_129ck1040 FIND v(dout0_129) AT=525.025n

.meas tran vdout0_130ck1040 FIND v(dout0_130) AT=525.025n

.meas tran vdout0_131ck1040 FIND v(dout0_131) AT=525.025n

.meas tran vdout0_132ck1040 FIND v(dout0_132) AT=525.025n

.meas tran vdout0_133ck1040 FIND v(dout0_133) AT=525.025n

.meas tran vdout0_134ck1040 FIND v(dout0_134) AT=525.025n

.meas tran vdout0_135ck1040 FIND v(dout0_135) AT=525.025n

.meas tran vdout0_136ck1040 FIND v(dout0_136) AT=525.025n

.meas tran vdout0_137ck1040 FIND v(dout0_137) AT=525.025n

.meas tran vdout0_138ck1040 FIND v(dout0_138) AT=525.025n

.meas tran vdout0_139ck1040 FIND v(dout0_139) AT=525.025n

.meas tran vdout0_140ck1040 FIND v(dout0_140) AT=525.025n

.meas tran vdout0_141ck1040 FIND v(dout0_141) AT=525.025n

.meas tran vdout0_142ck1040 FIND v(dout0_142) AT=525.025n

.meas tran vdout0_143ck1040 FIND v(dout0_143) AT=525.025n

.meas tran vdout0_144ck1040 FIND v(dout0_144) AT=525.025n

.meas tran vdout0_145ck1040 FIND v(dout0_145) AT=525.025n

.meas tran vdout0_146ck1040 FIND v(dout0_146) AT=525.025n

.meas tran vdout0_147ck1040 FIND v(dout0_147) AT=525.025n

.meas tran vdout0_148ck1040 FIND v(dout0_148) AT=525.025n

.meas tran vdout0_149ck1040 FIND v(dout0_149) AT=525.025n

.meas tran vdout0_0ck1110 FIND v(dout0_0) AT=560.025n

.meas tran vdout0_1ck1110 FIND v(dout0_1) AT=560.025n

.meas tran vdout0_2ck1110 FIND v(dout0_2) AT=560.025n

.meas tran vdout0_3ck1110 FIND v(dout0_3) AT=560.025n

.meas tran vdout0_4ck1110 FIND v(dout0_4) AT=560.025n

.meas tran vdout0_5ck1110 FIND v(dout0_5) AT=560.025n

.meas tran vdout0_6ck1110 FIND v(dout0_6) AT=560.025n

.meas tran vdout0_7ck1110 FIND v(dout0_7) AT=560.025n

.meas tran vdout0_8ck1110 FIND v(dout0_8) AT=560.025n

.meas tran vdout0_9ck1110 FIND v(dout0_9) AT=560.025n

.meas tran vdout0_10ck1110 FIND v(dout0_10) AT=560.025n

.meas tran vdout0_11ck1110 FIND v(dout0_11) AT=560.025n

.meas tran vdout0_12ck1110 FIND v(dout0_12) AT=560.025n

.meas tran vdout0_13ck1110 FIND v(dout0_13) AT=560.025n

.meas tran vdout0_14ck1110 FIND v(dout0_14) AT=560.025n

.meas tran vdout0_15ck1110 FIND v(dout0_15) AT=560.025n

.meas tran vdout0_16ck1110 FIND v(dout0_16) AT=560.025n

.meas tran vdout0_17ck1110 FIND v(dout0_17) AT=560.025n

.meas tran vdout0_18ck1110 FIND v(dout0_18) AT=560.025n

.meas tran vdout0_19ck1110 FIND v(dout0_19) AT=560.025n

.meas tran vdout0_20ck1110 FIND v(dout0_20) AT=560.025n

.meas tran vdout0_21ck1110 FIND v(dout0_21) AT=560.025n

.meas tran vdout0_22ck1110 FIND v(dout0_22) AT=560.025n

.meas tran vdout0_23ck1110 FIND v(dout0_23) AT=560.025n

.meas tran vdout0_24ck1110 FIND v(dout0_24) AT=560.025n

.meas tran vdout0_25ck1110 FIND v(dout0_25) AT=560.025n

.meas tran vdout0_26ck1110 FIND v(dout0_26) AT=560.025n

.meas tran vdout0_27ck1110 FIND v(dout0_27) AT=560.025n

.meas tran vdout0_28ck1110 FIND v(dout0_28) AT=560.025n

.meas tran vdout0_29ck1110 FIND v(dout0_29) AT=560.025n

.meas tran vdout0_30ck1110 FIND v(dout0_30) AT=560.025n

.meas tran vdout0_31ck1110 FIND v(dout0_31) AT=560.025n

.meas tran vdout0_32ck1110 FIND v(dout0_32) AT=560.025n

.meas tran vdout0_33ck1110 FIND v(dout0_33) AT=560.025n

.meas tran vdout0_34ck1110 FIND v(dout0_34) AT=560.025n

.meas tran vdout0_35ck1110 FIND v(dout0_35) AT=560.025n

.meas tran vdout0_36ck1110 FIND v(dout0_36) AT=560.025n

.meas tran vdout0_37ck1110 FIND v(dout0_37) AT=560.025n

.meas tran vdout0_38ck1110 FIND v(dout0_38) AT=560.025n

.meas tran vdout0_39ck1110 FIND v(dout0_39) AT=560.025n

.meas tran vdout0_40ck1110 FIND v(dout0_40) AT=560.025n

.meas tran vdout0_41ck1110 FIND v(dout0_41) AT=560.025n

.meas tran vdout0_42ck1110 FIND v(dout0_42) AT=560.025n

.meas tran vdout0_43ck1110 FIND v(dout0_43) AT=560.025n

.meas tran vdout0_44ck1110 FIND v(dout0_44) AT=560.025n

.meas tran vdout0_45ck1110 FIND v(dout0_45) AT=560.025n

.meas tran vdout0_46ck1110 FIND v(dout0_46) AT=560.025n

.meas tran vdout0_47ck1110 FIND v(dout0_47) AT=560.025n

.meas tran vdout0_48ck1110 FIND v(dout0_48) AT=560.025n

.meas tran vdout0_49ck1110 FIND v(dout0_49) AT=560.025n

.meas tran vdout0_50ck1110 FIND v(dout0_50) AT=560.025n

.meas tran vdout0_51ck1110 FIND v(dout0_51) AT=560.025n

.meas tran vdout0_52ck1110 FIND v(dout0_52) AT=560.025n

.meas tran vdout0_53ck1110 FIND v(dout0_53) AT=560.025n

.meas tran vdout0_54ck1110 FIND v(dout0_54) AT=560.025n

.meas tran vdout0_55ck1110 FIND v(dout0_55) AT=560.025n

.meas tran vdout0_56ck1110 FIND v(dout0_56) AT=560.025n

.meas tran vdout0_57ck1110 FIND v(dout0_57) AT=560.025n

.meas tran vdout0_58ck1110 FIND v(dout0_58) AT=560.025n

.meas tran vdout0_59ck1110 FIND v(dout0_59) AT=560.025n

.meas tran vdout0_60ck1110 FIND v(dout0_60) AT=560.025n

.meas tran vdout0_61ck1110 FIND v(dout0_61) AT=560.025n

.meas tran vdout0_62ck1110 FIND v(dout0_62) AT=560.025n

.meas tran vdout0_63ck1110 FIND v(dout0_63) AT=560.025n

.meas tran vdout0_64ck1110 FIND v(dout0_64) AT=560.025n

.meas tran vdout0_65ck1110 FIND v(dout0_65) AT=560.025n

.meas tran vdout0_66ck1110 FIND v(dout0_66) AT=560.025n

.meas tran vdout0_67ck1110 FIND v(dout0_67) AT=560.025n

.meas tran vdout0_68ck1110 FIND v(dout0_68) AT=560.025n

.meas tran vdout0_69ck1110 FIND v(dout0_69) AT=560.025n

.meas tran vdout0_70ck1110 FIND v(dout0_70) AT=560.025n

.meas tran vdout0_71ck1110 FIND v(dout0_71) AT=560.025n

.meas tran vdout0_72ck1110 FIND v(dout0_72) AT=560.025n

.meas tran vdout0_73ck1110 FIND v(dout0_73) AT=560.025n

.meas tran vdout0_74ck1110 FIND v(dout0_74) AT=560.025n

.meas tran vdout0_75ck1110 FIND v(dout0_75) AT=560.025n

.meas tran vdout0_76ck1110 FIND v(dout0_76) AT=560.025n

.meas tran vdout0_77ck1110 FIND v(dout0_77) AT=560.025n

.meas tran vdout0_78ck1110 FIND v(dout0_78) AT=560.025n

.meas tran vdout0_79ck1110 FIND v(dout0_79) AT=560.025n

.meas tran vdout0_80ck1110 FIND v(dout0_80) AT=560.025n

.meas tran vdout0_81ck1110 FIND v(dout0_81) AT=560.025n

.meas tran vdout0_82ck1110 FIND v(dout0_82) AT=560.025n

.meas tran vdout0_83ck1110 FIND v(dout0_83) AT=560.025n

.meas tran vdout0_84ck1110 FIND v(dout0_84) AT=560.025n

.meas tran vdout0_85ck1110 FIND v(dout0_85) AT=560.025n

.meas tran vdout0_86ck1110 FIND v(dout0_86) AT=560.025n

.meas tran vdout0_87ck1110 FIND v(dout0_87) AT=560.025n

.meas tran vdout0_88ck1110 FIND v(dout0_88) AT=560.025n

.meas tran vdout0_89ck1110 FIND v(dout0_89) AT=560.025n

.meas tran vdout0_90ck1110 FIND v(dout0_90) AT=560.025n

.meas tran vdout0_91ck1110 FIND v(dout0_91) AT=560.025n

.meas tran vdout0_92ck1110 FIND v(dout0_92) AT=560.025n

.meas tran vdout0_93ck1110 FIND v(dout0_93) AT=560.025n

.meas tran vdout0_94ck1110 FIND v(dout0_94) AT=560.025n

.meas tran vdout0_95ck1110 FIND v(dout0_95) AT=560.025n

.meas tran vdout0_96ck1110 FIND v(dout0_96) AT=560.025n

.meas tran vdout0_97ck1110 FIND v(dout0_97) AT=560.025n

.meas tran vdout0_98ck1110 FIND v(dout0_98) AT=560.025n

.meas tran vdout0_99ck1110 FIND v(dout0_99) AT=560.025n

.meas tran vdout0_100ck1110 FIND v(dout0_100) AT=560.025n

.meas tran vdout0_101ck1110 FIND v(dout0_101) AT=560.025n

.meas tran vdout0_102ck1110 FIND v(dout0_102) AT=560.025n

.meas tran vdout0_103ck1110 FIND v(dout0_103) AT=560.025n

.meas tran vdout0_104ck1110 FIND v(dout0_104) AT=560.025n

.meas tran vdout0_105ck1110 FIND v(dout0_105) AT=560.025n

.meas tran vdout0_106ck1110 FIND v(dout0_106) AT=560.025n

.meas tran vdout0_107ck1110 FIND v(dout0_107) AT=560.025n

.meas tran vdout0_108ck1110 FIND v(dout0_108) AT=560.025n

.meas tran vdout0_109ck1110 FIND v(dout0_109) AT=560.025n

.meas tran vdout0_110ck1110 FIND v(dout0_110) AT=560.025n

.meas tran vdout0_111ck1110 FIND v(dout0_111) AT=560.025n

.meas tran vdout0_112ck1110 FIND v(dout0_112) AT=560.025n

.meas tran vdout0_113ck1110 FIND v(dout0_113) AT=560.025n

.meas tran vdout0_114ck1110 FIND v(dout0_114) AT=560.025n

.meas tran vdout0_115ck1110 FIND v(dout0_115) AT=560.025n

.meas tran vdout0_116ck1110 FIND v(dout0_116) AT=560.025n

.meas tran vdout0_117ck1110 FIND v(dout0_117) AT=560.025n

.meas tran vdout0_118ck1110 FIND v(dout0_118) AT=560.025n

.meas tran vdout0_119ck1110 FIND v(dout0_119) AT=560.025n

.meas tran vdout0_120ck1110 FIND v(dout0_120) AT=560.025n

.meas tran vdout0_121ck1110 FIND v(dout0_121) AT=560.025n

.meas tran vdout0_122ck1110 FIND v(dout0_122) AT=560.025n

.meas tran vdout0_123ck1110 FIND v(dout0_123) AT=560.025n

.meas tran vdout0_124ck1110 FIND v(dout0_124) AT=560.025n

.meas tran vdout0_125ck1110 FIND v(dout0_125) AT=560.025n

.meas tran vdout0_126ck1110 FIND v(dout0_126) AT=560.025n

.meas tran vdout0_127ck1110 FIND v(dout0_127) AT=560.025n

.meas tran vdout0_128ck1110 FIND v(dout0_128) AT=560.025n

.meas tran vdout0_129ck1110 FIND v(dout0_129) AT=560.025n

.meas tran vdout0_130ck1110 FIND v(dout0_130) AT=560.025n

.meas tran vdout0_131ck1110 FIND v(dout0_131) AT=560.025n

.meas tran vdout0_132ck1110 FIND v(dout0_132) AT=560.025n

.meas tran vdout0_133ck1110 FIND v(dout0_133) AT=560.025n

.meas tran vdout0_134ck1110 FIND v(dout0_134) AT=560.025n

.meas tran vdout0_135ck1110 FIND v(dout0_135) AT=560.025n

.meas tran vdout0_136ck1110 FIND v(dout0_136) AT=560.025n

.meas tran vdout0_137ck1110 FIND v(dout0_137) AT=560.025n

.meas tran vdout0_138ck1110 FIND v(dout0_138) AT=560.025n

.meas tran vdout0_139ck1110 FIND v(dout0_139) AT=560.025n

.meas tran vdout0_140ck1110 FIND v(dout0_140) AT=560.025n

.meas tran vdout0_141ck1110 FIND v(dout0_141) AT=560.025n

.meas tran vdout0_142ck1110 FIND v(dout0_142) AT=560.025n

.meas tran vdout0_143ck1110 FIND v(dout0_143) AT=560.025n

.meas tran vdout0_144ck1110 FIND v(dout0_144) AT=560.025n

.meas tran vdout0_145ck1110 FIND v(dout0_145) AT=560.025n

.meas tran vdout0_146ck1110 FIND v(dout0_146) AT=560.025n

.meas tran vdout0_147ck1110 FIND v(dout0_147) AT=560.025n

.meas tran vdout0_148ck1110 FIND v(dout0_148) AT=560.025n

.meas tran vdout0_149ck1110 FIND v(dout0_149) AT=560.025n

.meas tran vdout0_0ck1120 FIND v(dout0_0) AT=565.025n

.meas tran vdout0_1ck1120 FIND v(dout0_1) AT=565.025n

.meas tran vdout0_2ck1120 FIND v(dout0_2) AT=565.025n

.meas tran vdout0_3ck1120 FIND v(dout0_3) AT=565.025n

.meas tran vdout0_4ck1120 FIND v(dout0_4) AT=565.025n

.meas tran vdout0_5ck1120 FIND v(dout0_5) AT=565.025n

.meas tran vdout0_6ck1120 FIND v(dout0_6) AT=565.025n

.meas tran vdout0_7ck1120 FIND v(dout0_7) AT=565.025n

.meas tran vdout0_8ck1120 FIND v(dout0_8) AT=565.025n

.meas tran vdout0_9ck1120 FIND v(dout0_9) AT=565.025n

.meas tran vdout0_10ck1120 FIND v(dout0_10) AT=565.025n

.meas tran vdout0_11ck1120 FIND v(dout0_11) AT=565.025n

.meas tran vdout0_12ck1120 FIND v(dout0_12) AT=565.025n

.meas tran vdout0_13ck1120 FIND v(dout0_13) AT=565.025n

.meas tran vdout0_14ck1120 FIND v(dout0_14) AT=565.025n

.meas tran vdout0_15ck1120 FIND v(dout0_15) AT=565.025n

.meas tran vdout0_16ck1120 FIND v(dout0_16) AT=565.025n

.meas tran vdout0_17ck1120 FIND v(dout0_17) AT=565.025n

.meas tran vdout0_18ck1120 FIND v(dout0_18) AT=565.025n

.meas tran vdout0_19ck1120 FIND v(dout0_19) AT=565.025n

.meas tran vdout0_20ck1120 FIND v(dout0_20) AT=565.025n

.meas tran vdout0_21ck1120 FIND v(dout0_21) AT=565.025n

.meas tran vdout0_22ck1120 FIND v(dout0_22) AT=565.025n

.meas tran vdout0_23ck1120 FIND v(dout0_23) AT=565.025n

.meas tran vdout0_24ck1120 FIND v(dout0_24) AT=565.025n

.meas tran vdout0_25ck1120 FIND v(dout0_25) AT=565.025n

.meas tran vdout0_26ck1120 FIND v(dout0_26) AT=565.025n

.meas tran vdout0_27ck1120 FIND v(dout0_27) AT=565.025n

.meas tran vdout0_28ck1120 FIND v(dout0_28) AT=565.025n

.meas tran vdout0_29ck1120 FIND v(dout0_29) AT=565.025n

.meas tran vdout0_30ck1120 FIND v(dout0_30) AT=565.025n

.meas tran vdout0_31ck1120 FIND v(dout0_31) AT=565.025n

.meas tran vdout0_32ck1120 FIND v(dout0_32) AT=565.025n

.meas tran vdout0_33ck1120 FIND v(dout0_33) AT=565.025n

.meas tran vdout0_34ck1120 FIND v(dout0_34) AT=565.025n

.meas tran vdout0_35ck1120 FIND v(dout0_35) AT=565.025n

.meas tran vdout0_36ck1120 FIND v(dout0_36) AT=565.025n

.meas tran vdout0_37ck1120 FIND v(dout0_37) AT=565.025n

.meas tran vdout0_38ck1120 FIND v(dout0_38) AT=565.025n

.meas tran vdout0_39ck1120 FIND v(dout0_39) AT=565.025n

.meas tran vdout0_40ck1120 FIND v(dout0_40) AT=565.025n

.meas tran vdout0_41ck1120 FIND v(dout0_41) AT=565.025n

.meas tran vdout0_42ck1120 FIND v(dout0_42) AT=565.025n

.meas tran vdout0_43ck1120 FIND v(dout0_43) AT=565.025n

.meas tran vdout0_44ck1120 FIND v(dout0_44) AT=565.025n

.meas tran vdout0_45ck1120 FIND v(dout0_45) AT=565.025n

.meas tran vdout0_46ck1120 FIND v(dout0_46) AT=565.025n

.meas tran vdout0_47ck1120 FIND v(dout0_47) AT=565.025n

.meas tran vdout0_48ck1120 FIND v(dout0_48) AT=565.025n

.meas tran vdout0_49ck1120 FIND v(dout0_49) AT=565.025n

.meas tran vdout0_50ck1120 FIND v(dout0_50) AT=565.025n

.meas tran vdout0_51ck1120 FIND v(dout0_51) AT=565.025n

.meas tran vdout0_52ck1120 FIND v(dout0_52) AT=565.025n

.meas tran vdout0_53ck1120 FIND v(dout0_53) AT=565.025n

.meas tran vdout0_54ck1120 FIND v(dout0_54) AT=565.025n

.meas tran vdout0_55ck1120 FIND v(dout0_55) AT=565.025n

.meas tran vdout0_56ck1120 FIND v(dout0_56) AT=565.025n

.meas tran vdout0_57ck1120 FIND v(dout0_57) AT=565.025n

.meas tran vdout0_58ck1120 FIND v(dout0_58) AT=565.025n

.meas tran vdout0_59ck1120 FIND v(dout0_59) AT=565.025n

.meas tran vdout0_60ck1120 FIND v(dout0_60) AT=565.025n

.meas tran vdout0_61ck1120 FIND v(dout0_61) AT=565.025n

.meas tran vdout0_62ck1120 FIND v(dout0_62) AT=565.025n

.meas tran vdout0_63ck1120 FIND v(dout0_63) AT=565.025n

.meas tran vdout0_64ck1120 FIND v(dout0_64) AT=565.025n

.meas tran vdout0_65ck1120 FIND v(dout0_65) AT=565.025n

.meas tran vdout0_66ck1120 FIND v(dout0_66) AT=565.025n

.meas tran vdout0_67ck1120 FIND v(dout0_67) AT=565.025n

.meas tran vdout0_68ck1120 FIND v(dout0_68) AT=565.025n

.meas tran vdout0_69ck1120 FIND v(dout0_69) AT=565.025n

.meas tran vdout0_70ck1120 FIND v(dout0_70) AT=565.025n

.meas tran vdout0_71ck1120 FIND v(dout0_71) AT=565.025n

.meas tran vdout0_72ck1120 FIND v(dout0_72) AT=565.025n

.meas tran vdout0_73ck1120 FIND v(dout0_73) AT=565.025n

.meas tran vdout0_74ck1120 FIND v(dout0_74) AT=565.025n

.meas tran vdout0_75ck1120 FIND v(dout0_75) AT=565.025n

.meas tran vdout0_76ck1120 FIND v(dout0_76) AT=565.025n

.meas tran vdout0_77ck1120 FIND v(dout0_77) AT=565.025n

.meas tran vdout0_78ck1120 FIND v(dout0_78) AT=565.025n

.meas tran vdout0_79ck1120 FIND v(dout0_79) AT=565.025n

.meas tran vdout0_80ck1120 FIND v(dout0_80) AT=565.025n

.meas tran vdout0_81ck1120 FIND v(dout0_81) AT=565.025n

.meas tran vdout0_82ck1120 FIND v(dout0_82) AT=565.025n

.meas tran vdout0_83ck1120 FIND v(dout0_83) AT=565.025n

.meas tran vdout0_84ck1120 FIND v(dout0_84) AT=565.025n

.meas tran vdout0_85ck1120 FIND v(dout0_85) AT=565.025n

.meas tran vdout0_86ck1120 FIND v(dout0_86) AT=565.025n

.meas tran vdout0_87ck1120 FIND v(dout0_87) AT=565.025n

.meas tran vdout0_88ck1120 FIND v(dout0_88) AT=565.025n

.meas tran vdout0_89ck1120 FIND v(dout0_89) AT=565.025n

.meas tran vdout0_90ck1120 FIND v(dout0_90) AT=565.025n

.meas tran vdout0_91ck1120 FIND v(dout0_91) AT=565.025n

.meas tran vdout0_92ck1120 FIND v(dout0_92) AT=565.025n

.meas tran vdout0_93ck1120 FIND v(dout0_93) AT=565.025n

.meas tran vdout0_94ck1120 FIND v(dout0_94) AT=565.025n

.meas tran vdout0_95ck1120 FIND v(dout0_95) AT=565.025n

.meas tran vdout0_96ck1120 FIND v(dout0_96) AT=565.025n

.meas tran vdout0_97ck1120 FIND v(dout0_97) AT=565.025n

.meas tran vdout0_98ck1120 FIND v(dout0_98) AT=565.025n

.meas tran vdout0_99ck1120 FIND v(dout0_99) AT=565.025n

.meas tran vdout0_100ck1120 FIND v(dout0_100) AT=565.025n

.meas tran vdout0_101ck1120 FIND v(dout0_101) AT=565.025n

.meas tran vdout0_102ck1120 FIND v(dout0_102) AT=565.025n

.meas tran vdout0_103ck1120 FIND v(dout0_103) AT=565.025n

.meas tran vdout0_104ck1120 FIND v(dout0_104) AT=565.025n

.meas tran vdout0_105ck1120 FIND v(dout0_105) AT=565.025n

.meas tran vdout0_106ck1120 FIND v(dout0_106) AT=565.025n

.meas tran vdout0_107ck1120 FIND v(dout0_107) AT=565.025n

.meas tran vdout0_108ck1120 FIND v(dout0_108) AT=565.025n

.meas tran vdout0_109ck1120 FIND v(dout0_109) AT=565.025n

.meas tran vdout0_110ck1120 FIND v(dout0_110) AT=565.025n

.meas tran vdout0_111ck1120 FIND v(dout0_111) AT=565.025n

.meas tran vdout0_112ck1120 FIND v(dout0_112) AT=565.025n

.meas tran vdout0_113ck1120 FIND v(dout0_113) AT=565.025n

.meas tran vdout0_114ck1120 FIND v(dout0_114) AT=565.025n

.meas tran vdout0_115ck1120 FIND v(dout0_115) AT=565.025n

.meas tran vdout0_116ck1120 FIND v(dout0_116) AT=565.025n

.meas tran vdout0_117ck1120 FIND v(dout0_117) AT=565.025n

.meas tran vdout0_118ck1120 FIND v(dout0_118) AT=565.025n

.meas tran vdout0_119ck1120 FIND v(dout0_119) AT=565.025n

.meas tran vdout0_120ck1120 FIND v(dout0_120) AT=565.025n

.meas tran vdout0_121ck1120 FIND v(dout0_121) AT=565.025n

.meas tran vdout0_122ck1120 FIND v(dout0_122) AT=565.025n

.meas tran vdout0_123ck1120 FIND v(dout0_123) AT=565.025n

.meas tran vdout0_124ck1120 FIND v(dout0_124) AT=565.025n

.meas tran vdout0_125ck1120 FIND v(dout0_125) AT=565.025n

.meas tran vdout0_126ck1120 FIND v(dout0_126) AT=565.025n

.meas tran vdout0_127ck1120 FIND v(dout0_127) AT=565.025n

.meas tran vdout0_128ck1120 FIND v(dout0_128) AT=565.025n

.meas tran vdout0_129ck1120 FIND v(dout0_129) AT=565.025n

.meas tran vdout0_130ck1120 FIND v(dout0_130) AT=565.025n

.meas tran vdout0_131ck1120 FIND v(dout0_131) AT=565.025n

.meas tran vdout0_132ck1120 FIND v(dout0_132) AT=565.025n

.meas tran vdout0_133ck1120 FIND v(dout0_133) AT=565.025n

.meas tran vdout0_134ck1120 FIND v(dout0_134) AT=565.025n

.meas tran vdout0_135ck1120 FIND v(dout0_135) AT=565.025n

.meas tran vdout0_136ck1120 FIND v(dout0_136) AT=565.025n

.meas tran vdout0_137ck1120 FIND v(dout0_137) AT=565.025n

.meas tran vdout0_138ck1120 FIND v(dout0_138) AT=565.025n

.meas tran vdout0_139ck1120 FIND v(dout0_139) AT=565.025n

.meas tran vdout0_140ck1120 FIND v(dout0_140) AT=565.025n

.meas tran vdout0_141ck1120 FIND v(dout0_141) AT=565.025n

.meas tran vdout0_142ck1120 FIND v(dout0_142) AT=565.025n

.meas tran vdout0_143ck1120 FIND v(dout0_143) AT=565.025n

.meas tran vdout0_144ck1120 FIND v(dout0_144) AT=565.025n

.meas tran vdout0_145ck1120 FIND v(dout0_145) AT=565.025n

.meas tran vdout0_146ck1120 FIND v(dout0_146) AT=565.025n

.meas tran vdout0_147ck1120 FIND v(dout0_147) AT=565.025n

.meas tran vdout0_148ck1120 FIND v(dout0_148) AT=565.025n

.meas tran vdout0_149ck1120 FIND v(dout0_149) AT=565.025n

.meas tran vdout0_0ck1160 FIND v(dout0_0) AT=585.025n

.meas tran vdout0_1ck1160 FIND v(dout0_1) AT=585.025n

.meas tran vdout0_2ck1160 FIND v(dout0_2) AT=585.025n

.meas tran vdout0_3ck1160 FIND v(dout0_3) AT=585.025n

.meas tran vdout0_4ck1160 FIND v(dout0_4) AT=585.025n

.meas tran vdout0_5ck1160 FIND v(dout0_5) AT=585.025n

.meas tran vdout0_6ck1160 FIND v(dout0_6) AT=585.025n

.meas tran vdout0_7ck1160 FIND v(dout0_7) AT=585.025n

.meas tran vdout0_8ck1160 FIND v(dout0_8) AT=585.025n

.meas tran vdout0_9ck1160 FIND v(dout0_9) AT=585.025n

.meas tran vdout0_10ck1160 FIND v(dout0_10) AT=585.025n

.meas tran vdout0_11ck1160 FIND v(dout0_11) AT=585.025n

.meas tran vdout0_12ck1160 FIND v(dout0_12) AT=585.025n

.meas tran vdout0_13ck1160 FIND v(dout0_13) AT=585.025n

.meas tran vdout0_14ck1160 FIND v(dout0_14) AT=585.025n

.meas tran vdout0_15ck1160 FIND v(dout0_15) AT=585.025n

.meas tran vdout0_16ck1160 FIND v(dout0_16) AT=585.025n

.meas tran vdout0_17ck1160 FIND v(dout0_17) AT=585.025n

.meas tran vdout0_18ck1160 FIND v(dout0_18) AT=585.025n

.meas tran vdout0_19ck1160 FIND v(dout0_19) AT=585.025n

.meas tran vdout0_20ck1160 FIND v(dout0_20) AT=585.025n

.meas tran vdout0_21ck1160 FIND v(dout0_21) AT=585.025n

.meas tran vdout0_22ck1160 FIND v(dout0_22) AT=585.025n

.meas tran vdout0_23ck1160 FIND v(dout0_23) AT=585.025n

.meas tran vdout0_24ck1160 FIND v(dout0_24) AT=585.025n

.meas tran vdout0_25ck1160 FIND v(dout0_25) AT=585.025n

.meas tran vdout0_26ck1160 FIND v(dout0_26) AT=585.025n

.meas tran vdout0_27ck1160 FIND v(dout0_27) AT=585.025n

.meas tran vdout0_28ck1160 FIND v(dout0_28) AT=585.025n

.meas tran vdout0_29ck1160 FIND v(dout0_29) AT=585.025n

.meas tran vdout0_30ck1160 FIND v(dout0_30) AT=585.025n

.meas tran vdout0_31ck1160 FIND v(dout0_31) AT=585.025n

.meas tran vdout0_32ck1160 FIND v(dout0_32) AT=585.025n

.meas tran vdout0_33ck1160 FIND v(dout0_33) AT=585.025n

.meas tran vdout0_34ck1160 FIND v(dout0_34) AT=585.025n

.meas tran vdout0_35ck1160 FIND v(dout0_35) AT=585.025n

.meas tran vdout0_36ck1160 FIND v(dout0_36) AT=585.025n

.meas tran vdout0_37ck1160 FIND v(dout0_37) AT=585.025n

.meas tran vdout0_38ck1160 FIND v(dout0_38) AT=585.025n

.meas tran vdout0_39ck1160 FIND v(dout0_39) AT=585.025n

.meas tran vdout0_40ck1160 FIND v(dout0_40) AT=585.025n

.meas tran vdout0_41ck1160 FIND v(dout0_41) AT=585.025n

.meas tran vdout0_42ck1160 FIND v(dout0_42) AT=585.025n

.meas tran vdout0_43ck1160 FIND v(dout0_43) AT=585.025n

.meas tran vdout0_44ck1160 FIND v(dout0_44) AT=585.025n

.meas tran vdout0_45ck1160 FIND v(dout0_45) AT=585.025n

.meas tran vdout0_46ck1160 FIND v(dout0_46) AT=585.025n

.meas tran vdout0_47ck1160 FIND v(dout0_47) AT=585.025n

.meas tran vdout0_48ck1160 FIND v(dout0_48) AT=585.025n

.meas tran vdout0_49ck1160 FIND v(dout0_49) AT=585.025n

.meas tran vdout0_50ck1160 FIND v(dout0_50) AT=585.025n

.meas tran vdout0_51ck1160 FIND v(dout0_51) AT=585.025n

.meas tran vdout0_52ck1160 FIND v(dout0_52) AT=585.025n

.meas tran vdout0_53ck1160 FIND v(dout0_53) AT=585.025n

.meas tran vdout0_54ck1160 FIND v(dout0_54) AT=585.025n

.meas tran vdout0_55ck1160 FIND v(dout0_55) AT=585.025n

.meas tran vdout0_56ck1160 FIND v(dout0_56) AT=585.025n

.meas tran vdout0_57ck1160 FIND v(dout0_57) AT=585.025n

.meas tran vdout0_58ck1160 FIND v(dout0_58) AT=585.025n

.meas tran vdout0_59ck1160 FIND v(dout0_59) AT=585.025n

.meas tran vdout0_60ck1160 FIND v(dout0_60) AT=585.025n

.meas tran vdout0_61ck1160 FIND v(dout0_61) AT=585.025n

.meas tran vdout0_62ck1160 FIND v(dout0_62) AT=585.025n

.meas tran vdout0_63ck1160 FIND v(dout0_63) AT=585.025n

.meas tran vdout0_64ck1160 FIND v(dout0_64) AT=585.025n

.meas tran vdout0_65ck1160 FIND v(dout0_65) AT=585.025n

.meas tran vdout0_66ck1160 FIND v(dout0_66) AT=585.025n

.meas tran vdout0_67ck1160 FIND v(dout0_67) AT=585.025n

.meas tran vdout0_68ck1160 FIND v(dout0_68) AT=585.025n

.meas tran vdout0_69ck1160 FIND v(dout0_69) AT=585.025n

.meas tran vdout0_70ck1160 FIND v(dout0_70) AT=585.025n

.meas tran vdout0_71ck1160 FIND v(dout0_71) AT=585.025n

.meas tran vdout0_72ck1160 FIND v(dout0_72) AT=585.025n

.meas tran vdout0_73ck1160 FIND v(dout0_73) AT=585.025n

.meas tran vdout0_74ck1160 FIND v(dout0_74) AT=585.025n

.meas tran vdout0_75ck1160 FIND v(dout0_75) AT=585.025n

.meas tran vdout0_76ck1160 FIND v(dout0_76) AT=585.025n

.meas tran vdout0_77ck1160 FIND v(dout0_77) AT=585.025n

.meas tran vdout0_78ck1160 FIND v(dout0_78) AT=585.025n

.meas tran vdout0_79ck1160 FIND v(dout0_79) AT=585.025n

.meas tran vdout0_80ck1160 FIND v(dout0_80) AT=585.025n

.meas tran vdout0_81ck1160 FIND v(dout0_81) AT=585.025n

.meas tran vdout0_82ck1160 FIND v(dout0_82) AT=585.025n

.meas tran vdout0_83ck1160 FIND v(dout0_83) AT=585.025n

.meas tran vdout0_84ck1160 FIND v(dout0_84) AT=585.025n

.meas tran vdout0_85ck1160 FIND v(dout0_85) AT=585.025n

.meas tran vdout0_86ck1160 FIND v(dout0_86) AT=585.025n

.meas tran vdout0_87ck1160 FIND v(dout0_87) AT=585.025n

.meas tran vdout0_88ck1160 FIND v(dout0_88) AT=585.025n

.meas tran vdout0_89ck1160 FIND v(dout0_89) AT=585.025n

.meas tran vdout0_90ck1160 FIND v(dout0_90) AT=585.025n

.meas tran vdout0_91ck1160 FIND v(dout0_91) AT=585.025n

.meas tran vdout0_92ck1160 FIND v(dout0_92) AT=585.025n

.meas tran vdout0_93ck1160 FIND v(dout0_93) AT=585.025n

.meas tran vdout0_94ck1160 FIND v(dout0_94) AT=585.025n

.meas tran vdout0_95ck1160 FIND v(dout0_95) AT=585.025n

.meas tran vdout0_96ck1160 FIND v(dout0_96) AT=585.025n

.meas tran vdout0_97ck1160 FIND v(dout0_97) AT=585.025n

.meas tran vdout0_98ck1160 FIND v(dout0_98) AT=585.025n

.meas tran vdout0_99ck1160 FIND v(dout0_99) AT=585.025n

.meas tran vdout0_100ck1160 FIND v(dout0_100) AT=585.025n

.meas tran vdout0_101ck1160 FIND v(dout0_101) AT=585.025n

.meas tran vdout0_102ck1160 FIND v(dout0_102) AT=585.025n

.meas tran vdout0_103ck1160 FIND v(dout0_103) AT=585.025n

.meas tran vdout0_104ck1160 FIND v(dout0_104) AT=585.025n

.meas tran vdout0_105ck1160 FIND v(dout0_105) AT=585.025n

.meas tran vdout0_106ck1160 FIND v(dout0_106) AT=585.025n

.meas tran vdout0_107ck1160 FIND v(dout0_107) AT=585.025n

.meas tran vdout0_108ck1160 FIND v(dout0_108) AT=585.025n

.meas tran vdout0_109ck1160 FIND v(dout0_109) AT=585.025n

.meas tran vdout0_110ck1160 FIND v(dout0_110) AT=585.025n

.meas tran vdout0_111ck1160 FIND v(dout0_111) AT=585.025n

.meas tran vdout0_112ck1160 FIND v(dout0_112) AT=585.025n

.meas tran vdout0_113ck1160 FIND v(dout0_113) AT=585.025n

.meas tran vdout0_114ck1160 FIND v(dout0_114) AT=585.025n

.meas tran vdout0_115ck1160 FIND v(dout0_115) AT=585.025n

.meas tran vdout0_116ck1160 FIND v(dout0_116) AT=585.025n

.meas tran vdout0_117ck1160 FIND v(dout0_117) AT=585.025n

.meas tran vdout0_118ck1160 FIND v(dout0_118) AT=585.025n

.meas tran vdout0_119ck1160 FIND v(dout0_119) AT=585.025n

.meas tran vdout0_120ck1160 FIND v(dout0_120) AT=585.025n

.meas tran vdout0_121ck1160 FIND v(dout0_121) AT=585.025n

.meas tran vdout0_122ck1160 FIND v(dout0_122) AT=585.025n

.meas tran vdout0_123ck1160 FIND v(dout0_123) AT=585.025n

.meas tran vdout0_124ck1160 FIND v(dout0_124) AT=585.025n

.meas tran vdout0_125ck1160 FIND v(dout0_125) AT=585.025n

.meas tran vdout0_126ck1160 FIND v(dout0_126) AT=585.025n

.meas tran vdout0_127ck1160 FIND v(dout0_127) AT=585.025n

.meas tran vdout0_128ck1160 FIND v(dout0_128) AT=585.025n

.meas tran vdout0_129ck1160 FIND v(dout0_129) AT=585.025n

.meas tran vdout0_130ck1160 FIND v(dout0_130) AT=585.025n

.meas tran vdout0_131ck1160 FIND v(dout0_131) AT=585.025n

.meas tran vdout0_132ck1160 FIND v(dout0_132) AT=585.025n

.meas tran vdout0_133ck1160 FIND v(dout0_133) AT=585.025n

.meas tran vdout0_134ck1160 FIND v(dout0_134) AT=585.025n

.meas tran vdout0_135ck1160 FIND v(dout0_135) AT=585.025n

.meas tran vdout0_136ck1160 FIND v(dout0_136) AT=585.025n

.meas tran vdout0_137ck1160 FIND v(dout0_137) AT=585.025n

.meas tran vdout0_138ck1160 FIND v(dout0_138) AT=585.025n

.meas tran vdout0_139ck1160 FIND v(dout0_139) AT=585.025n

.meas tran vdout0_140ck1160 FIND v(dout0_140) AT=585.025n

.meas tran vdout0_141ck1160 FIND v(dout0_141) AT=585.025n

.meas tran vdout0_142ck1160 FIND v(dout0_142) AT=585.025n

.meas tran vdout0_143ck1160 FIND v(dout0_143) AT=585.025n

.meas tran vdout0_144ck1160 FIND v(dout0_144) AT=585.025n

.meas tran vdout0_145ck1160 FIND v(dout0_145) AT=585.025n

.meas tran vdout0_146ck1160 FIND v(dout0_146) AT=585.025n

.meas tran vdout0_147ck1160 FIND v(dout0_147) AT=585.025n

.meas tran vdout0_148ck1160 FIND v(dout0_148) AT=585.025n

.meas tran vdout0_149ck1160 FIND v(dout0_149) AT=585.025n

.meas tran vdout0_0ck1210 FIND v(dout0_0) AT=610.025n

.meas tran vdout0_1ck1210 FIND v(dout0_1) AT=610.025n

.meas tran vdout0_2ck1210 FIND v(dout0_2) AT=610.025n

.meas tran vdout0_3ck1210 FIND v(dout0_3) AT=610.025n

.meas tran vdout0_4ck1210 FIND v(dout0_4) AT=610.025n

.meas tran vdout0_5ck1210 FIND v(dout0_5) AT=610.025n

.meas tran vdout0_6ck1210 FIND v(dout0_6) AT=610.025n

.meas tran vdout0_7ck1210 FIND v(dout0_7) AT=610.025n

.meas tran vdout0_8ck1210 FIND v(dout0_8) AT=610.025n

.meas tran vdout0_9ck1210 FIND v(dout0_9) AT=610.025n

.meas tran vdout0_10ck1210 FIND v(dout0_10) AT=610.025n

.meas tran vdout0_11ck1210 FIND v(dout0_11) AT=610.025n

.meas tran vdout0_12ck1210 FIND v(dout0_12) AT=610.025n

.meas tran vdout0_13ck1210 FIND v(dout0_13) AT=610.025n

.meas tran vdout0_14ck1210 FIND v(dout0_14) AT=610.025n

.meas tran vdout0_15ck1210 FIND v(dout0_15) AT=610.025n

.meas tran vdout0_16ck1210 FIND v(dout0_16) AT=610.025n

.meas tran vdout0_17ck1210 FIND v(dout0_17) AT=610.025n

.meas tran vdout0_18ck1210 FIND v(dout0_18) AT=610.025n

.meas tran vdout0_19ck1210 FIND v(dout0_19) AT=610.025n

.meas tran vdout0_20ck1210 FIND v(dout0_20) AT=610.025n

.meas tran vdout0_21ck1210 FIND v(dout0_21) AT=610.025n

.meas tran vdout0_22ck1210 FIND v(dout0_22) AT=610.025n

.meas tran vdout0_23ck1210 FIND v(dout0_23) AT=610.025n

.meas tran vdout0_24ck1210 FIND v(dout0_24) AT=610.025n

.meas tran vdout0_25ck1210 FIND v(dout0_25) AT=610.025n

.meas tran vdout0_26ck1210 FIND v(dout0_26) AT=610.025n

.meas tran vdout0_27ck1210 FIND v(dout0_27) AT=610.025n

.meas tran vdout0_28ck1210 FIND v(dout0_28) AT=610.025n

.meas tran vdout0_29ck1210 FIND v(dout0_29) AT=610.025n

.meas tran vdout0_30ck1210 FIND v(dout0_30) AT=610.025n

.meas tran vdout0_31ck1210 FIND v(dout0_31) AT=610.025n

.meas tran vdout0_32ck1210 FIND v(dout0_32) AT=610.025n

.meas tran vdout0_33ck1210 FIND v(dout0_33) AT=610.025n

.meas tran vdout0_34ck1210 FIND v(dout0_34) AT=610.025n

.meas tran vdout0_35ck1210 FIND v(dout0_35) AT=610.025n

.meas tran vdout0_36ck1210 FIND v(dout0_36) AT=610.025n

.meas tran vdout0_37ck1210 FIND v(dout0_37) AT=610.025n

.meas tran vdout0_38ck1210 FIND v(dout0_38) AT=610.025n

.meas tran vdout0_39ck1210 FIND v(dout0_39) AT=610.025n

.meas tran vdout0_40ck1210 FIND v(dout0_40) AT=610.025n

.meas tran vdout0_41ck1210 FIND v(dout0_41) AT=610.025n

.meas tran vdout0_42ck1210 FIND v(dout0_42) AT=610.025n

.meas tran vdout0_43ck1210 FIND v(dout0_43) AT=610.025n

.meas tran vdout0_44ck1210 FIND v(dout0_44) AT=610.025n

.meas tran vdout0_45ck1210 FIND v(dout0_45) AT=610.025n

.meas tran vdout0_46ck1210 FIND v(dout0_46) AT=610.025n

.meas tran vdout0_47ck1210 FIND v(dout0_47) AT=610.025n

.meas tran vdout0_48ck1210 FIND v(dout0_48) AT=610.025n

.meas tran vdout0_49ck1210 FIND v(dout0_49) AT=610.025n

.meas tran vdout0_50ck1210 FIND v(dout0_50) AT=610.025n

.meas tran vdout0_51ck1210 FIND v(dout0_51) AT=610.025n

.meas tran vdout0_52ck1210 FIND v(dout0_52) AT=610.025n

.meas tran vdout0_53ck1210 FIND v(dout0_53) AT=610.025n

.meas tran vdout0_54ck1210 FIND v(dout0_54) AT=610.025n

.meas tran vdout0_55ck1210 FIND v(dout0_55) AT=610.025n

.meas tran vdout0_56ck1210 FIND v(dout0_56) AT=610.025n

.meas tran vdout0_57ck1210 FIND v(dout0_57) AT=610.025n

.meas tran vdout0_58ck1210 FIND v(dout0_58) AT=610.025n

.meas tran vdout0_59ck1210 FIND v(dout0_59) AT=610.025n

.meas tran vdout0_60ck1210 FIND v(dout0_60) AT=610.025n

.meas tran vdout0_61ck1210 FIND v(dout0_61) AT=610.025n

.meas tran vdout0_62ck1210 FIND v(dout0_62) AT=610.025n

.meas tran vdout0_63ck1210 FIND v(dout0_63) AT=610.025n

.meas tran vdout0_64ck1210 FIND v(dout0_64) AT=610.025n

.meas tran vdout0_65ck1210 FIND v(dout0_65) AT=610.025n

.meas tran vdout0_66ck1210 FIND v(dout0_66) AT=610.025n

.meas tran vdout0_67ck1210 FIND v(dout0_67) AT=610.025n

.meas tran vdout0_68ck1210 FIND v(dout0_68) AT=610.025n

.meas tran vdout0_69ck1210 FIND v(dout0_69) AT=610.025n

.meas tran vdout0_70ck1210 FIND v(dout0_70) AT=610.025n

.meas tran vdout0_71ck1210 FIND v(dout0_71) AT=610.025n

.meas tran vdout0_72ck1210 FIND v(dout0_72) AT=610.025n

.meas tran vdout0_73ck1210 FIND v(dout0_73) AT=610.025n

.meas tran vdout0_74ck1210 FIND v(dout0_74) AT=610.025n

.meas tran vdout0_75ck1210 FIND v(dout0_75) AT=610.025n

.meas tran vdout0_76ck1210 FIND v(dout0_76) AT=610.025n

.meas tran vdout0_77ck1210 FIND v(dout0_77) AT=610.025n

.meas tran vdout0_78ck1210 FIND v(dout0_78) AT=610.025n

.meas tran vdout0_79ck1210 FIND v(dout0_79) AT=610.025n

.meas tran vdout0_80ck1210 FIND v(dout0_80) AT=610.025n

.meas tran vdout0_81ck1210 FIND v(dout0_81) AT=610.025n

.meas tran vdout0_82ck1210 FIND v(dout0_82) AT=610.025n

.meas tran vdout0_83ck1210 FIND v(dout0_83) AT=610.025n

.meas tran vdout0_84ck1210 FIND v(dout0_84) AT=610.025n

.meas tran vdout0_85ck1210 FIND v(dout0_85) AT=610.025n

.meas tran vdout0_86ck1210 FIND v(dout0_86) AT=610.025n

.meas tran vdout0_87ck1210 FIND v(dout0_87) AT=610.025n

.meas tran vdout0_88ck1210 FIND v(dout0_88) AT=610.025n

.meas tran vdout0_89ck1210 FIND v(dout0_89) AT=610.025n

.meas tran vdout0_90ck1210 FIND v(dout0_90) AT=610.025n

.meas tran vdout0_91ck1210 FIND v(dout0_91) AT=610.025n

.meas tran vdout0_92ck1210 FIND v(dout0_92) AT=610.025n

.meas tran vdout0_93ck1210 FIND v(dout0_93) AT=610.025n

.meas tran vdout0_94ck1210 FIND v(dout0_94) AT=610.025n

.meas tran vdout0_95ck1210 FIND v(dout0_95) AT=610.025n

.meas tran vdout0_96ck1210 FIND v(dout0_96) AT=610.025n

.meas tran vdout0_97ck1210 FIND v(dout0_97) AT=610.025n

.meas tran vdout0_98ck1210 FIND v(dout0_98) AT=610.025n

.meas tran vdout0_99ck1210 FIND v(dout0_99) AT=610.025n

.meas tran vdout0_100ck1210 FIND v(dout0_100) AT=610.025n

.meas tran vdout0_101ck1210 FIND v(dout0_101) AT=610.025n

.meas tran vdout0_102ck1210 FIND v(dout0_102) AT=610.025n

.meas tran vdout0_103ck1210 FIND v(dout0_103) AT=610.025n

.meas tran vdout0_104ck1210 FIND v(dout0_104) AT=610.025n

.meas tran vdout0_105ck1210 FIND v(dout0_105) AT=610.025n

.meas tran vdout0_106ck1210 FIND v(dout0_106) AT=610.025n

.meas tran vdout0_107ck1210 FIND v(dout0_107) AT=610.025n

.meas tran vdout0_108ck1210 FIND v(dout0_108) AT=610.025n

.meas tran vdout0_109ck1210 FIND v(dout0_109) AT=610.025n

.meas tran vdout0_110ck1210 FIND v(dout0_110) AT=610.025n

.meas tran vdout0_111ck1210 FIND v(dout0_111) AT=610.025n

.meas tran vdout0_112ck1210 FIND v(dout0_112) AT=610.025n

.meas tran vdout0_113ck1210 FIND v(dout0_113) AT=610.025n

.meas tran vdout0_114ck1210 FIND v(dout0_114) AT=610.025n

.meas tran vdout0_115ck1210 FIND v(dout0_115) AT=610.025n

.meas tran vdout0_116ck1210 FIND v(dout0_116) AT=610.025n

.meas tran vdout0_117ck1210 FIND v(dout0_117) AT=610.025n

.meas tran vdout0_118ck1210 FIND v(dout0_118) AT=610.025n

.meas tran vdout0_119ck1210 FIND v(dout0_119) AT=610.025n

.meas tran vdout0_120ck1210 FIND v(dout0_120) AT=610.025n

.meas tran vdout0_121ck1210 FIND v(dout0_121) AT=610.025n

.meas tran vdout0_122ck1210 FIND v(dout0_122) AT=610.025n

.meas tran vdout0_123ck1210 FIND v(dout0_123) AT=610.025n

.meas tran vdout0_124ck1210 FIND v(dout0_124) AT=610.025n

.meas tran vdout0_125ck1210 FIND v(dout0_125) AT=610.025n

.meas tran vdout0_126ck1210 FIND v(dout0_126) AT=610.025n

.meas tran vdout0_127ck1210 FIND v(dout0_127) AT=610.025n

.meas tran vdout0_128ck1210 FIND v(dout0_128) AT=610.025n

.meas tran vdout0_129ck1210 FIND v(dout0_129) AT=610.025n

.meas tran vdout0_130ck1210 FIND v(dout0_130) AT=610.025n

.meas tran vdout0_131ck1210 FIND v(dout0_131) AT=610.025n

.meas tran vdout0_132ck1210 FIND v(dout0_132) AT=610.025n

.meas tran vdout0_133ck1210 FIND v(dout0_133) AT=610.025n

.meas tran vdout0_134ck1210 FIND v(dout0_134) AT=610.025n

.meas tran vdout0_135ck1210 FIND v(dout0_135) AT=610.025n

.meas tran vdout0_136ck1210 FIND v(dout0_136) AT=610.025n

.meas tran vdout0_137ck1210 FIND v(dout0_137) AT=610.025n

.meas tran vdout0_138ck1210 FIND v(dout0_138) AT=610.025n

.meas tran vdout0_139ck1210 FIND v(dout0_139) AT=610.025n

.meas tran vdout0_140ck1210 FIND v(dout0_140) AT=610.025n

.meas tran vdout0_141ck1210 FIND v(dout0_141) AT=610.025n

.meas tran vdout0_142ck1210 FIND v(dout0_142) AT=610.025n

.meas tran vdout0_143ck1210 FIND v(dout0_143) AT=610.025n

.meas tran vdout0_144ck1210 FIND v(dout0_144) AT=610.025n

.meas tran vdout0_145ck1210 FIND v(dout0_145) AT=610.025n

.meas tran vdout0_146ck1210 FIND v(dout0_146) AT=610.025n

.meas tran vdout0_147ck1210 FIND v(dout0_147) AT=610.025n

.meas tran vdout0_148ck1210 FIND v(dout0_148) AT=610.025n

.meas tran vdout0_149ck1210 FIND v(dout0_149) AT=610.025n

.meas tran vdout0_0ck1220 FIND v(dout0_0) AT=615.025n

.meas tran vdout0_1ck1220 FIND v(dout0_1) AT=615.025n

.meas tran vdout0_2ck1220 FIND v(dout0_2) AT=615.025n

.meas tran vdout0_3ck1220 FIND v(dout0_3) AT=615.025n

.meas tran vdout0_4ck1220 FIND v(dout0_4) AT=615.025n

.meas tran vdout0_5ck1220 FIND v(dout0_5) AT=615.025n

.meas tran vdout0_6ck1220 FIND v(dout0_6) AT=615.025n

.meas tran vdout0_7ck1220 FIND v(dout0_7) AT=615.025n

.meas tran vdout0_8ck1220 FIND v(dout0_8) AT=615.025n

.meas tran vdout0_9ck1220 FIND v(dout0_9) AT=615.025n

.meas tran vdout0_10ck1220 FIND v(dout0_10) AT=615.025n

.meas tran vdout0_11ck1220 FIND v(dout0_11) AT=615.025n

.meas tran vdout0_12ck1220 FIND v(dout0_12) AT=615.025n

.meas tran vdout0_13ck1220 FIND v(dout0_13) AT=615.025n

.meas tran vdout0_14ck1220 FIND v(dout0_14) AT=615.025n

.meas tran vdout0_15ck1220 FIND v(dout0_15) AT=615.025n

.meas tran vdout0_16ck1220 FIND v(dout0_16) AT=615.025n

.meas tran vdout0_17ck1220 FIND v(dout0_17) AT=615.025n

.meas tran vdout0_18ck1220 FIND v(dout0_18) AT=615.025n

.meas tran vdout0_19ck1220 FIND v(dout0_19) AT=615.025n

.meas tran vdout0_20ck1220 FIND v(dout0_20) AT=615.025n

.meas tran vdout0_21ck1220 FIND v(dout0_21) AT=615.025n

.meas tran vdout0_22ck1220 FIND v(dout0_22) AT=615.025n

.meas tran vdout0_23ck1220 FIND v(dout0_23) AT=615.025n

.meas tran vdout0_24ck1220 FIND v(dout0_24) AT=615.025n

.meas tran vdout0_25ck1220 FIND v(dout0_25) AT=615.025n

.meas tran vdout0_26ck1220 FIND v(dout0_26) AT=615.025n

.meas tran vdout0_27ck1220 FIND v(dout0_27) AT=615.025n

.meas tran vdout0_28ck1220 FIND v(dout0_28) AT=615.025n

.meas tran vdout0_29ck1220 FIND v(dout0_29) AT=615.025n

.meas tran vdout0_30ck1220 FIND v(dout0_30) AT=615.025n

.meas tran vdout0_31ck1220 FIND v(dout0_31) AT=615.025n

.meas tran vdout0_32ck1220 FIND v(dout0_32) AT=615.025n

.meas tran vdout0_33ck1220 FIND v(dout0_33) AT=615.025n

.meas tran vdout0_34ck1220 FIND v(dout0_34) AT=615.025n

.meas tran vdout0_35ck1220 FIND v(dout0_35) AT=615.025n

.meas tran vdout0_36ck1220 FIND v(dout0_36) AT=615.025n

.meas tran vdout0_37ck1220 FIND v(dout0_37) AT=615.025n

.meas tran vdout0_38ck1220 FIND v(dout0_38) AT=615.025n

.meas tran vdout0_39ck1220 FIND v(dout0_39) AT=615.025n

.meas tran vdout0_40ck1220 FIND v(dout0_40) AT=615.025n

.meas tran vdout0_41ck1220 FIND v(dout0_41) AT=615.025n

.meas tran vdout0_42ck1220 FIND v(dout0_42) AT=615.025n

.meas tran vdout0_43ck1220 FIND v(dout0_43) AT=615.025n

.meas tran vdout0_44ck1220 FIND v(dout0_44) AT=615.025n

.meas tran vdout0_45ck1220 FIND v(dout0_45) AT=615.025n

.meas tran vdout0_46ck1220 FIND v(dout0_46) AT=615.025n

.meas tran vdout0_47ck1220 FIND v(dout0_47) AT=615.025n

.meas tran vdout0_48ck1220 FIND v(dout0_48) AT=615.025n

.meas tran vdout0_49ck1220 FIND v(dout0_49) AT=615.025n

.meas tran vdout0_50ck1220 FIND v(dout0_50) AT=615.025n

.meas tran vdout0_51ck1220 FIND v(dout0_51) AT=615.025n

.meas tran vdout0_52ck1220 FIND v(dout0_52) AT=615.025n

.meas tran vdout0_53ck1220 FIND v(dout0_53) AT=615.025n

.meas tran vdout0_54ck1220 FIND v(dout0_54) AT=615.025n

.meas tran vdout0_55ck1220 FIND v(dout0_55) AT=615.025n

.meas tran vdout0_56ck1220 FIND v(dout0_56) AT=615.025n

.meas tran vdout0_57ck1220 FIND v(dout0_57) AT=615.025n

.meas tran vdout0_58ck1220 FIND v(dout0_58) AT=615.025n

.meas tran vdout0_59ck1220 FIND v(dout0_59) AT=615.025n

.meas tran vdout0_60ck1220 FIND v(dout0_60) AT=615.025n

.meas tran vdout0_61ck1220 FIND v(dout0_61) AT=615.025n

.meas tran vdout0_62ck1220 FIND v(dout0_62) AT=615.025n

.meas tran vdout0_63ck1220 FIND v(dout0_63) AT=615.025n

.meas tran vdout0_64ck1220 FIND v(dout0_64) AT=615.025n

.meas tran vdout0_65ck1220 FIND v(dout0_65) AT=615.025n

.meas tran vdout0_66ck1220 FIND v(dout0_66) AT=615.025n

.meas tran vdout0_67ck1220 FIND v(dout0_67) AT=615.025n

.meas tran vdout0_68ck1220 FIND v(dout0_68) AT=615.025n

.meas tran vdout0_69ck1220 FIND v(dout0_69) AT=615.025n

.meas tran vdout0_70ck1220 FIND v(dout0_70) AT=615.025n

.meas tran vdout0_71ck1220 FIND v(dout0_71) AT=615.025n

.meas tran vdout0_72ck1220 FIND v(dout0_72) AT=615.025n

.meas tran vdout0_73ck1220 FIND v(dout0_73) AT=615.025n

.meas tran vdout0_74ck1220 FIND v(dout0_74) AT=615.025n

.meas tran vdout0_75ck1220 FIND v(dout0_75) AT=615.025n

.meas tran vdout0_76ck1220 FIND v(dout0_76) AT=615.025n

.meas tran vdout0_77ck1220 FIND v(dout0_77) AT=615.025n

.meas tran vdout0_78ck1220 FIND v(dout0_78) AT=615.025n

.meas tran vdout0_79ck1220 FIND v(dout0_79) AT=615.025n

.meas tran vdout0_80ck1220 FIND v(dout0_80) AT=615.025n

.meas tran vdout0_81ck1220 FIND v(dout0_81) AT=615.025n

.meas tran vdout0_82ck1220 FIND v(dout0_82) AT=615.025n

.meas tran vdout0_83ck1220 FIND v(dout0_83) AT=615.025n

.meas tran vdout0_84ck1220 FIND v(dout0_84) AT=615.025n

.meas tran vdout0_85ck1220 FIND v(dout0_85) AT=615.025n

.meas tran vdout0_86ck1220 FIND v(dout0_86) AT=615.025n

.meas tran vdout0_87ck1220 FIND v(dout0_87) AT=615.025n

.meas tran vdout0_88ck1220 FIND v(dout0_88) AT=615.025n

.meas tran vdout0_89ck1220 FIND v(dout0_89) AT=615.025n

.meas tran vdout0_90ck1220 FIND v(dout0_90) AT=615.025n

.meas tran vdout0_91ck1220 FIND v(dout0_91) AT=615.025n

.meas tran vdout0_92ck1220 FIND v(dout0_92) AT=615.025n

.meas tran vdout0_93ck1220 FIND v(dout0_93) AT=615.025n

.meas tran vdout0_94ck1220 FIND v(dout0_94) AT=615.025n

.meas tran vdout0_95ck1220 FIND v(dout0_95) AT=615.025n

.meas tran vdout0_96ck1220 FIND v(dout0_96) AT=615.025n

.meas tran vdout0_97ck1220 FIND v(dout0_97) AT=615.025n

.meas tran vdout0_98ck1220 FIND v(dout0_98) AT=615.025n

.meas tran vdout0_99ck1220 FIND v(dout0_99) AT=615.025n

.meas tran vdout0_100ck1220 FIND v(dout0_100) AT=615.025n

.meas tran vdout0_101ck1220 FIND v(dout0_101) AT=615.025n

.meas tran vdout0_102ck1220 FIND v(dout0_102) AT=615.025n

.meas tran vdout0_103ck1220 FIND v(dout0_103) AT=615.025n

.meas tran vdout0_104ck1220 FIND v(dout0_104) AT=615.025n

.meas tran vdout0_105ck1220 FIND v(dout0_105) AT=615.025n

.meas tran vdout0_106ck1220 FIND v(dout0_106) AT=615.025n

.meas tran vdout0_107ck1220 FIND v(dout0_107) AT=615.025n

.meas tran vdout0_108ck1220 FIND v(dout0_108) AT=615.025n

.meas tran vdout0_109ck1220 FIND v(dout0_109) AT=615.025n

.meas tran vdout0_110ck1220 FIND v(dout0_110) AT=615.025n

.meas tran vdout0_111ck1220 FIND v(dout0_111) AT=615.025n

.meas tran vdout0_112ck1220 FIND v(dout0_112) AT=615.025n

.meas tran vdout0_113ck1220 FIND v(dout0_113) AT=615.025n

.meas tran vdout0_114ck1220 FIND v(dout0_114) AT=615.025n

.meas tran vdout0_115ck1220 FIND v(dout0_115) AT=615.025n

.meas tran vdout0_116ck1220 FIND v(dout0_116) AT=615.025n

.meas tran vdout0_117ck1220 FIND v(dout0_117) AT=615.025n

.meas tran vdout0_118ck1220 FIND v(dout0_118) AT=615.025n

.meas tran vdout0_119ck1220 FIND v(dout0_119) AT=615.025n

.meas tran vdout0_120ck1220 FIND v(dout0_120) AT=615.025n

.meas tran vdout0_121ck1220 FIND v(dout0_121) AT=615.025n

.meas tran vdout0_122ck1220 FIND v(dout0_122) AT=615.025n

.meas tran vdout0_123ck1220 FIND v(dout0_123) AT=615.025n

.meas tran vdout0_124ck1220 FIND v(dout0_124) AT=615.025n

.meas tran vdout0_125ck1220 FIND v(dout0_125) AT=615.025n

.meas tran vdout0_126ck1220 FIND v(dout0_126) AT=615.025n

.meas tran vdout0_127ck1220 FIND v(dout0_127) AT=615.025n

.meas tran vdout0_128ck1220 FIND v(dout0_128) AT=615.025n

.meas tran vdout0_129ck1220 FIND v(dout0_129) AT=615.025n

.meas tran vdout0_130ck1220 FIND v(dout0_130) AT=615.025n

.meas tran vdout0_131ck1220 FIND v(dout0_131) AT=615.025n

.meas tran vdout0_132ck1220 FIND v(dout0_132) AT=615.025n

.meas tran vdout0_133ck1220 FIND v(dout0_133) AT=615.025n

.meas tran vdout0_134ck1220 FIND v(dout0_134) AT=615.025n

.meas tran vdout0_135ck1220 FIND v(dout0_135) AT=615.025n

.meas tran vdout0_136ck1220 FIND v(dout0_136) AT=615.025n

.meas tran vdout0_137ck1220 FIND v(dout0_137) AT=615.025n

.meas tran vdout0_138ck1220 FIND v(dout0_138) AT=615.025n

.meas tran vdout0_139ck1220 FIND v(dout0_139) AT=615.025n

.meas tran vdout0_140ck1220 FIND v(dout0_140) AT=615.025n

.meas tran vdout0_141ck1220 FIND v(dout0_141) AT=615.025n

.meas tran vdout0_142ck1220 FIND v(dout0_142) AT=615.025n

.meas tran vdout0_143ck1220 FIND v(dout0_143) AT=615.025n

.meas tran vdout0_144ck1220 FIND v(dout0_144) AT=615.025n

.meas tran vdout0_145ck1220 FIND v(dout0_145) AT=615.025n

.meas tran vdout0_146ck1220 FIND v(dout0_146) AT=615.025n

.meas tran vdout0_147ck1220 FIND v(dout0_147) AT=615.025n

.meas tran vdout0_148ck1220 FIND v(dout0_148) AT=615.025n

.meas tran vdout0_149ck1220 FIND v(dout0_149) AT=615.025n

.meas tran vdout0_0ck1230 FIND v(dout0_0) AT=620.025n

.meas tran vdout0_1ck1230 FIND v(dout0_1) AT=620.025n

.meas tran vdout0_2ck1230 FIND v(dout0_2) AT=620.025n

.meas tran vdout0_3ck1230 FIND v(dout0_3) AT=620.025n

.meas tran vdout0_4ck1230 FIND v(dout0_4) AT=620.025n

.meas tran vdout0_5ck1230 FIND v(dout0_5) AT=620.025n

.meas tran vdout0_6ck1230 FIND v(dout0_6) AT=620.025n

.meas tran vdout0_7ck1230 FIND v(dout0_7) AT=620.025n

.meas tran vdout0_8ck1230 FIND v(dout0_8) AT=620.025n

.meas tran vdout0_9ck1230 FIND v(dout0_9) AT=620.025n

.meas tran vdout0_10ck1230 FIND v(dout0_10) AT=620.025n

.meas tran vdout0_11ck1230 FIND v(dout0_11) AT=620.025n

.meas tran vdout0_12ck1230 FIND v(dout0_12) AT=620.025n

.meas tran vdout0_13ck1230 FIND v(dout0_13) AT=620.025n

.meas tran vdout0_14ck1230 FIND v(dout0_14) AT=620.025n

.meas tran vdout0_15ck1230 FIND v(dout0_15) AT=620.025n

.meas tran vdout0_16ck1230 FIND v(dout0_16) AT=620.025n

.meas tran vdout0_17ck1230 FIND v(dout0_17) AT=620.025n

.meas tran vdout0_18ck1230 FIND v(dout0_18) AT=620.025n

.meas tran vdout0_19ck1230 FIND v(dout0_19) AT=620.025n

.meas tran vdout0_20ck1230 FIND v(dout0_20) AT=620.025n

.meas tran vdout0_21ck1230 FIND v(dout0_21) AT=620.025n

.meas tran vdout0_22ck1230 FIND v(dout0_22) AT=620.025n

.meas tran vdout0_23ck1230 FIND v(dout0_23) AT=620.025n

.meas tran vdout0_24ck1230 FIND v(dout0_24) AT=620.025n

.meas tran vdout0_25ck1230 FIND v(dout0_25) AT=620.025n

.meas tran vdout0_26ck1230 FIND v(dout0_26) AT=620.025n

.meas tran vdout0_27ck1230 FIND v(dout0_27) AT=620.025n

.meas tran vdout0_28ck1230 FIND v(dout0_28) AT=620.025n

.meas tran vdout0_29ck1230 FIND v(dout0_29) AT=620.025n

.meas tran vdout0_30ck1230 FIND v(dout0_30) AT=620.025n

.meas tran vdout0_31ck1230 FIND v(dout0_31) AT=620.025n

.meas tran vdout0_32ck1230 FIND v(dout0_32) AT=620.025n

.meas tran vdout0_33ck1230 FIND v(dout0_33) AT=620.025n

.meas tran vdout0_34ck1230 FIND v(dout0_34) AT=620.025n

.meas tran vdout0_35ck1230 FIND v(dout0_35) AT=620.025n

.meas tran vdout0_36ck1230 FIND v(dout0_36) AT=620.025n

.meas tran vdout0_37ck1230 FIND v(dout0_37) AT=620.025n

.meas tran vdout0_38ck1230 FIND v(dout0_38) AT=620.025n

.meas tran vdout0_39ck1230 FIND v(dout0_39) AT=620.025n

.meas tran vdout0_40ck1230 FIND v(dout0_40) AT=620.025n

.meas tran vdout0_41ck1230 FIND v(dout0_41) AT=620.025n

.meas tran vdout0_42ck1230 FIND v(dout0_42) AT=620.025n

.meas tran vdout0_43ck1230 FIND v(dout0_43) AT=620.025n

.meas tran vdout0_44ck1230 FIND v(dout0_44) AT=620.025n

.meas tran vdout0_45ck1230 FIND v(dout0_45) AT=620.025n

.meas tran vdout0_46ck1230 FIND v(dout0_46) AT=620.025n

.meas tran vdout0_47ck1230 FIND v(dout0_47) AT=620.025n

.meas tran vdout0_48ck1230 FIND v(dout0_48) AT=620.025n

.meas tran vdout0_49ck1230 FIND v(dout0_49) AT=620.025n

.meas tran vdout0_50ck1230 FIND v(dout0_50) AT=620.025n

.meas tran vdout0_51ck1230 FIND v(dout0_51) AT=620.025n

.meas tran vdout0_52ck1230 FIND v(dout0_52) AT=620.025n

.meas tran vdout0_53ck1230 FIND v(dout0_53) AT=620.025n

.meas tran vdout0_54ck1230 FIND v(dout0_54) AT=620.025n

.meas tran vdout0_55ck1230 FIND v(dout0_55) AT=620.025n

.meas tran vdout0_56ck1230 FIND v(dout0_56) AT=620.025n

.meas tran vdout0_57ck1230 FIND v(dout0_57) AT=620.025n

.meas tran vdout0_58ck1230 FIND v(dout0_58) AT=620.025n

.meas tran vdout0_59ck1230 FIND v(dout0_59) AT=620.025n

.meas tran vdout0_60ck1230 FIND v(dout0_60) AT=620.025n

.meas tran vdout0_61ck1230 FIND v(dout0_61) AT=620.025n

.meas tran vdout0_62ck1230 FIND v(dout0_62) AT=620.025n

.meas tran vdout0_63ck1230 FIND v(dout0_63) AT=620.025n

.meas tran vdout0_64ck1230 FIND v(dout0_64) AT=620.025n

.meas tran vdout0_65ck1230 FIND v(dout0_65) AT=620.025n

.meas tran vdout0_66ck1230 FIND v(dout0_66) AT=620.025n

.meas tran vdout0_67ck1230 FIND v(dout0_67) AT=620.025n

.meas tran vdout0_68ck1230 FIND v(dout0_68) AT=620.025n

.meas tran vdout0_69ck1230 FIND v(dout0_69) AT=620.025n

.meas tran vdout0_70ck1230 FIND v(dout0_70) AT=620.025n

.meas tran vdout0_71ck1230 FIND v(dout0_71) AT=620.025n

.meas tran vdout0_72ck1230 FIND v(dout0_72) AT=620.025n

.meas tran vdout0_73ck1230 FIND v(dout0_73) AT=620.025n

.meas tran vdout0_74ck1230 FIND v(dout0_74) AT=620.025n

.meas tran vdout0_75ck1230 FIND v(dout0_75) AT=620.025n

.meas tran vdout0_76ck1230 FIND v(dout0_76) AT=620.025n

.meas tran vdout0_77ck1230 FIND v(dout0_77) AT=620.025n

.meas tran vdout0_78ck1230 FIND v(dout0_78) AT=620.025n

.meas tran vdout0_79ck1230 FIND v(dout0_79) AT=620.025n

.meas tran vdout0_80ck1230 FIND v(dout0_80) AT=620.025n

.meas tran vdout0_81ck1230 FIND v(dout0_81) AT=620.025n

.meas tran vdout0_82ck1230 FIND v(dout0_82) AT=620.025n

.meas tran vdout0_83ck1230 FIND v(dout0_83) AT=620.025n

.meas tran vdout0_84ck1230 FIND v(dout0_84) AT=620.025n

.meas tran vdout0_85ck1230 FIND v(dout0_85) AT=620.025n

.meas tran vdout0_86ck1230 FIND v(dout0_86) AT=620.025n

.meas tran vdout0_87ck1230 FIND v(dout0_87) AT=620.025n

.meas tran vdout0_88ck1230 FIND v(dout0_88) AT=620.025n

.meas tran vdout0_89ck1230 FIND v(dout0_89) AT=620.025n

.meas tran vdout0_90ck1230 FIND v(dout0_90) AT=620.025n

.meas tran vdout0_91ck1230 FIND v(dout0_91) AT=620.025n

.meas tran vdout0_92ck1230 FIND v(dout0_92) AT=620.025n

.meas tran vdout0_93ck1230 FIND v(dout0_93) AT=620.025n

.meas tran vdout0_94ck1230 FIND v(dout0_94) AT=620.025n

.meas tran vdout0_95ck1230 FIND v(dout0_95) AT=620.025n

.meas tran vdout0_96ck1230 FIND v(dout0_96) AT=620.025n

.meas tran vdout0_97ck1230 FIND v(dout0_97) AT=620.025n

.meas tran vdout0_98ck1230 FIND v(dout0_98) AT=620.025n

.meas tran vdout0_99ck1230 FIND v(dout0_99) AT=620.025n

.meas tran vdout0_100ck1230 FIND v(dout0_100) AT=620.025n

.meas tran vdout0_101ck1230 FIND v(dout0_101) AT=620.025n

.meas tran vdout0_102ck1230 FIND v(dout0_102) AT=620.025n

.meas tran vdout0_103ck1230 FIND v(dout0_103) AT=620.025n

.meas tran vdout0_104ck1230 FIND v(dout0_104) AT=620.025n

.meas tran vdout0_105ck1230 FIND v(dout0_105) AT=620.025n

.meas tran vdout0_106ck1230 FIND v(dout0_106) AT=620.025n

.meas tran vdout0_107ck1230 FIND v(dout0_107) AT=620.025n

.meas tran vdout0_108ck1230 FIND v(dout0_108) AT=620.025n

.meas tran vdout0_109ck1230 FIND v(dout0_109) AT=620.025n

.meas tran vdout0_110ck1230 FIND v(dout0_110) AT=620.025n

.meas tran vdout0_111ck1230 FIND v(dout0_111) AT=620.025n

.meas tran vdout0_112ck1230 FIND v(dout0_112) AT=620.025n

.meas tran vdout0_113ck1230 FIND v(dout0_113) AT=620.025n

.meas tran vdout0_114ck1230 FIND v(dout0_114) AT=620.025n

.meas tran vdout0_115ck1230 FIND v(dout0_115) AT=620.025n

.meas tran vdout0_116ck1230 FIND v(dout0_116) AT=620.025n

.meas tran vdout0_117ck1230 FIND v(dout0_117) AT=620.025n

.meas tran vdout0_118ck1230 FIND v(dout0_118) AT=620.025n

.meas tran vdout0_119ck1230 FIND v(dout0_119) AT=620.025n

.meas tran vdout0_120ck1230 FIND v(dout0_120) AT=620.025n

.meas tran vdout0_121ck1230 FIND v(dout0_121) AT=620.025n

.meas tran vdout0_122ck1230 FIND v(dout0_122) AT=620.025n

.meas tran vdout0_123ck1230 FIND v(dout0_123) AT=620.025n

.meas tran vdout0_124ck1230 FIND v(dout0_124) AT=620.025n

.meas tran vdout0_125ck1230 FIND v(dout0_125) AT=620.025n

.meas tran vdout0_126ck1230 FIND v(dout0_126) AT=620.025n

.meas tran vdout0_127ck1230 FIND v(dout0_127) AT=620.025n

.meas tran vdout0_128ck1230 FIND v(dout0_128) AT=620.025n

.meas tran vdout0_129ck1230 FIND v(dout0_129) AT=620.025n

.meas tran vdout0_130ck1230 FIND v(dout0_130) AT=620.025n

.meas tran vdout0_131ck1230 FIND v(dout0_131) AT=620.025n

.meas tran vdout0_132ck1230 FIND v(dout0_132) AT=620.025n

.meas tran vdout0_133ck1230 FIND v(dout0_133) AT=620.025n

.meas tran vdout0_134ck1230 FIND v(dout0_134) AT=620.025n

.meas tran vdout0_135ck1230 FIND v(dout0_135) AT=620.025n

.meas tran vdout0_136ck1230 FIND v(dout0_136) AT=620.025n

.meas tran vdout0_137ck1230 FIND v(dout0_137) AT=620.025n

.meas tran vdout0_138ck1230 FIND v(dout0_138) AT=620.025n

.meas tran vdout0_139ck1230 FIND v(dout0_139) AT=620.025n

.meas tran vdout0_140ck1230 FIND v(dout0_140) AT=620.025n

.meas tran vdout0_141ck1230 FIND v(dout0_141) AT=620.025n

.meas tran vdout0_142ck1230 FIND v(dout0_142) AT=620.025n

.meas tran vdout0_143ck1230 FIND v(dout0_143) AT=620.025n

.meas tran vdout0_144ck1230 FIND v(dout0_144) AT=620.025n

.meas tran vdout0_145ck1230 FIND v(dout0_145) AT=620.025n

.meas tran vdout0_146ck1230 FIND v(dout0_146) AT=620.025n

.meas tran vdout0_147ck1230 FIND v(dout0_147) AT=620.025n

.meas tran vdout0_148ck1230 FIND v(dout0_148) AT=620.025n

.meas tran vdout0_149ck1230 FIND v(dout0_149) AT=620.025n

.meas tran vdout0_0ck1240 FIND v(dout0_0) AT=625.025n

.meas tran vdout0_1ck1240 FIND v(dout0_1) AT=625.025n

.meas tran vdout0_2ck1240 FIND v(dout0_2) AT=625.025n

.meas tran vdout0_3ck1240 FIND v(dout0_3) AT=625.025n

.meas tran vdout0_4ck1240 FIND v(dout0_4) AT=625.025n

.meas tran vdout0_5ck1240 FIND v(dout0_5) AT=625.025n

.meas tran vdout0_6ck1240 FIND v(dout0_6) AT=625.025n

.meas tran vdout0_7ck1240 FIND v(dout0_7) AT=625.025n

.meas tran vdout0_8ck1240 FIND v(dout0_8) AT=625.025n

.meas tran vdout0_9ck1240 FIND v(dout0_9) AT=625.025n

.meas tran vdout0_10ck1240 FIND v(dout0_10) AT=625.025n

.meas tran vdout0_11ck1240 FIND v(dout0_11) AT=625.025n

.meas tran vdout0_12ck1240 FIND v(dout0_12) AT=625.025n

.meas tran vdout0_13ck1240 FIND v(dout0_13) AT=625.025n

.meas tran vdout0_14ck1240 FIND v(dout0_14) AT=625.025n

.meas tran vdout0_15ck1240 FIND v(dout0_15) AT=625.025n

.meas tran vdout0_16ck1240 FIND v(dout0_16) AT=625.025n

.meas tran vdout0_17ck1240 FIND v(dout0_17) AT=625.025n

.meas tran vdout0_18ck1240 FIND v(dout0_18) AT=625.025n

.meas tran vdout0_19ck1240 FIND v(dout0_19) AT=625.025n

.meas tran vdout0_20ck1240 FIND v(dout0_20) AT=625.025n

.meas tran vdout0_21ck1240 FIND v(dout0_21) AT=625.025n

.meas tran vdout0_22ck1240 FIND v(dout0_22) AT=625.025n

.meas tran vdout0_23ck1240 FIND v(dout0_23) AT=625.025n

.meas tran vdout0_24ck1240 FIND v(dout0_24) AT=625.025n

.meas tran vdout0_25ck1240 FIND v(dout0_25) AT=625.025n

.meas tran vdout0_26ck1240 FIND v(dout0_26) AT=625.025n

.meas tran vdout0_27ck1240 FIND v(dout0_27) AT=625.025n

.meas tran vdout0_28ck1240 FIND v(dout0_28) AT=625.025n

.meas tran vdout0_29ck1240 FIND v(dout0_29) AT=625.025n

.meas tran vdout0_30ck1240 FIND v(dout0_30) AT=625.025n

.meas tran vdout0_31ck1240 FIND v(dout0_31) AT=625.025n

.meas tran vdout0_32ck1240 FIND v(dout0_32) AT=625.025n

.meas tran vdout0_33ck1240 FIND v(dout0_33) AT=625.025n

.meas tran vdout0_34ck1240 FIND v(dout0_34) AT=625.025n

.meas tran vdout0_35ck1240 FIND v(dout0_35) AT=625.025n

.meas tran vdout0_36ck1240 FIND v(dout0_36) AT=625.025n

.meas tran vdout0_37ck1240 FIND v(dout0_37) AT=625.025n

.meas tran vdout0_38ck1240 FIND v(dout0_38) AT=625.025n

.meas tran vdout0_39ck1240 FIND v(dout0_39) AT=625.025n

.meas tran vdout0_40ck1240 FIND v(dout0_40) AT=625.025n

.meas tran vdout0_41ck1240 FIND v(dout0_41) AT=625.025n

.meas tran vdout0_42ck1240 FIND v(dout0_42) AT=625.025n

.meas tran vdout0_43ck1240 FIND v(dout0_43) AT=625.025n

.meas tran vdout0_44ck1240 FIND v(dout0_44) AT=625.025n

.meas tran vdout0_45ck1240 FIND v(dout0_45) AT=625.025n

.meas tran vdout0_46ck1240 FIND v(dout0_46) AT=625.025n

.meas tran vdout0_47ck1240 FIND v(dout0_47) AT=625.025n

.meas tran vdout0_48ck1240 FIND v(dout0_48) AT=625.025n

.meas tran vdout0_49ck1240 FIND v(dout0_49) AT=625.025n

.meas tran vdout0_50ck1240 FIND v(dout0_50) AT=625.025n

.meas tran vdout0_51ck1240 FIND v(dout0_51) AT=625.025n

.meas tran vdout0_52ck1240 FIND v(dout0_52) AT=625.025n

.meas tran vdout0_53ck1240 FIND v(dout0_53) AT=625.025n

.meas tran vdout0_54ck1240 FIND v(dout0_54) AT=625.025n

.meas tran vdout0_55ck1240 FIND v(dout0_55) AT=625.025n

.meas tran vdout0_56ck1240 FIND v(dout0_56) AT=625.025n

.meas tran vdout0_57ck1240 FIND v(dout0_57) AT=625.025n

.meas tran vdout0_58ck1240 FIND v(dout0_58) AT=625.025n

.meas tran vdout0_59ck1240 FIND v(dout0_59) AT=625.025n

.meas tran vdout0_60ck1240 FIND v(dout0_60) AT=625.025n

.meas tran vdout0_61ck1240 FIND v(dout0_61) AT=625.025n

.meas tran vdout0_62ck1240 FIND v(dout0_62) AT=625.025n

.meas tran vdout0_63ck1240 FIND v(dout0_63) AT=625.025n

.meas tran vdout0_64ck1240 FIND v(dout0_64) AT=625.025n

.meas tran vdout0_65ck1240 FIND v(dout0_65) AT=625.025n

.meas tran vdout0_66ck1240 FIND v(dout0_66) AT=625.025n

.meas tran vdout0_67ck1240 FIND v(dout0_67) AT=625.025n

.meas tran vdout0_68ck1240 FIND v(dout0_68) AT=625.025n

.meas tran vdout0_69ck1240 FIND v(dout0_69) AT=625.025n

.meas tran vdout0_70ck1240 FIND v(dout0_70) AT=625.025n

.meas tran vdout0_71ck1240 FIND v(dout0_71) AT=625.025n

.meas tran vdout0_72ck1240 FIND v(dout0_72) AT=625.025n

.meas tran vdout0_73ck1240 FIND v(dout0_73) AT=625.025n

.meas tran vdout0_74ck1240 FIND v(dout0_74) AT=625.025n

.meas tran vdout0_75ck1240 FIND v(dout0_75) AT=625.025n

.meas tran vdout0_76ck1240 FIND v(dout0_76) AT=625.025n

.meas tran vdout0_77ck1240 FIND v(dout0_77) AT=625.025n

.meas tran vdout0_78ck1240 FIND v(dout0_78) AT=625.025n

.meas tran vdout0_79ck1240 FIND v(dout0_79) AT=625.025n

.meas tran vdout0_80ck1240 FIND v(dout0_80) AT=625.025n

.meas tran vdout0_81ck1240 FIND v(dout0_81) AT=625.025n

.meas tran vdout0_82ck1240 FIND v(dout0_82) AT=625.025n

.meas tran vdout0_83ck1240 FIND v(dout0_83) AT=625.025n

.meas tran vdout0_84ck1240 FIND v(dout0_84) AT=625.025n

.meas tran vdout0_85ck1240 FIND v(dout0_85) AT=625.025n

.meas tran vdout0_86ck1240 FIND v(dout0_86) AT=625.025n

.meas tran vdout0_87ck1240 FIND v(dout0_87) AT=625.025n

.meas tran vdout0_88ck1240 FIND v(dout0_88) AT=625.025n

.meas tran vdout0_89ck1240 FIND v(dout0_89) AT=625.025n

.meas tran vdout0_90ck1240 FIND v(dout0_90) AT=625.025n

.meas tran vdout0_91ck1240 FIND v(dout0_91) AT=625.025n

.meas tran vdout0_92ck1240 FIND v(dout0_92) AT=625.025n

.meas tran vdout0_93ck1240 FIND v(dout0_93) AT=625.025n

.meas tran vdout0_94ck1240 FIND v(dout0_94) AT=625.025n

.meas tran vdout0_95ck1240 FIND v(dout0_95) AT=625.025n

.meas tran vdout0_96ck1240 FIND v(dout0_96) AT=625.025n

.meas tran vdout0_97ck1240 FIND v(dout0_97) AT=625.025n

.meas tran vdout0_98ck1240 FIND v(dout0_98) AT=625.025n

.meas tran vdout0_99ck1240 FIND v(dout0_99) AT=625.025n

.meas tran vdout0_100ck1240 FIND v(dout0_100) AT=625.025n

.meas tran vdout0_101ck1240 FIND v(dout0_101) AT=625.025n

.meas tran vdout0_102ck1240 FIND v(dout0_102) AT=625.025n

.meas tran vdout0_103ck1240 FIND v(dout0_103) AT=625.025n

.meas tran vdout0_104ck1240 FIND v(dout0_104) AT=625.025n

.meas tran vdout0_105ck1240 FIND v(dout0_105) AT=625.025n

.meas tran vdout0_106ck1240 FIND v(dout0_106) AT=625.025n

.meas tran vdout0_107ck1240 FIND v(dout0_107) AT=625.025n

.meas tran vdout0_108ck1240 FIND v(dout0_108) AT=625.025n

.meas tran vdout0_109ck1240 FIND v(dout0_109) AT=625.025n

.meas tran vdout0_110ck1240 FIND v(dout0_110) AT=625.025n

.meas tran vdout0_111ck1240 FIND v(dout0_111) AT=625.025n

.meas tran vdout0_112ck1240 FIND v(dout0_112) AT=625.025n

.meas tran vdout0_113ck1240 FIND v(dout0_113) AT=625.025n

.meas tran vdout0_114ck1240 FIND v(dout0_114) AT=625.025n

.meas tran vdout0_115ck1240 FIND v(dout0_115) AT=625.025n

.meas tran vdout0_116ck1240 FIND v(dout0_116) AT=625.025n

.meas tran vdout0_117ck1240 FIND v(dout0_117) AT=625.025n

.meas tran vdout0_118ck1240 FIND v(dout0_118) AT=625.025n

.meas tran vdout0_119ck1240 FIND v(dout0_119) AT=625.025n

.meas tran vdout0_120ck1240 FIND v(dout0_120) AT=625.025n

.meas tran vdout0_121ck1240 FIND v(dout0_121) AT=625.025n

.meas tran vdout0_122ck1240 FIND v(dout0_122) AT=625.025n

.meas tran vdout0_123ck1240 FIND v(dout0_123) AT=625.025n

.meas tran vdout0_124ck1240 FIND v(dout0_124) AT=625.025n

.meas tran vdout0_125ck1240 FIND v(dout0_125) AT=625.025n

.meas tran vdout0_126ck1240 FIND v(dout0_126) AT=625.025n

.meas tran vdout0_127ck1240 FIND v(dout0_127) AT=625.025n

.meas tran vdout0_128ck1240 FIND v(dout0_128) AT=625.025n

.meas tran vdout0_129ck1240 FIND v(dout0_129) AT=625.025n

.meas tran vdout0_130ck1240 FIND v(dout0_130) AT=625.025n

.meas tran vdout0_131ck1240 FIND v(dout0_131) AT=625.025n

.meas tran vdout0_132ck1240 FIND v(dout0_132) AT=625.025n

.meas tran vdout0_133ck1240 FIND v(dout0_133) AT=625.025n

.meas tran vdout0_134ck1240 FIND v(dout0_134) AT=625.025n

.meas tran vdout0_135ck1240 FIND v(dout0_135) AT=625.025n

.meas tran vdout0_136ck1240 FIND v(dout0_136) AT=625.025n

.meas tran vdout0_137ck1240 FIND v(dout0_137) AT=625.025n

.meas tran vdout0_138ck1240 FIND v(dout0_138) AT=625.025n

.meas tran vdout0_139ck1240 FIND v(dout0_139) AT=625.025n

.meas tran vdout0_140ck1240 FIND v(dout0_140) AT=625.025n

.meas tran vdout0_141ck1240 FIND v(dout0_141) AT=625.025n

.meas tran vdout0_142ck1240 FIND v(dout0_142) AT=625.025n

.meas tran vdout0_143ck1240 FIND v(dout0_143) AT=625.025n

.meas tran vdout0_144ck1240 FIND v(dout0_144) AT=625.025n

.meas tran vdout0_145ck1240 FIND v(dout0_145) AT=625.025n

.meas tran vdout0_146ck1240 FIND v(dout0_146) AT=625.025n

.meas tran vdout0_147ck1240 FIND v(dout0_147) AT=625.025n

.meas tran vdout0_148ck1240 FIND v(dout0_148) AT=625.025n

.meas tran vdout0_149ck1240 FIND v(dout0_149) AT=625.025n

.meas tran vdout0_0ck1260 FIND v(dout0_0) AT=635.025n

.meas tran vdout0_1ck1260 FIND v(dout0_1) AT=635.025n

.meas tran vdout0_2ck1260 FIND v(dout0_2) AT=635.025n

.meas tran vdout0_3ck1260 FIND v(dout0_3) AT=635.025n

.meas tran vdout0_4ck1260 FIND v(dout0_4) AT=635.025n

.meas tran vdout0_5ck1260 FIND v(dout0_5) AT=635.025n

.meas tran vdout0_6ck1260 FIND v(dout0_6) AT=635.025n

.meas tran vdout0_7ck1260 FIND v(dout0_7) AT=635.025n

.meas tran vdout0_8ck1260 FIND v(dout0_8) AT=635.025n

.meas tran vdout0_9ck1260 FIND v(dout0_9) AT=635.025n

.meas tran vdout0_10ck1260 FIND v(dout0_10) AT=635.025n

.meas tran vdout0_11ck1260 FIND v(dout0_11) AT=635.025n

.meas tran vdout0_12ck1260 FIND v(dout0_12) AT=635.025n

.meas tran vdout0_13ck1260 FIND v(dout0_13) AT=635.025n

.meas tran vdout0_14ck1260 FIND v(dout0_14) AT=635.025n

.meas tran vdout0_15ck1260 FIND v(dout0_15) AT=635.025n

.meas tran vdout0_16ck1260 FIND v(dout0_16) AT=635.025n

.meas tran vdout0_17ck1260 FIND v(dout0_17) AT=635.025n

.meas tran vdout0_18ck1260 FIND v(dout0_18) AT=635.025n

.meas tran vdout0_19ck1260 FIND v(dout0_19) AT=635.025n

.meas tran vdout0_20ck1260 FIND v(dout0_20) AT=635.025n

.meas tran vdout0_21ck1260 FIND v(dout0_21) AT=635.025n

.meas tran vdout0_22ck1260 FIND v(dout0_22) AT=635.025n

.meas tran vdout0_23ck1260 FIND v(dout0_23) AT=635.025n

.meas tran vdout0_24ck1260 FIND v(dout0_24) AT=635.025n

.meas tran vdout0_25ck1260 FIND v(dout0_25) AT=635.025n

.meas tran vdout0_26ck1260 FIND v(dout0_26) AT=635.025n

.meas tran vdout0_27ck1260 FIND v(dout0_27) AT=635.025n

.meas tran vdout0_28ck1260 FIND v(dout0_28) AT=635.025n

.meas tran vdout0_29ck1260 FIND v(dout0_29) AT=635.025n

.meas tran vdout0_30ck1260 FIND v(dout0_30) AT=635.025n

.meas tran vdout0_31ck1260 FIND v(dout0_31) AT=635.025n

.meas tran vdout0_32ck1260 FIND v(dout0_32) AT=635.025n

.meas tran vdout0_33ck1260 FIND v(dout0_33) AT=635.025n

.meas tran vdout0_34ck1260 FIND v(dout0_34) AT=635.025n

.meas tran vdout0_35ck1260 FIND v(dout0_35) AT=635.025n

.meas tran vdout0_36ck1260 FIND v(dout0_36) AT=635.025n

.meas tran vdout0_37ck1260 FIND v(dout0_37) AT=635.025n

.meas tran vdout0_38ck1260 FIND v(dout0_38) AT=635.025n

.meas tran vdout0_39ck1260 FIND v(dout0_39) AT=635.025n

.meas tran vdout0_40ck1260 FIND v(dout0_40) AT=635.025n

.meas tran vdout0_41ck1260 FIND v(dout0_41) AT=635.025n

.meas tran vdout0_42ck1260 FIND v(dout0_42) AT=635.025n

.meas tran vdout0_43ck1260 FIND v(dout0_43) AT=635.025n

.meas tran vdout0_44ck1260 FIND v(dout0_44) AT=635.025n

.meas tran vdout0_45ck1260 FIND v(dout0_45) AT=635.025n

.meas tran vdout0_46ck1260 FIND v(dout0_46) AT=635.025n

.meas tran vdout0_47ck1260 FIND v(dout0_47) AT=635.025n

.meas tran vdout0_48ck1260 FIND v(dout0_48) AT=635.025n

.meas tran vdout0_49ck1260 FIND v(dout0_49) AT=635.025n

.meas tran vdout0_50ck1260 FIND v(dout0_50) AT=635.025n

.meas tran vdout0_51ck1260 FIND v(dout0_51) AT=635.025n

.meas tran vdout0_52ck1260 FIND v(dout0_52) AT=635.025n

.meas tran vdout0_53ck1260 FIND v(dout0_53) AT=635.025n

.meas tran vdout0_54ck1260 FIND v(dout0_54) AT=635.025n

.meas tran vdout0_55ck1260 FIND v(dout0_55) AT=635.025n

.meas tran vdout0_56ck1260 FIND v(dout0_56) AT=635.025n

.meas tran vdout0_57ck1260 FIND v(dout0_57) AT=635.025n

.meas tran vdout0_58ck1260 FIND v(dout0_58) AT=635.025n

.meas tran vdout0_59ck1260 FIND v(dout0_59) AT=635.025n

.meas tran vdout0_60ck1260 FIND v(dout0_60) AT=635.025n

.meas tran vdout0_61ck1260 FIND v(dout0_61) AT=635.025n

.meas tran vdout0_62ck1260 FIND v(dout0_62) AT=635.025n

.meas tran vdout0_63ck1260 FIND v(dout0_63) AT=635.025n

.meas tran vdout0_64ck1260 FIND v(dout0_64) AT=635.025n

.meas tran vdout0_65ck1260 FIND v(dout0_65) AT=635.025n

.meas tran vdout0_66ck1260 FIND v(dout0_66) AT=635.025n

.meas tran vdout0_67ck1260 FIND v(dout0_67) AT=635.025n

.meas tran vdout0_68ck1260 FIND v(dout0_68) AT=635.025n

.meas tran vdout0_69ck1260 FIND v(dout0_69) AT=635.025n

.meas tran vdout0_70ck1260 FIND v(dout0_70) AT=635.025n

.meas tran vdout0_71ck1260 FIND v(dout0_71) AT=635.025n

.meas tran vdout0_72ck1260 FIND v(dout0_72) AT=635.025n

.meas tran vdout0_73ck1260 FIND v(dout0_73) AT=635.025n

.meas tran vdout0_74ck1260 FIND v(dout0_74) AT=635.025n

.meas tran vdout0_75ck1260 FIND v(dout0_75) AT=635.025n

.meas tran vdout0_76ck1260 FIND v(dout0_76) AT=635.025n

.meas tran vdout0_77ck1260 FIND v(dout0_77) AT=635.025n

.meas tran vdout0_78ck1260 FIND v(dout0_78) AT=635.025n

.meas tran vdout0_79ck1260 FIND v(dout0_79) AT=635.025n

.meas tran vdout0_80ck1260 FIND v(dout0_80) AT=635.025n

.meas tran vdout0_81ck1260 FIND v(dout0_81) AT=635.025n

.meas tran vdout0_82ck1260 FIND v(dout0_82) AT=635.025n

.meas tran vdout0_83ck1260 FIND v(dout0_83) AT=635.025n

.meas tran vdout0_84ck1260 FIND v(dout0_84) AT=635.025n

.meas tran vdout0_85ck1260 FIND v(dout0_85) AT=635.025n

.meas tran vdout0_86ck1260 FIND v(dout0_86) AT=635.025n

.meas tran vdout0_87ck1260 FIND v(dout0_87) AT=635.025n

.meas tran vdout0_88ck1260 FIND v(dout0_88) AT=635.025n

.meas tran vdout0_89ck1260 FIND v(dout0_89) AT=635.025n

.meas tran vdout0_90ck1260 FIND v(dout0_90) AT=635.025n

.meas tran vdout0_91ck1260 FIND v(dout0_91) AT=635.025n

.meas tran vdout0_92ck1260 FIND v(dout0_92) AT=635.025n

.meas tran vdout0_93ck1260 FIND v(dout0_93) AT=635.025n

.meas tran vdout0_94ck1260 FIND v(dout0_94) AT=635.025n

.meas tran vdout0_95ck1260 FIND v(dout0_95) AT=635.025n

.meas tran vdout0_96ck1260 FIND v(dout0_96) AT=635.025n

.meas tran vdout0_97ck1260 FIND v(dout0_97) AT=635.025n

.meas tran vdout0_98ck1260 FIND v(dout0_98) AT=635.025n

.meas tran vdout0_99ck1260 FIND v(dout0_99) AT=635.025n

.meas tran vdout0_100ck1260 FIND v(dout0_100) AT=635.025n

.meas tran vdout0_101ck1260 FIND v(dout0_101) AT=635.025n

.meas tran vdout0_102ck1260 FIND v(dout0_102) AT=635.025n

.meas tran vdout0_103ck1260 FIND v(dout0_103) AT=635.025n

.meas tran vdout0_104ck1260 FIND v(dout0_104) AT=635.025n

.meas tran vdout0_105ck1260 FIND v(dout0_105) AT=635.025n

.meas tran vdout0_106ck1260 FIND v(dout0_106) AT=635.025n

.meas tran vdout0_107ck1260 FIND v(dout0_107) AT=635.025n

.meas tran vdout0_108ck1260 FIND v(dout0_108) AT=635.025n

.meas tran vdout0_109ck1260 FIND v(dout0_109) AT=635.025n

.meas tran vdout0_110ck1260 FIND v(dout0_110) AT=635.025n

.meas tran vdout0_111ck1260 FIND v(dout0_111) AT=635.025n

.meas tran vdout0_112ck1260 FIND v(dout0_112) AT=635.025n

.meas tran vdout0_113ck1260 FIND v(dout0_113) AT=635.025n

.meas tran vdout0_114ck1260 FIND v(dout0_114) AT=635.025n

.meas tran vdout0_115ck1260 FIND v(dout0_115) AT=635.025n

.meas tran vdout0_116ck1260 FIND v(dout0_116) AT=635.025n

.meas tran vdout0_117ck1260 FIND v(dout0_117) AT=635.025n

.meas tran vdout0_118ck1260 FIND v(dout0_118) AT=635.025n

.meas tran vdout0_119ck1260 FIND v(dout0_119) AT=635.025n

.meas tran vdout0_120ck1260 FIND v(dout0_120) AT=635.025n

.meas tran vdout0_121ck1260 FIND v(dout0_121) AT=635.025n

.meas tran vdout0_122ck1260 FIND v(dout0_122) AT=635.025n

.meas tran vdout0_123ck1260 FIND v(dout0_123) AT=635.025n

.meas tran vdout0_124ck1260 FIND v(dout0_124) AT=635.025n

.meas tran vdout0_125ck1260 FIND v(dout0_125) AT=635.025n

.meas tran vdout0_126ck1260 FIND v(dout0_126) AT=635.025n

.meas tran vdout0_127ck1260 FIND v(dout0_127) AT=635.025n

.meas tran vdout0_128ck1260 FIND v(dout0_128) AT=635.025n

.meas tran vdout0_129ck1260 FIND v(dout0_129) AT=635.025n

.meas tran vdout0_130ck1260 FIND v(dout0_130) AT=635.025n

.meas tran vdout0_131ck1260 FIND v(dout0_131) AT=635.025n

.meas tran vdout0_132ck1260 FIND v(dout0_132) AT=635.025n

.meas tran vdout0_133ck1260 FIND v(dout0_133) AT=635.025n

.meas tran vdout0_134ck1260 FIND v(dout0_134) AT=635.025n

.meas tran vdout0_135ck1260 FIND v(dout0_135) AT=635.025n

.meas tran vdout0_136ck1260 FIND v(dout0_136) AT=635.025n

.meas tran vdout0_137ck1260 FIND v(dout0_137) AT=635.025n

.meas tran vdout0_138ck1260 FIND v(dout0_138) AT=635.025n

.meas tran vdout0_139ck1260 FIND v(dout0_139) AT=635.025n

.meas tran vdout0_140ck1260 FIND v(dout0_140) AT=635.025n

.meas tran vdout0_141ck1260 FIND v(dout0_141) AT=635.025n

.meas tran vdout0_142ck1260 FIND v(dout0_142) AT=635.025n

.meas tran vdout0_143ck1260 FIND v(dout0_143) AT=635.025n

.meas tran vdout0_144ck1260 FIND v(dout0_144) AT=635.025n

.meas tran vdout0_145ck1260 FIND v(dout0_145) AT=635.025n

.meas tran vdout0_146ck1260 FIND v(dout0_146) AT=635.025n

.meas tran vdout0_147ck1260 FIND v(dout0_147) AT=635.025n

.meas tran vdout0_148ck1260 FIND v(dout0_148) AT=635.025n

.meas tran vdout0_149ck1260 FIND v(dout0_149) AT=635.025n

.meas tran vdout0_0ck1270 FIND v(dout0_0) AT=640.025n

.meas tran vdout0_1ck1270 FIND v(dout0_1) AT=640.025n

.meas tran vdout0_2ck1270 FIND v(dout0_2) AT=640.025n

.meas tran vdout0_3ck1270 FIND v(dout0_3) AT=640.025n

.meas tran vdout0_4ck1270 FIND v(dout0_4) AT=640.025n

.meas tran vdout0_5ck1270 FIND v(dout0_5) AT=640.025n

.meas tran vdout0_6ck1270 FIND v(dout0_6) AT=640.025n

.meas tran vdout0_7ck1270 FIND v(dout0_7) AT=640.025n

.meas tran vdout0_8ck1270 FIND v(dout0_8) AT=640.025n

.meas tran vdout0_9ck1270 FIND v(dout0_9) AT=640.025n

.meas tran vdout0_10ck1270 FIND v(dout0_10) AT=640.025n

.meas tran vdout0_11ck1270 FIND v(dout0_11) AT=640.025n

.meas tran vdout0_12ck1270 FIND v(dout0_12) AT=640.025n

.meas tran vdout0_13ck1270 FIND v(dout0_13) AT=640.025n

.meas tran vdout0_14ck1270 FIND v(dout0_14) AT=640.025n

.meas tran vdout0_15ck1270 FIND v(dout0_15) AT=640.025n

.meas tran vdout0_16ck1270 FIND v(dout0_16) AT=640.025n

.meas tran vdout0_17ck1270 FIND v(dout0_17) AT=640.025n

.meas tran vdout0_18ck1270 FIND v(dout0_18) AT=640.025n

.meas tran vdout0_19ck1270 FIND v(dout0_19) AT=640.025n

.meas tran vdout0_20ck1270 FIND v(dout0_20) AT=640.025n

.meas tran vdout0_21ck1270 FIND v(dout0_21) AT=640.025n

.meas tran vdout0_22ck1270 FIND v(dout0_22) AT=640.025n

.meas tran vdout0_23ck1270 FIND v(dout0_23) AT=640.025n

.meas tran vdout0_24ck1270 FIND v(dout0_24) AT=640.025n

.meas tran vdout0_25ck1270 FIND v(dout0_25) AT=640.025n

.meas tran vdout0_26ck1270 FIND v(dout0_26) AT=640.025n

.meas tran vdout0_27ck1270 FIND v(dout0_27) AT=640.025n

.meas tran vdout0_28ck1270 FIND v(dout0_28) AT=640.025n

.meas tran vdout0_29ck1270 FIND v(dout0_29) AT=640.025n

.meas tran vdout0_30ck1270 FIND v(dout0_30) AT=640.025n

.meas tran vdout0_31ck1270 FIND v(dout0_31) AT=640.025n

.meas tran vdout0_32ck1270 FIND v(dout0_32) AT=640.025n

.meas tran vdout0_33ck1270 FIND v(dout0_33) AT=640.025n

.meas tran vdout0_34ck1270 FIND v(dout0_34) AT=640.025n

.meas tran vdout0_35ck1270 FIND v(dout0_35) AT=640.025n

.meas tran vdout0_36ck1270 FIND v(dout0_36) AT=640.025n

.meas tran vdout0_37ck1270 FIND v(dout0_37) AT=640.025n

.meas tran vdout0_38ck1270 FIND v(dout0_38) AT=640.025n

.meas tran vdout0_39ck1270 FIND v(dout0_39) AT=640.025n

.meas tran vdout0_40ck1270 FIND v(dout0_40) AT=640.025n

.meas tran vdout0_41ck1270 FIND v(dout0_41) AT=640.025n

.meas tran vdout0_42ck1270 FIND v(dout0_42) AT=640.025n

.meas tran vdout0_43ck1270 FIND v(dout0_43) AT=640.025n

.meas tran vdout0_44ck1270 FIND v(dout0_44) AT=640.025n

.meas tran vdout0_45ck1270 FIND v(dout0_45) AT=640.025n

.meas tran vdout0_46ck1270 FIND v(dout0_46) AT=640.025n

.meas tran vdout0_47ck1270 FIND v(dout0_47) AT=640.025n

.meas tran vdout0_48ck1270 FIND v(dout0_48) AT=640.025n

.meas tran vdout0_49ck1270 FIND v(dout0_49) AT=640.025n

.meas tran vdout0_50ck1270 FIND v(dout0_50) AT=640.025n

.meas tran vdout0_51ck1270 FIND v(dout0_51) AT=640.025n

.meas tran vdout0_52ck1270 FIND v(dout0_52) AT=640.025n

.meas tran vdout0_53ck1270 FIND v(dout0_53) AT=640.025n

.meas tran vdout0_54ck1270 FIND v(dout0_54) AT=640.025n

.meas tran vdout0_55ck1270 FIND v(dout0_55) AT=640.025n

.meas tran vdout0_56ck1270 FIND v(dout0_56) AT=640.025n

.meas tran vdout0_57ck1270 FIND v(dout0_57) AT=640.025n

.meas tran vdout0_58ck1270 FIND v(dout0_58) AT=640.025n

.meas tran vdout0_59ck1270 FIND v(dout0_59) AT=640.025n

.meas tran vdout0_60ck1270 FIND v(dout0_60) AT=640.025n

.meas tran vdout0_61ck1270 FIND v(dout0_61) AT=640.025n

.meas tran vdout0_62ck1270 FIND v(dout0_62) AT=640.025n

.meas tran vdout0_63ck1270 FIND v(dout0_63) AT=640.025n

.meas tran vdout0_64ck1270 FIND v(dout0_64) AT=640.025n

.meas tran vdout0_65ck1270 FIND v(dout0_65) AT=640.025n

.meas tran vdout0_66ck1270 FIND v(dout0_66) AT=640.025n

.meas tran vdout0_67ck1270 FIND v(dout0_67) AT=640.025n

.meas tran vdout0_68ck1270 FIND v(dout0_68) AT=640.025n

.meas tran vdout0_69ck1270 FIND v(dout0_69) AT=640.025n

.meas tran vdout0_70ck1270 FIND v(dout0_70) AT=640.025n

.meas tran vdout0_71ck1270 FIND v(dout0_71) AT=640.025n

.meas tran vdout0_72ck1270 FIND v(dout0_72) AT=640.025n

.meas tran vdout0_73ck1270 FIND v(dout0_73) AT=640.025n

.meas tran vdout0_74ck1270 FIND v(dout0_74) AT=640.025n

.meas tran vdout0_75ck1270 FIND v(dout0_75) AT=640.025n

.meas tran vdout0_76ck1270 FIND v(dout0_76) AT=640.025n

.meas tran vdout0_77ck1270 FIND v(dout0_77) AT=640.025n

.meas tran vdout0_78ck1270 FIND v(dout0_78) AT=640.025n

.meas tran vdout0_79ck1270 FIND v(dout0_79) AT=640.025n

.meas tran vdout0_80ck1270 FIND v(dout0_80) AT=640.025n

.meas tran vdout0_81ck1270 FIND v(dout0_81) AT=640.025n

.meas tran vdout0_82ck1270 FIND v(dout0_82) AT=640.025n

.meas tran vdout0_83ck1270 FIND v(dout0_83) AT=640.025n

.meas tran vdout0_84ck1270 FIND v(dout0_84) AT=640.025n

.meas tran vdout0_85ck1270 FIND v(dout0_85) AT=640.025n

.meas tran vdout0_86ck1270 FIND v(dout0_86) AT=640.025n

.meas tran vdout0_87ck1270 FIND v(dout0_87) AT=640.025n

.meas tran vdout0_88ck1270 FIND v(dout0_88) AT=640.025n

.meas tran vdout0_89ck1270 FIND v(dout0_89) AT=640.025n

.meas tran vdout0_90ck1270 FIND v(dout0_90) AT=640.025n

.meas tran vdout0_91ck1270 FIND v(dout0_91) AT=640.025n

.meas tran vdout0_92ck1270 FIND v(dout0_92) AT=640.025n

.meas tran vdout0_93ck1270 FIND v(dout0_93) AT=640.025n

.meas tran vdout0_94ck1270 FIND v(dout0_94) AT=640.025n

.meas tran vdout0_95ck1270 FIND v(dout0_95) AT=640.025n

.meas tran vdout0_96ck1270 FIND v(dout0_96) AT=640.025n

.meas tran vdout0_97ck1270 FIND v(dout0_97) AT=640.025n

.meas tran vdout0_98ck1270 FIND v(dout0_98) AT=640.025n

.meas tran vdout0_99ck1270 FIND v(dout0_99) AT=640.025n

.meas tran vdout0_100ck1270 FIND v(dout0_100) AT=640.025n

.meas tran vdout0_101ck1270 FIND v(dout0_101) AT=640.025n

.meas tran vdout0_102ck1270 FIND v(dout0_102) AT=640.025n

.meas tran vdout0_103ck1270 FIND v(dout0_103) AT=640.025n

.meas tran vdout0_104ck1270 FIND v(dout0_104) AT=640.025n

.meas tran vdout0_105ck1270 FIND v(dout0_105) AT=640.025n

.meas tran vdout0_106ck1270 FIND v(dout0_106) AT=640.025n

.meas tran vdout0_107ck1270 FIND v(dout0_107) AT=640.025n

.meas tran vdout0_108ck1270 FIND v(dout0_108) AT=640.025n

.meas tran vdout0_109ck1270 FIND v(dout0_109) AT=640.025n

.meas tran vdout0_110ck1270 FIND v(dout0_110) AT=640.025n

.meas tran vdout0_111ck1270 FIND v(dout0_111) AT=640.025n

.meas tran vdout0_112ck1270 FIND v(dout0_112) AT=640.025n

.meas tran vdout0_113ck1270 FIND v(dout0_113) AT=640.025n

.meas tran vdout0_114ck1270 FIND v(dout0_114) AT=640.025n

.meas tran vdout0_115ck1270 FIND v(dout0_115) AT=640.025n

.meas tran vdout0_116ck1270 FIND v(dout0_116) AT=640.025n

.meas tran vdout0_117ck1270 FIND v(dout0_117) AT=640.025n

.meas tran vdout0_118ck1270 FIND v(dout0_118) AT=640.025n

.meas tran vdout0_119ck1270 FIND v(dout0_119) AT=640.025n

.meas tran vdout0_120ck1270 FIND v(dout0_120) AT=640.025n

.meas tran vdout0_121ck1270 FIND v(dout0_121) AT=640.025n

.meas tran vdout0_122ck1270 FIND v(dout0_122) AT=640.025n

.meas tran vdout0_123ck1270 FIND v(dout0_123) AT=640.025n

.meas tran vdout0_124ck1270 FIND v(dout0_124) AT=640.025n

.meas tran vdout0_125ck1270 FIND v(dout0_125) AT=640.025n

.meas tran vdout0_126ck1270 FIND v(dout0_126) AT=640.025n

.meas tran vdout0_127ck1270 FIND v(dout0_127) AT=640.025n

.meas tran vdout0_128ck1270 FIND v(dout0_128) AT=640.025n

.meas tran vdout0_129ck1270 FIND v(dout0_129) AT=640.025n

.meas tran vdout0_130ck1270 FIND v(dout0_130) AT=640.025n

.meas tran vdout0_131ck1270 FIND v(dout0_131) AT=640.025n

.meas tran vdout0_132ck1270 FIND v(dout0_132) AT=640.025n

.meas tran vdout0_133ck1270 FIND v(dout0_133) AT=640.025n

.meas tran vdout0_134ck1270 FIND v(dout0_134) AT=640.025n

.meas tran vdout0_135ck1270 FIND v(dout0_135) AT=640.025n

.meas tran vdout0_136ck1270 FIND v(dout0_136) AT=640.025n

.meas tran vdout0_137ck1270 FIND v(dout0_137) AT=640.025n

.meas tran vdout0_138ck1270 FIND v(dout0_138) AT=640.025n

.meas tran vdout0_139ck1270 FIND v(dout0_139) AT=640.025n

.meas tran vdout0_140ck1270 FIND v(dout0_140) AT=640.025n

.meas tran vdout0_141ck1270 FIND v(dout0_141) AT=640.025n

.meas tran vdout0_142ck1270 FIND v(dout0_142) AT=640.025n

.meas tran vdout0_143ck1270 FIND v(dout0_143) AT=640.025n

.meas tran vdout0_144ck1270 FIND v(dout0_144) AT=640.025n

.meas tran vdout0_145ck1270 FIND v(dout0_145) AT=640.025n

.meas tran vdout0_146ck1270 FIND v(dout0_146) AT=640.025n

.meas tran vdout0_147ck1270 FIND v(dout0_147) AT=640.025n

.meas tran vdout0_148ck1270 FIND v(dout0_148) AT=640.025n

.meas tran vdout0_149ck1270 FIND v(dout0_149) AT=640.025n

.meas tran vdout0_0ck1280 FIND v(dout0_0) AT=645.025n

.meas tran vdout0_1ck1280 FIND v(dout0_1) AT=645.025n

.meas tran vdout0_2ck1280 FIND v(dout0_2) AT=645.025n

.meas tran vdout0_3ck1280 FIND v(dout0_3) AT=645.025n

.meas tran vdout0_4ck1280 FIND v(dout0_4) AT=645.025n

.meas tran vdout0_5ck1280 FIND v(dout0_5) AT=645.025n

.meas tran vdout0_6ck1280 FIND v(dout0_6) AT=645.025n

.meas tran vdout0_7ck1280 FIND v(dout0_7) AT=645.025n

.meas tran vdout0_8ck1280 FIND v(dout0_8) AT=645.025n

.meas tran vdout0_9ck1280 FIND v(dout0_9) AT=645.025n

.meas tran vdout0_10ck1280 FIND v(dout0_10) AT=645.025n

.meas tran vdout0_11ck1280 FIND v(dout0_11) AT=645.025n

.meas tran vdout0_12ck1280 FIND v(dout0_12) AT=645.025n

.meas tran vdout0_13ck1280 FIND v(dout0_13) AT=645.025n

.meas tran vdout0_14ck1280 FIND v(dout0_14) AT=645.025n

.meas tran vdout0_15ck1280 FIND v(dout0_15) AT=645.025n

.meas tran vdout0_16ck1280 FIND v(dout0_16) AT=645.025n

.meas tran vdout0_17ck1280 FIND v(dout0_17) AT=645.025n

.meas tran vdout0_18ck1280 FIND v(dout0_18) AT=645.025n

.meas tran vdout0_19ck1280 FIND v(dout0_19) AT=645.025n

.meas tran vdout0_20ck1280 FIND v(dout0_20) AT=645.025n

.meas tran vdout0_21ck1280 FIND v(dout0_21) AT=645.025n

.meas tran vdout0_22ck1280 FIND v(dout0_22) AT=645.025n

.meas tran vdout0_23ck1280 FIND v(dout0_23) AT=645.025n

.meas tran vdout0_24ck1280 FIND v(dout0_24) AT=645.025n

.meas tran vdout0_25ck1280 FIND v(dout0_25) AT=645.025n

.meas tran vdout0_26ck1280 FIND v(dout0_26) AT=645.025n

.meas tran vdout0_27ck1280 FIND v(dout0_27) AT=645.025n

.meas tran vdout0_28ck1280 FIND v(dout0_28) AT=645.025n

.meas tran vdout0_29ck1280 FIND v(dout0_29) AT=645.025n

.meas tran vdout0_30ck1280 FIND v(dout0_30) AT=645.025n

.meas tran vdout0_31ck1280 FIND v(dout0_31) AT=645.025n

.meas tran vdout0_32ck1280 FIND v(dout0_32) AT=645.025n

.meas tran vdout0_33ck1280 FIND v(dout0_33) AT=645.025n

.meas tran vdout0_34ck1280 FIND v(dout0_34) AT=645.025n

.meas tran vdout0_35ck1280 FIND v(dout0_35) AT=645.025n

.meas tran vdout0_36ck1280 FIND v(dout0_36) AT=645.025n

.meas tran vdout0_37ck1280 FIND v(dout0_37) AT=645.025n

.meas tran vdout0_38ck1280 FIND v(dout0_38) AT=645.025n

.meas tran vdout0_39ck1280 FIND v(dout0_39) AT=645.025n

.meas tran vdout0_40ck1280 FIND v(dout0_40) AT=645.025n

.meas tran vdout0_41ck1280 FIND v(dout0_41) AT=645.025n

.meas tran vdout0_42ck1280 FIND v(dout0_42) AT=645.025n

.meas tran vdout0_43ck1280 FIND v(dout0_43) AT=645.025n

.meas tran vdout0_44ck1280 FIND v(dout0_44) AT=645.025n

.meas tran vdout0_45ck1280 FIND v(dout0_45) AT=645.025n

.meas tran vdout0_46ck1280 FIND v(dout0_46) AT=645.025n

.meas tran vdout0_47ck1280 FIND v(dout0_47) AT=645.025n

.meas tran vdout0_48ck1280 FIND v(dout0_48) AT=645.025n

.meas tran vdout0_49ck1280 FIND v(dout0_49) AT=645.025n

.meas tran vdout0_50ck1280 FIND v(dout0_50) AT=645.025n

.meas tran vdout0_51ck1280 FIND v(dout0_51) AT=645.025n

.meas tran vdout0_52ck1280 FIND v(dout0_52) AT=645.025n

.meas tran vdout0_53ck1280 FIND v(dout0_53) AT=645.025n

.meas tran vdout0_54ck1280 FIND v(dout0_54) AT=645.025n

.meas tran vdout0_55ck1280 FIND v(dout0_55) AT=645.025n

.meas tran vdout0_56ck1280 FIND v(dout0_56) AT=645.025n

.meas tran vdout0_57ck1280 FIND v(dout0_57) AT=645.025n

.meas tran vdout0_58ck1280 FIND v(dout0_58) AT=645.025n

.meas tran vdout0_59ck1280 FIND v(dout0_59) AT=645.025n

.meas tran vdout0_60ck1280 FIND v(dout0_60) AT=645.025n

.meas tran vdout0_61ck1280 FIND v(dout0_61) AT=645.025n

.meas tran vdout0_62ck1280 FIND v(dout0_62) AT=645.025n

.meas tran vdout0_63ck1280 FIND v(dout0_63) AT=645.025n

.meas tran vdout0_64ck1280 FIND v(dout0_64) AT=645.025n

.meas tran vdout0_65ck1280 FIND v(dout0_65) AT=645.025n

.meas tran vdout0_66ck1280 FIND v(dout0_66) AT=645.025n

.meas tran vdout0_67ck1280 FIND v(dout0_67) AT=645.025n

.meas tran vdout0_68ck1280 FIND v(dout0_68) AT=645.025n

.meas tran vdout0_69ck1280 FIND v(dout0_69) AT=645.025n

.meas tran vdout0_70ck1280 FIND v(dout0_70) AT=645.025n

.meas tran vdout0_71ck1280 FIND v(dout0_71) AT=645.025n

.meas tran vdout0_72ck1280 FIND v(dout0_72) AT=645.025n

.meas tran vdout0_73ck1280 FIND v(dout0_73) AT=645.025n

.meas tran vdout0_74ck1280 FIND v(dout0_74) AT=645.025n

.meas tran vdout0_75ck1280 FIND v(dout0_75) AT=645.025n

.meas tran vdout0_76ck1280 FIND v(dout0_76) AT=645.025n

.meas tran vdout0_77ck1280 FIND v(dout0_77) AT=645.025n

.meas tran vdout0_78ck1280 FIND v(dout0_78) AT=645.025n

.meas tran vdout0_79ck1280 FIND v(dout0_79) AT=645.025n

.meas tran vdout0_80ck1280 FIND v(dout0_80) AT=645.025n

.meas tran vdout0_81ck1280 FIND v(dout0_81) AT=645.025n

.meas tran vdout0_82ck1280 FIND v(dout0_82) AT=645.025n

.meas tran vdout0_83ck1280 FIND v(dout0_83) AT=645.025n

.meas tran vdout0_84ck1280 FIND v(dout0_84) AT=645.025n

.meas tran vdout0_85ck1280 FIND v(dout0_85) AT=645.025n

.meas tran vdout0_86ck1280 FIND v(dout0_86) AT=645.025n

.meas tran vdout0_87ck1280 FIND v(dout0_87) AT=645.025n

.meas tran vdout0_88ck1280 FIND v(dout0_88) AT=645.025n

.meas tran vdout0_89ck1280 FIND v(dout0_89) AT=645.025n

.meas tran vdout0_90ck1280 FIND v(dout0_90) AT=645.025n

.meas tran vdout0_91ck1280 FIND v(dout0_91) AT=645.025n

.meas tran vdout0_92ck1280 FIND v(dout0_92) AT=645.025n

.meas tran vdout0_93ck1280 FIND v(dout0_93) AT=645.025n

.meas tran vdout0_94ck1280 FIND v(dout0_94) AT=645.025n

.meas tran vdout0_95ck1280 FIND v(dout0_95) AT=645.025n

.meas tran vdout0_96ck1280 FIND v(dout0_96) AT=645.025n

.meas tran vdout0_97ck1280 FIND v(dout0_97) AT=645.025n

.meas tran vdout0_98ck1280 FIND v(dout0_98) AT=645.025n

.meas tran vdout0_99ck1280 FIND v(dout0_99) AT=645.025n

.meas tran vdout0_100ck1280 FIND v(dout0_100) AT=645.025n

.meas tran vdout0_101ck1280 FIND v(dout0_101) AT=645.025n

.meas tran vdout0_102ck1280 FIND v(dout0_102) AT=645.025n

.meas tran vdout0_103ck1280 FIND v(dout0_103) AT=645.025n

.meas tran vdout0_104ck1280 FIND v(dout0_104) AT=645.025n

.meas tran vdout0_105ck1280 FIND v(dout0_105) AT=645.025n

.meas tran vdout0_106ck1280 FIND v(dout0_106) AT=645.025n

.meas tran vdout0_107ck1280 FIND v(dout0_107) AT=645.025n

.meas tran vdout0_108ck1280 FIND v(dout0_108) AT=645.025n

.meas tran vdout0_109ck1280 FIND v(dout0_109) AT=645.025n

.meas tran vdout0_110ck1280 FIND v(dout0_110) AT=645.025n

.meas tran vdout0_111ck1280 FIND v(dout0_111) AT=645.025n

.meas tran vdout0_112ck1280 FIND v(dout0_112) AT=645.025n

.meas tran vdout0_113ck1280 FIND v(dout0_113) AT=645.025n

.meas tran vdout0_114ck1280 FIND v(dout0_114) AT=645.025n

.meas tran vdout0_115ck1280 FIND v(dout0_115) AT=645.025n

.meas tran vdout0_116ck1280 FIND v(dout0_116) AT=645.025n

.meas tran vdout0_117ck1280 FIND v(dout0_117) AT=645.025n

.meas tran vdout0_118ck1280 FIND v(dout0_118) AT=645.025n

.meas tran vdout0_119ck1280 FIND v(dout0_119) AT=645.025n

.meas tran vdout0_120ck1280 FIND v(dout0_120) AT=645.025n

.meas tran vdout0_121ck1280 FIND v(dout0_121) AT=645.025n

.meas tran vdout0_122ck1280 FIND v(dout0_122) AT=645.025n

.meas tran vdout0_123ck1280 FIND v(dout0_123) AT=645.025n

.meas tran vdout0_124ck1280 FIND v(dout0_124) AT=645.025n

.meas tran vdout0_125ck1280 FIND v(dout0_125) AT=645.025n

.meas tran vdout0_126ck1280 FIND v(dout0_126) AT=645.025n

.meas tran vdout0_127ck1280 FIND v(dout0_127) AT=645.025n

.meas tran vdout0_128ck1280 FIND v(dout0_128) AT=645.025n

.meas tran vdout0_129ck1280 FIND v(dout0_129) AT=645.025n

.meas tran vdout0_130ck1280 FIND v(dout0_130) AT=645.025n

.meas tran vdout0_131ck1280 FIND v(dout0_131) AT=645.025n

.meas tran vdout0_132ck1280 FIND v(dout0_132) AT=645.025n

.meas tran vdout0_133ck1280 FIND v(dout0_133) AT=645.025n

.meas tran vdout0_134ck1280 FIND v(dout0_134) AT=645.025n

.meas tran vdout0_135ck1280 FIND v(dout0_135) AT=645.025n

.meas tran vdout0_136ck1280 FIND v(dout0_136) AT=645.025n

.meas tran vdout0_137ck1280 FIND v(dout0_137) AT=645.025n

.meas tran vdout0_138ck1280 FIND v(dout0_138) AT=645.025n

.meas tran vdout0_139ck1280 FIND v(dout0_139) AT=645.025n

.meas tran vdout0_140ck1280 FIND v(dout0_140) AT=645.025n

.meas tran vdout0_141ck1280 FIND v(dout0_141) AT=645.025n

.meas tran vdout0_142ck1280 FIND v(dout0_142) AT=645.025n

.meas tran vdout0_143ck1280 FIND v(dout0_143) AT=645.025n

.meas tran vdout0_144ck1280 FIND v(dout0_144) AT=645.025n

.meas tran vdout0_145ck1280 FIND v(dout0_145) AT=645.025n

.meas tran vdout0_146ck1280 FIND v(dout0_146) AT=645.025n

.meas tran vdout0_147ck1280 FIND v(dout0_147) AT=645.025n

.meas tran vdout0_148ck1280 FIND v(dout0_148) AT=645.025n

.meas tran vdout0_149ck1280 FIND v(dout0_149) AT=645.025n

.meas tran vdout0_0ck1300 FIND v(dout0_0) AT=655.025n

.meas tran vdout0_1ck1300 FIND v(dout0_1) AT=655.025n

.meas tran vdout0_2ck1300 FIND v(dout0_2) AT=655.025n

.meas tran vdout0_3ck1300 FIND v(dout0_3) AT=655.025n

.meas tran vdout0_4ck1300 FIND v(dout0_4) AT=655.025n

.meas tran vdout0_5ck1300 FIND v(dout0_5) AT=655.025n

.meas tran vdout0_6ck1300 FIND v(dout0_6) AT=655.025n

.meas tran vdout0_7ck1300 FIND v(dout0_7) AT=655.025n

.meas tran vdout0_8ck1300 FIND v(dout0_8) AT=655.025n

.meas tran vdout0_9ck1300 FIND v(dout0_9) AT=655.025n

.meas tran vdout0_10ck1300 FIND v(dout0_10) AT=655.025n

.meas tran vdout0_11ck1300 FIND v(dout0_11) AT=655.025n

.meas tran vdout0_12ck1300 FIND v(dout0_12) AT=655.025n

.meas tran vdout0_13ck1300 FIND v(dout0_13) AT=655.025n

.meas tran vdout0_14ck1300 FIND v(dout0_14) AT=655.025n

.meas tran vdout0_15ck1300 FIND v(dout0_15) AT=655.025n

.meas tran vdout0_16ck1300 FIND v(dout0_16) AT=655.025n

.meas tran vdout0_17ck1300 FIND v(dout0_17) AT=655.025n

.meas tran vdout0_18ck1300 FIND v(dout0_18) AT=655.025n

.meas tran vdout0_19ck1300 FIND v(dout0_19) AT=655.025n

.meas tran vdout0_20ck1300 FIND v(dout0_20) AT=655.025n

.meas tran vdout0_21ck1300 FIND v(dout0_21) AT=655.025n

.meas tran vdout0_22ck1300 FIND v(dout0_22) AT=655.025n

.meas tran vdout0_23ck1300 FIND v(dout0_23) AT=655.025n

.meas tran vdout0_24ck1300 FIND v(dout0_24) AT=655.025n

.meas tran vdout0_25ck1300 FIND v(dout0_25) AT=655.025n

.meas tran vdout0_26ck1300 FIND v(dout0_26) AT=655.025n

.meas tran vdout0_27ck1300 FIND v(dout0_27) AT=655.025n

.meas tran vdout0_28ck1300 FIND v(dout0_28) AT=655.025n

.meas tran vdout0_29ck1300 FIND v(dout0_29) AT=655.025n

.meas tran vdout0_30ck1300 FIND v(dout0_30) AT=655.025n

.meas tran vdout0_31ck1300 FIND v(dout0_31) AT=655.025n

.meas tran vdout0_32ck1300 FIND v(dout0_32) AT=655.025n

.meas tran vdout0_33ck1300 FIND v(dout0_33) AT=655.025n

.meas tran vdout0_34ck1300 FIND v(dout0_34) AT=655.025n

.meas tran vdout0_35ck1300 FIND v(dout0_35) AT=655.025n

.meas tran vdout0_36ck1300 FIND v(dout0_36) AT=655.025n

.meas tran vdout0_37ck1300 FIND v(dout0_37) AT=655.025n

.meas tran vdout0_38ck1300 FIND v(dout0_38) AT=655.025n

.meas tran vdout0_39ck1300 FIND v(dout0_39) AT=655.025n

.meas tran vdout0_40ck1300 FIND v(dout0_40) AT=655.025n

.meas tran vdout0_41ck1300 FIND v(dout0_41) AT=655.025n

.meas tran vdout0_42ck1300 FIND v(dout0_42) AT=655.025n

.meas tran vdout0_43ck1300 FIND v(dout0_43) AT=655.025n

.meas tran vdout0_44ck1300 FIND v(dout0_44) AT=655.025n

.meas tran vdout0_45ck1300 FIND v(dout0_45) AT=655.025n

.meas tran vdout0_46ck1300 FIND v(dout0_46) AT=655.025n

.meas tran vdout0_47ck1300 FIND v(dout0_47) AT=655.025n

.meas tran vdout0_48ck1300 FIND v(dout0_48) AT=655.025n

.meas tran vdout0_49ck1300 FIND v(dout0_49) AT=655.025n

.meas tran vdout0_50ck1300 FIND v(dout0_50) AT=655.025n

.meas tran vdout0_51ck1300 FIND v(dout0_51) AT=655.025n

.meas tran vdout0_52ck1300 FIND v(dout0_52) AT=655.025n

.meas tran vdout0_53ck1300 FIND v(dout0_53) AT=655.025n

.meas tran vdout0_54ck1300 FIND v(dout0_54) AT=655.025n

.meas tran vdout0_55ck1300 FIND v(dout0_55) AT=655.025n

.meas tran vdout0_56ck1300 FIND v(dout0_56) AT=655.025n

.meas tran vdout0_57ck1300 FIND v(dout0_57) AT=655.025n

.meas tran vdout0_58ck1300 FIND v(dout0_58) AT=655.025n

.meas tran vdout0_59ck1300 FIND v(dout0_59) AT=655.025n

.meas tran vdout0_60ck1300 FIND v(dout0_60) AT=655.025n

.meas tran vdout0_61ck1300 FIND v(dout0_61) AT=655.025n

.meas tran vdout0_62ck1300 FIND v(dout0_62) AT=655.025n

.meas tran vdout0_63ck1300 FIND v(dout0_63) AT=655.025n

.meas tran vdout0_64ck1300 FIND v(dout0_64) AT=655.025n

.meas tran vdout0_65ck1300 FIND v(dout0_65) AT=655.025n

.meas tran vdout0_66ck1300 FIND v(dout0_66) AT=655.025n

.meas tran vdout0_67ck1300 FIND v(dout0_67) AT=655.025n

.meas tran vdout0_68ck1300 FIND v(dout0_68) AT=655.025n

.meas tran vdout0_69ck1300 FIND v(dout0_69) AT=655.025n

.meas tran vdout0_70ck1300 FIND v(dout0_70) AT=655.025n

.meas tran vdout0_71ck1300 FIND v(dout0_71) AT=655.025n

.meas tran vdout0_72ck1300 FIND v(dout0_72) AT=655.025n

.meas tran vdout0_73ck1300 FIND v(dout0_73) AT=655.025n

.meas tran vdout0_74ck1300 FIND v(dout0_74) AT=655.025n

.meas tran vdout0_75ck1300 FIND v(dout0_75) AT=655.025n

.meas tran vdout0_76ck1300 FIND v(dout0_76) AT=655.025n

.meas tran vdout0_77ck1300 FIND v(dout0_77) AT=655.025n

.meas tran vdout0_78ck1300 FIND v(dout0_78) AT=655.025n

.meas tran vdout0_79ck1300 FIND v(dout0_79) AT=655.025n

.meas tran vdout0_80ck1300 FIND v(dout0_80) AT=655.025n

.meas tran vdout0_81ck1300 FIND v(dout0_81) AT=655.025n

.meas tran vdout0_82ck1300 FIND v(dout0_82) AT=655.025n

.meas tran vdout0_83ck1300 FIND v(dout0_83) AT=655.025n

.meas tran vdout0_84ck1300 FIND v(dout0_84) AT=655.025n

.meas tran vdout0_85ck1300 FIND v(dout0_85) AT=655.025n

.meas tran vdout0_86ck1300 FIND v(dout0_86) AT=655.025n

.meas tran vdout0_87ck1300 FIND v(dout0_87) AT=655.025n

.meas tran vdout0_88ck1300 FIND v(dout0_88) AT=655.025n

.meas tran vdout0_89ck1300 FIND v(dout0_89) AT=655.025n

.meas tran vdout0_90ck1300 FIND v(dout0_90) AT=655.025n

.meas tran vdout0_91ck1300 FIND v(dout0_91) AT=655.025n

.meas tran vdout0_92ck1300 FIND v(dout0_92) AT=655.025n

.meas tran vdout0_93ck1300 FIND v(dout0_93) AT=655.025n

.meas tran vdout0_94ck1300 FIND v(dout0_94) AT=655.025n

.meas tran vdout0_95ck1300 FIND v(dout0_95) AT=655.025n

.meas tran vdout0_96ck1300 FIND v(dout0_96) AT=655.025n

.meas tran vdout0_97ck1300 FIND v(dout0_97) AT=655.025n

.meas tran vdout0_98ck1300 FIND v(dout0_98) AT=655.025n

.meas tran vdout0_99ck1300 FIND v(dout0_99) AT=655.025n

.meas tran vdout0_100ck1300 FIND v(dout0_100) AT=655.025n

.meas tran vdout0_101ck1300 FIND v(dout0_101) AT=655.025n

.meas tran vdout0_102ck1300 FIND v(dout0_102) AT=655.025n

.meas tran vdout0_103ck1300 FIND v(dout0_103) AT=655.025n

.meas tran vdout0_104ck1300 FIND v(dout0_104) AT=655.025n

.meas tran vdout0_105ck1300 FIND v(dout0_105) AT=655.025n

.meas tran vdout0_106ck1300 FIND v(dout0_106) AT=655.025n

.meas tran vdout0_107ck1300 FIND v(dout0_107) AT=655.025n

.meas tran vdout0_108ck1300 FIND v(dout0_108) AT=655.025n

.meas tran vdout0_109ck1300 FIND v(dout0_109) AT=655.025n

.meas tran vdout0_110ck1300 FIND v(dout0_110) AT=655.025n

.meas tran vdout0_111ck1300 FIND v(dout0_111) AT=655.025n

.meas tran vdout0_112ck1300 FIND v(dout0_112) AT=655.025n

.meas tran vdout0_113ck1300 FIND v(dout0_113) AT=655.025n

.meas tran vdout0_114ck1300 FIND v(dout0_114) AT=655.025n

.meas tran vdout0_115ck1300 FIND v(dout0_115) AT=655.025n

.meas tran vdout0_116ck1300 FIND v(dout0_116) AT=655.025n

.meas tran vdout0_117ck1300 FIND v(dout0_117) AT=655.025n

.meas tran vdout0_118ck1300 FIND v(dout0_118) AT=655.025n

.meas tran vdout0_119ck1300 FIND v(dout0_119) AT=655.025n

.meas tran vdout0_120ck1300 FIND v(dout0_120) AT=655.025n

.meas tran vdout0_121ck1300 FIND v(dout0_121) AT=655.025n

.meas tran vdout0_122ck1300 FIND v(dout0_122) AT=655.025n

.meas tran vdout0_123ck1300 FIND v(dout0_123) AT=655.025n

.meas tran vdout0_124ck1300 FIND v(dout0_124) AT=655.025n

.meas tran vdout0_125ck1300 FIND v(dout0_125) AT=655.025n

.meas tran vdout0_126ck1300 FIND v(dout0_126) AT=655.025n

.meas tran vdout0_127ck1300 FIND v(dout0_127) AT=655.025n

.meas tran vdout0_128ck1300 FIND v(dout0_128) AT=655.025n

.meas tran vdout0_129ck1300 FIND v(dout0_129) AT=655.025n

.meas tran vdout0_130ck1300 FIND v(dout0_130) AT=655.025n

.meas tran vdout0_131ck1300 FIND v(dout0_131) AT=655.025n

.meas tran vdout0_132ck1300 FIND v(dout0_132) AT=655.025n

.meas tran vdout0_133ck1300 FIND v(dout0_133) AT=655.025n

.meas tran vdout0_134ck1300 FIND v(dout0_134) AT=655.025n

.meas tran vdout0_135ck1300 FIND v(dout0_135) AT=655.025n

.meas tran vdout0_136ck1300 FIND v(dout0_136) AT=655.025n

.meas tran vdout0_137ck1300 FIND v(dout0_137) AT=655.025n

.meas tran vdout0_138ck1300 FIND v(dout0_138) AT=655.025n

.meas tran vdout0_139ck1300 FIND v(dout0_139) AT=655.025n

.meas tran vdout0_140ck1300 FIND v(dout0_140) AT=655.025n

.meas tran vdout0_141ck1300 FIND v(dout0_141) AT=655.025n

.meas tran vdout0_142ck1300 FIND v(dout0_142) AT=655.025n

.meas tran vdout0_143ck1300 FIND v(dout0_143) AT=655.025n

.meas tran vdout0_144ck1300 FIND v(dout0_144) AT=655.025n

.meas tran vdout0_145ck1300 FIND v(dout0_145) AT=655.025n

.meas tran vdout0_146ck1300 FIND v(dout0_146) AT=655.025n

.meas tran vdout0_147ck1300 FIND v(dout0_147) AT=655.025n

.meas tran vdout0_148ck1300 FIND v(dout0_148) AT=655.025n

.meas tran vdout0_149ck1300 FIND v(dout0_149) AT=655.025n

.meas tran vdout0_0ck1320 FIND v(dout0_0) AT=665.025n

.meas tran vdout0_1ck1320 FIND v(dout0_1) AT=665.025n

.meas tran vdout0_2ck1320 FIND v(dout0_2) AT=665.025n

.meas tran vdout0_3ck1320 FIND v(dout0_3) AT=665.025n

.meas tran vdout0_4ck1320 FIND v(dout0_4) AT=665.025n

.meas tran vdout0_5ck1320 FIND v(dout0_5) AT=665.025n

.meas tran vdout0_6ck1320 FIND v(dout0_6) AT=665.025n

.meas tran vdout0_7ck1320 FIND v(dout0_7) AT=665.025n

.meas tran vdout0_8ck1320 FIND v(dout0_8) AT=665.025n

.meas tran vdout0_9ck1320 FIND v(dout0_9) AT=665.025n

.meas tran vdout0_10ck1320 FIND v(dout0_10) AT=665.025n

.meas tran vdout0_11ck1320 FIND v(dout0_11) AT=665.025n

.meas tran vdout0_12ck1320 FIND v(dout0_12) AT=665.025n

.meas tran vdout0_13ck1320 FIND v(dout0_13) AT=665.025n

.meas tran vdout0_14ck1320 FIND v(dout0_14) AT=665.025n

.meas tran vdout0_15ck1320 FIND v(dout0_15) AT=665.025n

.meas tran vdout0_16ck1320 FIND v(dout0_16) AT=665.025n

.meas tran vdout0_17ck1320 FIND v(dout0_17) AT=665.025n

.meas tran vdout0_18ck1320 FIND v(dout0_18) AT=665.025n

.meas tran vdout0_19ck1320 FIND v(dout0_19) AT=665.025n

.meas tran vdout0_20ck1320 FIND v(dout0_20) AT=665.025n

.meas tran vdout0_21ck1320 FIND v(dout0_21) AT=665.025n

.meas tran vdout0_22ck1320 FIND v(dout0_22) AT=665.025n

.meas tran vdout0_23ck1320 FIND v(dout0_23) AT=665.025n

.meas tran vdout0_24ck1320 FIND v(dout0_24) AT=665.025n

.meas tran vdout0_25ck1320 FIND v(dout0_25) AT=665.025n

.meas tran vdout0_26ck1320 FIND v(dout0_26) AT=665.025n

.meas tran vdout0_27ck1320 FIND v(dout0_27) AT=665.025n

.meas tran vdout0_28ck1320 FIND v(dout0_28) AT=665.025n

.meas tran vdout0_29ck1320 FIND v(dout0_29) AT=665.025n

.meas tran vdout0_30ck1320 FIND v(dout0_30) AT=665.025n

.meas tran vdout0_31ck1320 FIND v(dout0_31) AT=665.025n

.meas tran vdout0_32ck1320 FIND v(dout0_32) AT=665.025n

.meas tran vdout0_33ck1320 FIND v(dout0_33) AT=665.025n

.meas tran vdout0_34ck1320 FIND v(dout0_34) AT=665.025n

.meas tran vdout0_35ck1320 FIND v(dout0_35) AT=665.025n

.meas tran vdout0_36ck1320 FIND v(dout0_36) AT=665.025n

.meas tran vdout0_37ck1320 FIND v(dout0_37) AT=665.025n

.meas tran vdout0_38ck1320 FIND v(dout0_38) AT=665.025n

.meas tran vdout0_39ck1320 FIND v(dout0_39) AT=665.025n

.meas tran vdout0_40ck1320 FIND v(dout0_40) AT=665.025n

.meas tran vdout0_41ck1320 FIND v(dout0_41) AT=665.025n

.meas tran vdout0_42ck1320 FIND v(dout0_42) AT=665.025n

.meas tran vdout0_43ck1320 FIND v(dout0_43) AT=665.025n

.meas tran vdout0_44ck1320 FIND v(dout0_44) AT=665.025n

.meas tran vdout0_45ck1320 FIND v(dout0_45) AT=665.025n

.meas tran vdout0_46ck1320 FIND v(dout0_46) AT=665.025n

.meas tran vdout0_47ck1320 FIND v(dout0_47) AT=665.025n

.meas tran vdout0_48ck1320 FIND v(dout0_48) AT=665.025n

.meas tran vdout0_49ck1320 FIND v(dout0_49) AT=665.025n

.meas tran vdout0_50ck1320 FIND v(dout0_50) AT=665.025n

.meas tran vdout0_51ck1320 FIND v(dout0_51) AT=665.025n

.meas tran vdout0_52ck1320 FIND v(dout0_52) AT=665.025n

.meas tran vdout0_53ck1320 FIND v(dout0_53) AT=665.025n

.meas tran vdout0_54ck1320 FIND v(dout0_54) AT=665.025n

.meas tran vdout0_55ck1320 FIND v(dout0_55) AT=665.025n

.meas tran vdout0_56ck1320 FIND v(dout0_56) AT=665.025n

.meas tran vdout0_57ck1320 FIND v(dout0_57) AT=665.025n

.meas tran vdout0_58ck1320 FIND v(dout0_58) AT=665.025n

.meas tran vdout0_59ck1320 FIND v(dout0_59) AT=665.025n

.meas tran vdout0_60ck1320 FIND v(dout0_60) AT=665.025n

.meas tran vdout0_61ck1320 FIND v(dout0_61) AT=665.025n

.meas tran vdout0_62ck1320 FIND v(dout0_62) AT=665.025n

.meas tran vdout0_63ck1320 FIND v(dout0_63) AT=665.025n

.meas tran vdout0_64ck1320 FIND v(dout0_64) AT=665.025n

.meas tran vdout0_65ck1320 FIND v(dout0_65) AT=665.025n

.meas tran vdout0_66ck1320 FIND v(dout0_66) AT=665.025n

.meas tran vdout0_67ck1320 FIND v(dout0_67) AT=665.025n

.meas tran vdout0_68ck1320 FIND v(dout0_68) AT=665.025n

.meas tran vdout0_69ck1320 FIND v(dout0_69) AT=665.025n

.meas tran vdout0_70ck1320 FIND v(dout0_70) AT=665.025n

.meas tran vdout0_71ck1320 FIND v(dout0_71) AT=665.025n

.meas tran vdout0_72ck1320 FIND v(dout0_72) AT=665.025n

.meas tran vdout0_73ck1320 FIND v(dout0_73) AT=665.025n

.meas tran vdout0_74ck1320 FIND v(dout0_74) AT=665.025n

.meas tran vdout0_75ck1320 FIND v(dout0_75) AT=665.025n

.meas tran vdout0_76ck1320 FIND v(dout0_76) AT=665.025n

.meas tran vdout0_77ck1320 FIND v(dout0_77) AT=665.025n

.meas tran vdout0_78ck1320 FIND v(dout0_78) AT=665.025n

.meas tran vdout0_79ck1320 FIND v(dout0_79) AT=665.025n

.meas tran vdout0_80ck1320 FIND v(dout0_80) AT=665.025n

.meas tran vdout0_81ck1320 FIND v(dout0_81) AT=665.025n

.meas tran vdout0_82ck1320 FIND v(dout0_82) AT=665.025n

.meas tran vdout0_83ck1320 FIND v(dout0_83) AT=665.025n

.meas tran vdout0_84ck1320 FIND v(dout0_84) AT=665.025n

.meas tran vdout0_85ck1320 FIND v(dout0_85) AT=665.025n

.meas tran vdout0_86ck1320 FIND v(dout0_86) AT=665.025n

.meas tran vdout0_87ck1320 FIND v(dout0_87) AT=665.025n

.meas tran vdout0_88ck1320 FIND v(dout0_88) AT=665.025n

.meas tran vdout0_89ck1320 FIND v(dout0_89) AT=665.025n

.meas tran vdout0_90ck1320 FIND v(dout0_90) AT=665.025n

.meas tran vdout0_91ck1320 FIND v(dout0_91) AT=665.025n

.meas tran vdout0_92ck1320 FIND v(dout0_92) AT=665.025n

.meas tran vdout0_93ck1320 FIND v(dout0_93) AT=665.025n

.meas tran vdout0_94ck1320 FIND v(dout0_94) AT=665.025n

.meas tran vdout0_95ck1320 FIND v(dout0_95) AT=665.025n

.meas tran vdout0_96ck1320 FIND v(dout0_96) AT=665.025n

.meas tran vdout0_97ck1320 FIND v(dout0_97) AT=665.025n

.meas tran vdout0_98ck1320 FIND v(dout0_98) AT=665.025n

.meas tran vdout0_99ck1320 FIND v(dout0_99) AT=665.025n

.meas tran vdout0_100ck1320 FIND v(dout0_100) AT=665.025n

.meas tran vdout0_101ck1320 FIND v(dout0_101) AT=665.025n

.meas tran vdout0_102ck1320 FIND v(dout0_102) AT=665.025n

.meas tran vdout0_103ck1320 FIND v(dout0_103) AT=665.025n

.meas tran vdout0_104ck1320 FIND v(dout0_104) AT=665.025n

.meas tran vdout0_105ck1320 FIND v(dout0_105) AT=665.025n

.meas tran vdout0_106ck1320 FIND v(dout0_106) AT=665.025n

.meas tran vdout0_107ck1320 FIND v(dout0_107) AT=665.025n

.meas tran vdout0_108ck1320 FIND v(dout0_108) AT=665.025n

.meas tran vdout0_109ck1320 FIND v(dout0_109) AT=665.025n

.meas tran vdout0_110ck1320 FIND v(dout0_110) AT=665.025n

.meas tran vdout0_111ck1320 FIND v(dout0_111) AT=665.025n

.meas tran vdout0_112ck1320 FIND v(dout0_112) AT=665.025n

.meas tran vdout0_113ck1320 FIND v(dout0_113) AT=665.025n

.meas tran vdout0_114ck1320 FIND v(dout0_114) AT=665.025n

.meas tran vdout0_115ck1320 FIND v(dout0_115) AT=665.025n

.meas tran vdout0_116ck1320 FIND v(dout0_116) AT=665.025n

.meas tran vdout0_117ck1320 FIND v(dout0_117) AT=665.025n

.meas tran vdout0_118ck1320 FIND v(dout0_118) AT=665.025n

.meas tran vdout0_119ck1320 FIND v(dout0_119) AT=665.025n

.meas tran vdout0_120ck1320 FIND v(dout0_120) AT=665.025n

.meas tran vdout0_121ck1320 FIND v(dout0_121) AT=665.025n

.meas tran vdout0_122ck1320 FIND v(dout0_122) AT=665.025n

.meas tran vdout0_123ck1320 FIND v(dout0_123) AT=665.025n

.meas tran vdout0_124ck1320 FIND v(dout0_124) AT=665.025n

.meas tran vdout0_125ck1320 FIND v(dout0_125) AT=665.025n

.meas tran vdout0_126ck1320 FIND v(dout0_126) AT=665.025n

.meas tran vdout0_127ck1320 FIND v(dout0_127) AT=665.025n

.meas tran vdout0_128ck1320 FIND v(dout0_128) AT=665.025n

.meas tran vdout0_129ck1320 FIND v(dout0_129) AT=665.025n

.meas tran vdout0_130ck1320 FIND v(dout0_130) AT=665.025n

.meas tran vdout0_131ck1320 FIND v(dout0_131) AT=665.025n

.meas tran vdout0_132ck1320 FIND v(dout0_132) AT=665.025n

.meas tran vdout0_133ck1320 FIND v(dout0_133) AT=665.025n

.meas tran vdout0_134ck1320 FIND v(dout0_134) AT=665.025n

.meas tran vdout0_135ck1320 FIND v(dout0_135) AT=665.025n

.meas tran vdout0_136ck1320 FIND v(dout0_136) AT=665.025n

.meas tran vdout0_137ck1320 FIND v(dout0_137) AT=665.025n

.meas tran vdout0_138ck1320 FIND v(dout0_138) AT=665.025n

.meas tran vdout0_139ck1320 FIND v(dout0_139) AT=665.025n

.meas tran vdout0_140ck1320 FIND v(dout0_140) AT=665.025n

.meas tran vdout0_141ck1320 FIND v(dout0_141) AT=665.025n

.meas tran vdout0_142ck1320 FIND v(dout0_142) AT=665.025n

.meas tran vdout0_143ck1320 FIND v(dout0_143) AT=665.025n

.meas tran vdout0_144ck1320 FIND v(dout0_144) AT=665.025n

.meas tran vdout0_145ck1320 FIND v(dout0_145) AT=665.025n

.meas tran vdout0_146ck1320 FIND v(dout0_146) AT=665.025n

.meas tran vdout0_147ck1320 FIND v(dout0_147) AT=665.025n

.meas tran vdout0_148ck1320 FIND v(dout0_148) AT=665.025n

.meas tran vdout0_149ck1320 FIND v(dout0_149) AT=665.025n

.meas tran vdout0_0ck1330 FIND v(dout0_0) AT=670.025n

.meas tran vdout0_1ck1330 FIND v(dout0_1) AT=670.025n

.meas tran vdout0_2ck1330 FIND v(dout0_2) AT=670.025n

.meas tran vdout0_3ck1330 FIND v(dout0_3) AT=670.025n

.meas tran vdout0_4ck1330 FIND v(dout0_4) AT=670.025n

.meas tran vdout0_5ck1330 FIND v(dout0_5) AT=670.025n

.meas tran vdout0_6ck1330 FIND v(dout0_6) AT=670.025n

.meas tran vdout0_7ck1330 FIND v(dout0_7) AT=670.025n

.meas tran vdout0_8ck1330 FIND v(dout0_8) AT=670.025n

.meas tran vdout0_9ck1330 FIND v(dout0_9) AT=670.025n

.meas tran vdout0_10ck1330 FIND v(dout0_10) AT=670.025n

.meas tran vdout0_11ck1330 FIND v(dout0_11) AT=670.025n

.meas tran vdout0_12ck1330 FIND v(dout0_12) AT=670.025n

.meas tran vdout0_13ck1330 FIND v(dout0_13) AT=670.025n

.meas tran vdout0_14ck1330 FIND v(dout0_14) AT=670.025n

.meas tran vdout0_15ck1330 FIND v(dout0_15) AT=670.025n

.meas tran vdout0_16ck1330 FIND v(dout0_16) AT=670.025n

.meas tran vdout0_17ck1330 FIND v(dout0_17) AT=670.025n

.meas tran vdout0_18ck1330 FIND v(dout0_18) AT=670.025n

.meas tran vdout0_19ck1330 FIND v(dout0_19) AT=670.025n

.meas tran vdout0_20ck1330 FIND v(dout0_20) AT=670.025n

.meas tran vdout0_21ck1330 FIND v(dout0_21) AT=670.025n

.meas tran vdout0_22ck1330 FIND v(dout0_22) AT=670.025n

.meas tran vdout0_23ck1330 FIND v(dout0_23) AT=670.025n

.meas tran vdout0_24ck1330 FIND v(dout0_24) AT=670.025n

.meas tran vdout0_25ck1330 FIND v(dout0_25) AT=670.025n

.meas tran vdout0_26ck1330 FIND v(dout0_26) AT=670.025n

.meas tran vdout0_27ck1330 FIND v(dout0_27) AT=670.025n

.meas tran vdout0_28ck1330 FIND v(dout0_28) AT=670.025n

.meas tran vdout0_29ck1330 FIND v(dout0_29) AT=670.025n

.meas tran vdout0_30ck1330 FIND v(dout0_30) AT=670.025n

.meas tran vdout0_31ck1330 FIND v(dout0_31) AT=670.025n

.meas tran vdout0_32ck1330 FIND v(dout0_32) AT=670.025n

.meas tran vdout0_33ck1330 FIND v(dout0_33) AT=670.025n

.meas tran vdout0_34ck1330 FIND v(dout0_34) AT=670.025n

.meas tran vdout0_35ck1330 FIND v(dout0_35) AT=670.025n

.meas tran vdout0_36ck1330 FIND v(dout0_36) AT=670.025n

.meas tran vdout0_37ck1330 FIND v(dout0_37) AT=670.025n

.meas tran vdout0_38ck1330 FIND v(dout0_38) AT=670.025n

.meas tran vdout0_39ck1330 FIND v(dout0_39) AT=670.025n

.meas tran vdout0_40ck1330 FIND v(dout0_40) AT=670.025n

.meas tran vdout0_41ck1330 FIND v(dout0_41) AT=670.025n

.meas tran vdout0_42ck1330 FIND v(dout0_42) AT=670.025n

.meas tran vdout0_43ck1330 FIND v(dout0_43) AT=670.025n

.meas tran vdout0_44ck1330 FIND v(dout0_44) AT=670.025n

.meas tran vdout0_45ck1330 FIND v(dout0_45) AT=670.025n

.meas tran vdout0_46ck1330 FIND v(dout0_46) AT=670.025n

.meas tran vdout0_47ck1330 FIND v(dout0_47) AT=670.025n

.meas tran vdout0_48ck1330 FIND v(dout0_48) AT=670.025n

.meas tran vdout0_49ck1330 FIND v(dout0_49) AT=670.025n

.meas tran vdout0_50ck1330 FIND v(dout0_50) AT=670.025n

.meas tran vdout0_51ck1330 FIND v(dout0_51) AT=670.025n

.meas tran vdout0_52ck1330 FIND v(dout0_52) AT=670.025n

.meas tran vdout0_53ck1330 FIND v(dout0_53) AT=670.025n

.meas tran vdout0_54ck1330 FIND v(dout0_54) AT=670.025n

.meas tran vdout0_55ck1330 FIND v(dout0_55) AT=670.025n

.meas tran vdout0_56ck1330 FIND v(dout0_56) AT=670.025n

.meas tran vdout0_57ck1330 FIND v(dout0_57) AT=670.025n

.meas tran vdout0_58ck1330 FIND v(dout0_58) AT=670.025n

.meas tran vdout0_59ck1330 FIND v(dout0_59) AT=670.025n

.meas tran vdout0_60ck1330 FIND v(dout0_60) AT=670.025n

.meas tran vdout0_61ck1330 FIND v(dout0_61) AT=670.025n

.meas tran vdout0_62ck1330 FIND v(dout0_62) AT=670.025n

.meas tran vdout0_63ck1330 FIND v(dout0_63) AT=670.025n

.meas tran vdout0_64ck1330 FIND v(dout0_64) AT=670.025n

.meas tran vdout0_65ck1330 FIND v(dout0_65) AT=670.025n

.meas tran vdout0_66ck1330 FIND v(dout0_66) AT=670.025n

.meas tran vdout0_67ck1330 FIND v(dout0_67) AT=670.025n

.meas tran vdout0_68ck1330 FIND v(dout0_68) AT=670.025n

.meas tran vdout0_69ck1330 FIND v(dout0_69) AT=670.025n

.meas tran vdout0_70ck1330 FIND v(dout0_70) AT=670.025n

.meas tran vdout0_71ck1330 FIND v(dout0_71) AT=670.025n

.meas tran vdout0_72ck1330 FIND v(dout0_72) AT=670.025n

.meas tran vdout0_73ck1330 FIND v(dout0_73) AT=670.025n

.meas tran vdout0_74ck1330 FIND v(dout0_74) AT=670.025n

.meas tran vdout0_75ck1330 FIND v(dout0_75) AT=670.025n

.meas tran vdout0_76ck1330 FIND v(dout0_76) AT=670.025n

.meas tran vdout0_77ck1330 FIND v(dout0_77) AT=670.025n

.meas tran vdout0_78ck1330 FIND v(dout0_78) AT=670.025n

.meas tran vdout0_79ck1330 FIND v(dout0_79) AT=670.025n

.meas tran vdout0_80ck1330 FIND v(dout0_80) AT=670.025n

.meas tran vdout0_81ck1330 FIND v(dout0_81) AT=670.025n

.meas tran vdout0_82ck1330 FIND v(dout0_82) AT=670.025n

.meas tran vdout0_83ck1330 FIND v(dout0_83) AT=670.025n

.meas tran vdout0_84ck1330 FIND v(dout0_84) AT=670.025n

.meas tran vdout0_85ck1330 FIND v(dout0_85) AT=670.025n

.meas tran vdout0_86ck1330 FIND v(dout0_86) AT=670.025n

.meas tran vdout0_87ck1330 FIND v(dout0_87) AT=670.025n

.meas tran vdout0_88ck1330 FIND v(dout0_88) AT=670.025n

.meas tran vdout0_89ck1330 FIND v(dout0_89) AT=670.025n

.meas tran vdout0_90ck1330 FIND v(dout0_90) AT=670.025n

.meas tran vdout0_91ck1330 FIND v(dout0_91) AT=670.025n

.meas tran vdout0_92ck1330 FIND v(dout0_92) AT=670.025n

.meas tran vdout0_93ck1330 FIND v(dout0_93) AT=670.025n

.meas tran vdout0_94ck1330 FIND v(dout0_94) AT=670.025n

.meas tran vdout0_95ck1330 FIND v(dout0_95) AT=670.025n

.meas tran vdout0_96ck1330 FIND v(dout0_96) AT=670.025n

.meas tran vdout0_97ck1330 FIND v(dout0_97) AT=670.025n

.meas tran vdout0_98ck1330 FIND v(dout0_98) AT=670.025n

.meas tran vdout0_99ck1330 FIND v(dout0_99) AT=670.025n

.meas tran vdout0_100ck1330 FIND v(dout0_100) AT=670.025n

.meas tran vdout0_101ck1330 FIND v(dout0_101) AT=670.025n

.meas tran vdout0_102ck1330 FIND v(dout0_102) AT=670.025n

.meas tran vdout0_103ck1330 FIND v(dout0_103) AT=670.025n

.meas tran vdout0_104ck1330 FIND v(dout0_104) AT=670.025n

.meas tran vdout0_105ck1330 FIND v(dout0_105) AT=670.025n

.meas tran vdout0_106ck1330 FIND v(dout0_106) AT=670.025n

.meas tran vdout0_107ck1330 FIND v(dout0_107) AT=670.025n

.meas tran vdout0_108ck1330 FIND v(dout0_108) AT=670.025n

.meas tran vdout0_109ck1330 FIND v(dout0_109) AT=670.025n

.meas tran vdout0_110ck1330 FIND v(dout0_110) AT=670.025n

.meas tran vdout0_111ck1330 FIND v(dout0_111) AT=670.025n

.meas tran vdout0_112ck1330 FIND v(dout0_112) AT=670.025n

.meas tran vdout0_113ck1330 FIND v(dout0_113) AT=670.025n

.meas tran vdout0_114ck1330 FIND v(dout0_114) AT=670.025n

.meas tran vdout0_115ck1330 FIND v(dout0_115) AT=670.025n

.meas tran vdout0_116ck1330 FIND v(dout0_116) AT=670.025n

.meas tran vdout0_117ck1330 FIND v(dout0_117) AT=670.025n

.meas tran vdout0_118ck1330 FIND v(dout0_118) AT=670.025n

.meas tran vdout0_119ck1330 FIND v(dout0_119) AT=670.025n

.meas tran vdout0_120ck1330 FIND v(dout0_120) AT=670.025n

.meas tran vdout0_121ck1330 FIND v(dout0_121) AT=670.025n

.meas tran vdout0_122ck1330 FIND v(dout0_122) AT=670.025n

.meas tran vdout0_123ck1330 FIND v(dout0_123) AT=670.025n

.meas tran vdout0_124ck1330 FIND v(dout0_124) AT=670.025n

.meas tran vdout0_125ck1330 FIND v(dout0_125) AT=670.025n

.meas tran vdout0_126ck1330 FIND v(dout0_126) AT=670.025n

.meas tran vdout0_127ck1330 FIND v(dout0_127) AT=670.025n

.meas tran vdout0_128ck1330 FIND v(dout0_128) AT=670.025n

.meas tran vdout0_129ck1330 FIND v(dout0_129) AT=670.025n

.meas tran vdout0_130ck1330 FIND v(dout0_130) AT=670.025n

.meas tran vdout0_131ck1330 FIND v(dout0_131) AT=670.025n

.meas tran vdout0_132ck1330 FIND v(dout0_132) AT=670.025n

.meas tran vdout0_133ck1330 FIND v(dout0_133) AT=670.025n

.meas tran vdout0_134ck1330 FIND v(dout0_134) AT=670.025n

.meas tran vdout0_135ck1330 FIND v(dout0_135) AT=670.025n

.meas tran vdout0_136ck1330 FIND v(dout0_136) AT=670.025n

.meas tran vdout0_137ck1330 FIND v(dout0_137) AT=670.025n

.meas tran vdout0_138ck1330 FIND v(dout0_138) AT=670.025n

.meas tran vdout0_139ck1330 FIND v(dout0_139) AT=670.025n

.meas tran vdout0_140ck1330 FIND v(dout0_140) AT=670.025n

.meas tran vdout0_141ck1330 FIND v(dout0_141) AT=670.025n

.meas tran vdout0_142ck1330 FIND v(dout0_142) AT=670.025n

.meas tran vdout0_143ck1330 FIND v(dout0_143) AT=670.025n

.meas tran vdout0_144ck1330 FIND v(dout0_144) AT=670.025n

.meas tran vdout0_145ck1330 FIND v(dout0_145) AT=670.025n

.meas tran vdout0_146ck1330 FIND v(dout0_146) AT=670.025n

.meas tran vdout0_147ck1330 FIND v(dout0_147) AT=670.025n

.meas tran vdout0_148ck1330 FIND v(dout0_148) AT=670.025n

.meas tran vdout0_149ck1330 FIND v(dout0_149) AT=670.025n

.meas tran vdout0_0ck1340 FIND v(dout0_0) AT=675.025n

.meas tran vdout0_1ck1340 FIND v(dout0_1) AT=675.025n

.meas tran vdout0_2ck1340 FIND v(dout0_2) AT=675.025n

.meas tran vdout0_3ck1340 FIND v(dout0_3) AT=675.025n

.meas tran vdout0_4ck1340 FIND v(dout0_4) AT=675.025n

.meas tran vdout0_5ck1340 FIND v(dout0_5) AT=675.025n

.meas tran vdout0_6ck1340 FIND v(dout0_6) AT=675.025n

.meas tran vdout0_7ck1340 FIND v(dout0_7) AT=675.025n

.meas tran vdout0_8ck1340 FIND v(dout0_8) AT=675.025n

.meas tran vdout0_9ck1340 FIND v(dout0_9) AT=675.025n

.meas tran vdout0_10ck1340 FIND v(dout0_10) AT=675.025n

.meas tran vdout0_11ck1340 FIND v(dout0_11) AT=675.025n

.meas tran vdout0_12ck1340 FIND v(dout0_12) AT=675.025n

.meas tran vdout0_13ck1340 FIND v(dout0_13) AT=675.025n

.meas tran vdout0_14ck1340 FIND v(dout0_14) AT=675.025n

.meas tran vdout0_15ck1340 FIND v(dout0_15) AT=675.025n

.meas tran vdout0_16ck1340 FIND v(dout0_16) AT=675.025n

.meas tran vdout0_17ck1340 FIND v(dout0_17) AT=675.025n

.meas tran vdout0_18ck1340 FIND v(dout0_18) AT=675.025n

.meas tran vdout0_19ck1340 FIND v(dout0_19) AT=675.025n

.meas tran vdout0_20ck1340 FIND v(dout0_20) AT=675.025n

.meas tran vdout0_21ck1340 FIND v(dout0_21) AT=675.025n

.meas tran vdout0_22ck1340 FIND v(dout0_22) AT=675.025n

.meas tran vdout0_23ck1340 FIND v(dout0_23) AT=675.025n

.meas tran vdout0_24ck1340 FIND v(dout0_24) AT=675.025n

.meas tran vdout0_25ck1340 FIND v(dout0_25) AT=675.025n

.meas tran vdout0_26ck1340 FIND v(dout0_26) AT=675.025n

.meas tran vdout0_27ck1340 FIND v(dout0_27) AT=675.025n

.meas tran vdout0_28ck1340 FIND v(dout0_28) AT=675.025n

.meas tran vdout0_29ck1340 FIND v(dout0_29) AT=675.025n

.meas tran vdout0_30ck1340 FIND v(dout0_30) AT=675.025n

.meas tran vdout0_31ck1340 FIND v(dout0_31) AT=675.025n

.meas tran vdout0_32ck1340 FIND v(dout0_32) AT=675.025n

.meas tran vdout0_33ck1340 FIND v(dout0_33) AT=675.025n

.meas tran vdout0_34ck1340 FIND v(dout0_34) AT=675.025n

.meas tran vdout0_35ck1340 FIND v(dout0_35) AT=675.025n

.meas tran vdout0_36ck1340 FIND v(dout0_36) AT=675.025n

.meas tran vdout0_37ck1340 FIND v(dout0_37) AT=675.025n

.meas tran vdout0_38ck1340 FIND v(dout0_38) AT=675.025n

.meas tran vdout0_39ck1340 FIND v(dout0_39) AT=675.025n

.meas tran vdout0_40ck1340 FIND v(dout0_40) AT=675.025n

.meas tran vdout0_41ck1340 FIND v(dout0_41) AT=675.025n

.meas tran vdout0_42ck1340 FIND v(dout0_42) AT=675.025n

.meas tran vdout0_43ck1340 FIND v(dout0_43) AT=675.025n

.meas tran vdout0_44ck1340 FIND v(dout0_44) AT=675.025n

.meas tran vdout0_45ck1340 FIND v(dout0_45) AT=675.025n

.meas tran vdout0_46ck1340 FIND v(dout0_46) AT=675.025n

.meas tran vdout0_47ck1340 FIND v(dout0_47) AT=675.025n

.meas tran vdout0_48ck1340 FIND v(dout0_48) AT=675.025n

.meas tran vdout0_49ck1340 FIND v(dout0_49) AT=675.025n

.meas tran vdout0_50ck1340 FIND v(dout0_50) AT=675.025n

.meas tran vdout0_51ck1340 FIND v(dout0_51) AT=675.025n

.meas tran vdout0_52ck1340 FIND v(dout0_52) AT=675.025n

.meas tran vdout0_53ck1340 FIND v(dout0_53) AT=675.025n

.meas tran vdout0_54ck1340 FIND v(dout0_54) AT=675.025n

.meas tran vdout0_55ck1340 FIND v(dout0_55) AT=675.025n

.meas tran vdout0_56ck1340 FIND v(dout0_56) AT=675.025n

.meas tran vdout0_57ck1340 FIND v(dout0_57) AT=675.025n

.meas tran vdout0_58ck1340 FIND v(dout0_58) AT=675.025n

.meas tran vdout0_59ck1340 FIND v(dout0_59) AT=675.025n

.meas tran vdout0_60ck1340 FIND v(dout0_60) AT=675.025n

.meas tran vdout0_61ck1340 FIND v(dout0_61) AT=675.025n

.meas tran vdout0_62ck1340 FIND v(dout0_62) AT=675.025n

.meas tran vdout0_63ck1340 FIND v(dout0_63) AT=675.025n

.meas tran vdout0_64ck1340 FIND v(dout0_64) AT=675.025n

.meas tran vdout0_65ck1340 FIND v(dout0_65) AT=675.025n

.meas tran vdout0_66ck1340 FIND v(dout0_66) AT=675.025n

.meas tran vdout0_67ck1340 FIND v(dout0_67) AT=675.025n

.meas tran vdout0_68ck1340 FIND v(dout0_68) AT=675.025n

.meas tran vdout0_69ck1340 FIND v(dout0_69) AT=675.025n

.meas tran vdout0_70ck1340 FIND v(dout0_70) AT=675.025n

.meas tran vdout0_71ck1340 FIND v(dout0_71) AT=675.025n

.meas tran vdout0_72ck1340 FIND v(dout0_72) AT=675.025n

.meas tran vdout0_73ck1340 FIND v(dout0_73) AT=675.025n

.meas tran vdout0_74ck1340 FIND v(dout0_74) AT=675.025n

.meas tran vdout0_75ck1340 FIND v(dout0_75) AT=675.025n

.meas tran vdout0_76ck1340 FIND v(dout0_76) AT=675.025n

.meas tran vdout0_77ck1340 FIND v(dout0_77) AT=675.025n

.meas tran vdout0_78ck1340 FIND v(dout0_78) AT=675.025n

.meas tran vdout0_79ck1340 FIND v(dout0_79) AT=675.025n

.meas tran vdout0_80ck1340 FIND v(dout0_80) AT=675.025n

.meas tran vdout0_81ck1340 FIND v(dout0_81) AT=675.025n

.meas tran vdout0_82ck1340 FIND v(dout0_82) AT=675.025n

.meas tran vdout0_83ck1340 FIND v(dout0_83) AT=675.025n

.meas tran vdout0_84ck1340 FIND v(dout0_84) AT=675.025n

.meas tran vdout0_85ck1340 FIND v(dout0_85) AT=675.025n

.meas tran vdout0_86ck1340 FIND v(dout0_86) AT=675.025n

.meas tran vdout0_87ck1340 FIND v(dout0_87) AT=675.025n

.meas tran vdout0_88ck1340 FIND v(dout0_88) AT=675.025n

.meas tran vdout0_89ck1340 FIND v(dout0_89) AT=675.025n

.meas tran vdout0_90ck1340 FIND v(dout0_90) AT=675.025n

.meas tran vdout0_91ck1340 FIND v(dout0_91) AT=675.025n

.meas tran vdout0_92ck1340 FIND v(dout0_92) AT=675.025n

.meas tran vdout0_93ck1340 FIND v(dout0_93) AT=675.025n

.meas tran vdout0_94ck1340 FIND v(dout0_94) AT=675.025n

.meas tran vdout0_95ck1340 FIND v(dout0_95) AT=675.025n

.meas tran vdout0_96ck1340 FIND v(dout0_96) AT=675.025n

.meas tran vdout0_97ck1340 FIND v(dout0_97) AT=675.025n

.meas tran vdout0_98ck1340 FIND v(dout0_98) AT=675.025n

.meas tran vdout0_99ck1340 FIND v(dout0_99) AT=675.025n

.meas tran vdout0_100ck1340 FIND v(dout0_100) AT=675.025n

.meas tran vdout0_101ck1340 FIND v(dout0_101) AT=675.025n

.meas tran vdout0_102ck1340 FIND v(dout0_102) AT=675.025n

.meas tran vdout0_103ck1340 FIND v(dout0_103) AT=675.025n

.meas tran vdout0_104ck1340 FIND v(dout0_104) AT=675.025n

.meas tran vdout0_105ck1340 FIND v(dout0_105) AT=675.025n

.meas tran vdout0_106ck1340 FIND v(dout0_106) AT=675.025n

.meas tran vdout0_107ck1340 FIND v(dout0_107) AT=675.025n

.meas tran vdout0_108ck1340 FIND v(dout0_108) AT=675.025n

.meas tran vdout0_109ck1340 FIND v(dout0_109) AT=675.025n

.meas tran vdout0_110ck1340 FIND v(dout0_110) AT=675.025n

.meas tran vdout0_111ck1340 FIND v(dout0_111) AT=675.025n

.meas tran vdout0_112ck1340 FIND v(dout0_112) AT=675.025n

.meas tran vdout0_113ck1340 FIND v(dout0_113) AT=675.025n

.meas tran vdout0_114ck1340 FIND v(dout0_114) AT=675.025n

.meas tran vdout0_115ck1340 FIND v(dout0_115) AT=675.025n

.meas tran vdout0_116ck1340 FIND v(dout0_116) AT=675.025n

.meas tran vdout0_117ck1340 FIND v(dout0_117) AT=675.025n

.meas tran vdout0_118ck1340 FIND v(dout0_118) AT=675.025n

.meas tran vdout0_119ck1340 FIND v(dout0_119) AT=675.025n

.meas tran vdout0_120ck1340 FIND v(dout0_120) AT=675.025n

.meas tran vdout0_121ck1340 FIND v(dout0_121) AT=675.025n

.meas tran vdout0_122ck1340 FIND v(dout0_122) AT=675.025n

.meas tran vdout0_123ck1340 FIND v(dout0_123) AT=675.025n

.meas tran vdout0_124ck1340 FIND v(dout0_124) AT=675.025n

.meas tran vdout0_125ck1340 FIND v(dout0_125) AT=675.025n

.meas tran vdout0_126ck1340 FIND v(dout0_126) AT=675.025n

.meas tran vdout0_127ck1340 FIND v(dout0_127) AT=675.025n

.meas tran vdout0_128ck1340 FIND v(dout0_128) AT=675.025n

.meas tran vdout0_129ck1340 FIND v(dout0_129) AT=675.025n

.meas tran vdout0_130ck1340 FIND v(dout0_130) AT=675.025n

.meas tran vdout0_131ck1340 FIND v(dout0_131) AT=675.025n

.meas tran vdout0_132ck1340 FIND v(dout0_132) AT=675.025n

.meas tran vdout0_133ck1340 FIND v(dout0_133) AT=675.025n

.meas tran vdout0_134ck1340 FIND v(dout0_134) AT=675.025n

.meas tran vdout0_135ck1340 FIND v(dout0_135) AT=675.025n

.meas tran vdout0_136ck1340 FIND v(dout0_136) AT=675.025n

.meas tran vdout0_137ck1340 FIND v(dout0_137) AT=675.025n

.meas tran vdout0_138ck1340 FIND v(dout0_138) AT=675.025n

.meas tran vdout0_139ck1340 FIND v(dout0_139) AT=675.025n

.meas tran vdout0_140ck1340 FIND v(dout0_140) AT=675.025n

.meas tran vdout0_141ck1340 FIND v(dout0_141) AT=675.025n

.meas tran vdout0_142ck1340 FIND v(dout0_142) AT=675.025n

.meas tran vdout0_143ck1340 FIND v(dout0_143) AT=675.025n

.meas tran vdout0_144ck1340 FIND v(dout0_144) AT=675.025n

.meas tran vdout0_145ck1340 FIND v(dout0_145) AT=675.025n

.meas tran vdout0_146ck1340 FIND v(dout0_146) AT=675.025n

.meas tran vdout0_147ck1340 FIND v(dout0_147) AT=675.025n

.meas tran vdout0_148ck1340 FIND v(dout0_148) AT=675.025n

.meas tran vdout0_149ck1340 FIND v(dout0_149) AT=675.025n

.meas tran vdout0_0ck1350 FIND v(dout0_0) AT=680.025n

.meas tran vdout0_1ck1350 FIND v(dout0_1) AT=680.025n

.meas tran vdout0_2ck1350 FIND v(dout0_2) AT=680.025n

.meas tran vdout0_3ck1350 FIND v(dout0_3) AT=680.025n

.meas tran vdout0_4ck1350 FIND v(dout0_4) AT=680.025n

.meas tran vdout0_5ck1350 FIND v(dout0_5) AT=680.025n

.meas tran vdout0_6ck1350 FIND v(dout0_6) AT=680.025n

.meas tran vdout0_7ck1350 FIND v(dout0_7) AT=680.025n

.meas tran vdout0_8ck1350 FIND v(dout0_8) AT=680.025n

.meas tran vdout0_9ck1350 FIND v(dout0_9) AT=680.025n

.meas tran vdout0_10ck1350 FIND v(dout0_10) AT=680.025n

.meas tran vdout0_11ck1350 FIND v(dout0_11) AT=680.025n

.meas tran vdout0_12ck1350 FIND v(dout0_12) AT=680.025n

.meas tran vdout0_13ck1350 FIND v(dout0_13) AT=680.025n

.meas tran vdout0_14ck1350 FIND v(dout0_14) AT=680.025n

.meas tran vdout0_15ck1350 FIND v(dout0_15) AT=680.025n

.meas tran vdout0_16ck1350 FIND v(dout0_16) AT=680.025n

.meas tran vdout0_17ck1350 FIND v(dout0_17) AT=680.025n

.meas tran vdout0_18ck1350 FIND v(dout0_18) AT=680.025n

.meas tran vdout0_19ck1350 FIND v(dout0_19) AT=680.025n

.meas tran vdout0_20ck1350 FIND v(dout0_20) AT=680.025n

.meas tran vdout0_21ck1350 FIND v(dout0_21) AT=680.025n

.meas tran vdout0_22ck1350 FIND v(dout0_22) AT=680.025n

.meas tran vdout0_23ck1350 FIND v(dout0_23) AT=680.025n

.meas tran vdout0_24ck1350 FIND v(dout0_24) AT=680.025n

.meas tran vdout0_25ck1350 FIND v(dout0_25) AT=680.025n

.meas tran vdout0_26ck1350 FIND v(dout0_26) AT=680.025n

.meas tran vdout0_27ck1350 FIND v(dout0_27) AT=680.025n

.meas tran vdout0_28ck1350 FIND v(dout0_28) AT=680.025n

.meas tran vdout0_29ck1350 FIND v(dout0_29) AT=680.025n

.meas tran vdout0_30ck1350 FIND v(dout0_30) AT=680.025n

.meas tran vdout0_31ck1350 FIND v(dout0_31) AT=680.025n

.meas tran vdout0_32ck1350 FIND v(dout0_32) AT=680.025n

.meas tran vdout0_33ck1350 FIND v(dout0_33) AT=680.025n

.meas tran vdout0_34ck1350 FIND v(dout0_34) AT=680.025n

.meas tran vdout0_35ck1350 FIND v(dout0_35) AT=680.025n

.meas tran vdout0_36ck1350 FIND v(dout0_36) AT=680.025n

.meas tran vdout0_37ck1350 FIND v(dout0_37) AT=680.025n

.meas tran vdout0_38ck1350 FIND v(dout0_38) AT=680.025n

.meas tran vdout0_39ck1350 FIND v(dout0_39) AT=680.025n

.meas tran vdout0_40ck1350 FIND v(dout0_40) AT=680.025n

.meas tran vdout0_41ck1350 FIND v(dout0_41) AT=680.025n

.meas tran vdout0_42ck1350 FIND v(dout0_42) AT=680.025n

.meas tran vdout0_43ck1350 FIND v(dout0_43) AT=680.025n

.meas tran vdout0_44ck1350 FIND v(dout0_44) AT=680.025n

.meas tran vdout0_45ck1350 FIND v(dout0_45) AT=680.025n

.meas tran vdout0_46ck1350 FIND v(dout0_46) AT=680.025n

.meas tran vdout0_47ck1350 FIND v(dout0_47) AT=680.025n

.meas tran vdout0_48ck1350 FIND v(dout0_48) AT=680.025n

.meas tran vdout0_49ck1350 FIND v(dout0_49) AT=680.025n

.meas tran vdout0_50ck1350 FIND v(dout0_50) AT=680.025n

.meas tran vdout0_51ck1350 FIND v(dout0_51) AT=680.025n

.meas tran vdout0_52ck1350 FIND v(dout0_52) AT=680.025n

.meas tran vdout0_53ck1350 FIND v(dout0_53) AT=680.025n

.meas tran vdout0_54ck1350 FIND v(dout0_54) AT=680.025n

.meas tran vdout0_55ck1350 FIND v(dout0_55) AT=680.025n

.meas tran vdout0_56ck1350 FIND v(dout0_56) AT=680.025n

.meas tran vdout0_57ck1350 FIND v(dout0_57) AT=680.025n

.meas tran vdout0_58ck1350 FIND v(dout0_58) AT=680.025n

.meas tran vdout0_59ck1350 FIND v(dout0_59) AT=680.025n

.meas tran vdout0_60ck1350 FIND v(dout0_60) AT=680.025n

.meas tran vdout0_61ck1350 FIND v(dout0_61) AT=680.025n

.meas tran vdout0_62ck1350 FIND v(dout0_62) AT=680.025n

.meas tran vdout0_63ck1350 FIND v(dout0_63) AT=680.025n

.meas tran vdout0_64ck1350 FIND v(dout0_64) AT=680.025n

.meas tran vdout0_65ck1350 FIND v(dout0_65) AT=680.025n

.meas tran vdout0_66ck1350 FIND v(dout0_66) AT=680.025n

.meas tran vdout0_67ck1350 FIND v(dout0_67) AT=680.025n

.meas tran vdout0_68ck1350 FIND v(dout0_68) AT=680.025n

.meas tran vdout0_69ck1350 FIND v(dout0_69) AT=680.025n

.meas tran vdout0_70ck1350 FIND v(dout0_70) AT=680.025n

.meas tran vdout0_71ck1350 FIND v(dout0_71) AT=680.025n

.meas tran vdout0_72ck1350 FIND v(dout0_72) AT=680.025n

.meas tran vdout0_73ck1350 FIND v(dout0_73) AT=680.025n

.meas tran vdout0_74ck1350 FIND v(dout0_74) AT=680.025n

.meas tran vdout0_75ck1350 FIND v(dout0_75) AT=680.025n

.meas tran vdout0_76ck1350 FIND v(dout0_76) AT=680.025n

.meas tran vdout0_77ck1350 FIND v(dout0_77) AT=680.025n

.meas tran vdout0_78ck1350 FIND v(dout0_78) AT=680.025n

.meas tran vdout0_79ck1350 FIND v(dout0_79) AT=680.025n

.meas tran vdout0_80ck1350 FIND v(dout0_80) AT=680.025n

.meas tran vdout0_81ck1350 FIND v(dout0_81) AT=680.025n

.meas tran vdout0_82ck1350 FIND v(dout0_82) AT=680.025n

.meas tran vdout0_83ck1350 FIND v(dout0_83) AT=680.025n

.meas tran vdout0_84ck1350 FIND v(dout0_84) AT=680.025n

.meas tran vdout0_85ck1350 FIND v(dout0_85) AT=680.025n

.meas tran vdout0_86ck1350 FIND v(dout0_86) AT=680.025n

.meas tran vdout0_87ck1350 FIND v(dout0_87) AT=680.025n

.meas tran vdout0_88ck1350 FIND v(dout0_88) AT=680.025n

.meas tran vdout0_89ck1350 FIND v(dout0_89) AT=680.025n

.meas tran vdout0_90ck1350 FIND v(dout0_90) AT=680.025n

.meas tran vdout0_91ck1350 FIND v(dout0_91) AT=680.025n

.meas tran vdout0_92ck1350 FIND v(dout0_92) AT=680.025n

.meas tran vdout0_93ck1350 FIND v(dout0_93) AT=680.025n

.meas tran vdout0_94ck1350 FIND v(dout0_94) AT=680.025n

.meas tran vdout0_95ck1350 FIND v(dout0_95) AT=680.025n

.meas tran vdout0_96ck1350 FIND v(dout0_96) AT=680.025n

.meas tran vdout0_97ck1350 FIND v(dout0_97) AT=680.025n

.meas tran vdout0_98ck1350 FIND v(dout0_98) AT=680.025n

.meas tran vdout0_99ck1350 FIND v(dout0_99) AT=680.025n

.meas tran vdout0_100ck1350 FIND v(dout0_100) AT=680.025n

.meas tran vdout0_101ck1350 FIND v(dout0_101) AT=680.025n

.meas tran vdout0_102ck1350 FIND v(dout0_102) AT=680.025n

.meas tran vdout0_103ck1350 FIND v(dout0_103) AT=680.025n

.meas tran vdout0_104ck1350 FIND v(dout0_104) AT=680.025n

.meas tran vdout0_105ck1350 FIND v(dout0_105) AT=680.025n

.meas tran vdout0_106ck1350 FIND v(dout0_106) AT=680.025n

.meas tran vdout0_107ck1350 FIND v(dout0_107) AT=680.025n

.meas tran vdout0_108ck1350 FIND v(dout0_108) AT=680.025n

.meas tran vdout0_109ck1350 FIND v(dout0_109) AT=680.025n

.meas tran vdout0_110ck1350 FIND v(dout0_110) AT=680.025n

.meas tran vdout0_111ck1350 FIND v(dout0_111) AT=680.025n

.meas tran vdout0_112ck1350 FIND v(dout0_112) AT=680.025n

.meas tran vdout0_113ck1350 FIND v(dout0_113) AT=680.025n

.meas tran vdout0_114ck1350 FIND v(dout0_114) AT=680.025n

.meas tran vdout0_115ck1350 FIND v(dout0_115) AT=680.025n

.meas tran vdout0_116ck1350 FIND v(dout0_116) AT=680.025n

.meas tran vdout0_117ck1350 FIND v(dout0_117) AT=680.025n

.meas tran vdout0_118ck1350 FIND v(dout0_118) AT=680.025n

.meas tran vdout0_119ck1350 FIND v(dout0_119) AT=680.025n

.meas tran vdout0_120ck1350 FIND v(dout0_120) AT=680.025n

.meas tran vdout0_121ck1350 FIND v(dout0_121) AT=680.025n

.meas tran vdout0_122ck1350 FIND v(dout0_122) AT=680.025n

.meas tran vdout0_123ck1350 FIND v(dout0_123) AT=680.025n

.meas tran vdout0_124ck1350 FIND v(dout0_124) AT=680.025n

.meas tran vdout0_125ck1350 FIND v(dout0_125) AT=680.025n

.meas tran vdout0_126ck1350 FIND v(dout0_126) AT=680.025n

.meas tran vdout0_127ck1350 FIND v(dout0_127) AT=680.025n

.meas tran vdout0_128ck1350 FIND v(dout0_128) AT=680.025n

.meas tran vdout0_129ck1350 FIND v(dout0_129) AT=680.025n

.meas tran vdout0_130ck1350 FIND v(dout0_130) AT=680.025n

.meas tran vdout0_131ck1350 FIND v(dout0_131) AT=680.025n

.meas tran vdout0_132ck1350 FIND v(dout0_132) AT=680.025n

.meas tran vdout0_133ck1350 FIND v(dout0_133) AT=680.025n

.meas tran vdout0_134ck1350 FIND v(dout0_134) AT=680.025n

.meas tran vdout0_135ck1350 FIND v(dout0_135) AT=680.025n

.meas tran vdout0_136ck1350 FIND v(dout0_136) AT=680.025n

.meas tran vdout0_137ck1350 FIND v(dout0_137) AT=680.025n

.meas tran vdout0_138ck1350 FIND v(dout0_138) AT=680.025n

.meas tran vdout0_139ck1350 FIND v(dout0_139) AT=680.025n

.meas tran vdout0_140ck1350 FIND v(dout0_140) AT=680.025n

.meas tran vdout0_141ck1350 FIND v(dout0_141) AT=680.025n

.meas tran vdout0_142ck1350 FIND v(dout0_142) AT=680.025n

.meas tran vdout0_143ck1350 FIND v(dout0_143) AT=680.025n

.meas tran vdout0_144ck1350 FIND v(dout0_144) AT=680.025n

.meas tran vdout0_145ck1350 FIND v(dout0_145) AT=680.025n

.meas tran vdout0_146ck1350 FIND v(dout0_146) AT=680.025n

.meas tran vdout0_147ck1350 FIND v(dout0_147) AT=680.025n

.meas tran vdout0_148ck1350 FIND v(dout0_148) AT=680.025n

.meas tran vdout0_149ck1350 FIND v(dout0_149) AT=680.025n

.meas tran vdout0_0ck1360 FIND v(dout0_0) AT=685.025n

.meas tran vdout0_1ck1360 FIND v(dout0_1) AT=685.025n

.meas tran vdout0_2ck1360 FIND v(dout0_2) AT=685.025n

.meas tran vdout0_3ck1360 FIND v(dout0_3) AT=685.025n

.meas tran vdout0_4ck1360 FIND v(dout0_4) AT=685.025n

.meas tran vdout0_5ck1360 FIND v(dout0_5) AT=685.025n

.meas tran vdout0_6ck1360 FIND v(dout0_6) AT=685.025n

.meas tran vdout0_7ck1360 FIND v(dout0_7) AT=685.025n

.meas tran vdout0_8ck1360 FIND v(dout0_8) AT=685.025n

.meas tran vdout0_9ck1360 FIND v(dout0_9) AT=685.025n

.meas tran vdout0_10ck1360 FIND v(dout0_10) AT=685.025n

.meas tran vdout0_11ck1360 FIND v(dout0_11) AT=685.025n

.meas tran vdout0_12ck1360 FIND v(dout0_12) AT=685.025n

.meas tran vdout0_13ck1360 FIND v(dout0_13) AT=685.025n

.meas tran vdout0_14ck1360 FIND v(dout0_14) AT=685.025n

.meas tran vdout0_15ck1360 FIND v(dout0_15) AT=685.025n

.meas tran vdout0_16ck1360 FIND v(dout0_16) AT=685.025n

.meas tran vdout0_17ck1360 FIND v(dout0_17) AT=685.025n

.meas tran vdout0_18ck1360 FIND v(dout0_18) AT=685.025n

.meas tran vdout0_19ck1360 FIND v(dout0_19) AT=685.025n

.meas tran vdout0_20ck1360 FIND v(dout0_20) AT=685.025n

.meas tran vdout0_21ck1360 FIND v(dout0_21) AT=685.025n

.meas tran vdout0_22ck1360 FIND v(dout0_22) AT=685.025n

.meas tran vdout0_23ck1360 FIND v(dout0_23) AT=685.025n

.meas tran vdout0_24ck1360 FIND v(dout0_24) AT=685.025n

.meas tran vdout0_25ck1360 FIND v(dout0_25) AT=685.025n

.meas tran vdout0_26ck1360 FIND v(dout0_26) AT=685.025n

.meas tran vdout0_27ck1360 FIND v(dout0_27) AT=685.025n

.meas tran vdout0_28ck1360 FIND v(dout0_28) AT=685.025n

.meas tran vdout0_29ck1360 FIND v(dout0_29) AT=685.025n

.meas tran vdout0_30ck1360 FIND v(dout0_30) AT=685.025n

.meas tran vdout0_31ck1360 FIND v(dout0_31) AT=685.025n

.meas tran vdout0_32ck1360 FIND v(dout0_32) AT=685.025n

.meas tran vdout0_33ck1360 FIND v(dout0_33) AT=685.025n

.meas tran vdout0_34ck1360 FIND v(dout0_34) AT=685.025n

.meas tran vdout0_35ck1360 FIND v(dout0_35) AT=685.025n

.meas tran vdout0_36ck1360 FIND v(dout0_36) AT=685.025n

.meas tran vdout0_37ck1360 FIND v(dout0_37) AT=685.025n

.meas tran vdout0_38ck1360 FIND v(dout0_38) AT=685.025n

.meas tran vdout0_39ck1360 FIND v(dout0_39) AT=685.025n

.meas tran vdout0_40ck1360 FIND v(dout0_40) AT=685.025n

.meas tran vdout0_41ck1360 FIND v(dout0_41) AT=685.025n

.meas tran vdout0_42ck1360 FIND v(dout0_42) AT=685.025n

.meas tran vdout0_43ck1360 FIND v(dout0_43) AT=685.025n

.meas tran vdout0_44ck1360 FIND v(dout0_44) AT=685.025n

.meas tran vdout0_45ck1360 FIND v(dout0_45) AT=685.025n

.meas tran vdout0_46ck1360 FIND v(dout0_46) AT=685.025n

.meas tran vdout0_47ck1360 FIND v(dout0_47) AT=685.025n

.meas tran vdout0_48ck1360 FIND v(dout0_48) AT=685.025n

.meas tran vdout0_49ck1360 FIND v(dout0_49) AT=685.025n

.meas tran vdout0_50ck1360 FIND v(dout0_50) AT=685.025n

.meas tran vdout0_51ck1360 FIND v(dout0_51) AT=685.025n

.meas tran vdout0_52ck1360 FIND v(dout0_52) AT=685.025n

.meas tran vdout0_53ck1360 FIND v(dout0_53) AT=685.025n

.meas tran vdout0_54ck1360 FIND v(dout0_54) AT=685.025n

.meas tran vdout0_55ck1360 FIND v(dout0_55) AT=685.025n

.meas tran vdout0_56ck1360 FIND v(dout0_56) AT=685.025n

.meas tran vdout0_57ck1360 FIND v(dout0_57) AT=685.025n

.meas tran vdout0_58ck1360 FIND v(dout0_58) AT=685.025n

.meas tran vdout0_59ck1360 FIND v(dout0_59) AT=685.025n

.meas tran vdout0_60ck1360 FIND v(dout0_60) AT=685.025n

.meas tran vdout0_61ck1360 FIND v(dout0_61) AT=685.025n

.meas tran vdout0_62ck1360 FIND v(dout0_62) AT=685.025n

.meas tran vdout0_63ck1360 FIND v(dout0_63) AT=685.025n

.meas tran vdout0_64ck1360 FIND v(dout0_64) AT=685.025n

.meas tran vdout0_65ck1360 FIND v(dout0_65) AT=685.025n

.meas tran vdout0_66ck1360 FIND v(dout0_66) AT=685.025n

.meas tran vdout0_67ck1360 FIND v(dout0_67) AT=685.025n

.meas tran vdout0_68ck1360 FIND v(dout0_68) AT=685.025n

.meas tran vdout0_69ck1360 FIND v(dout0_69) AT=685.025n

.meas tran vdout0_70ck1360 FIND v(dout0_70) AT=685.025n

.meas tran vdout0_71ck1360 FIND v(dout0_71) AT=685.025n

.meas tran vdout0_72ck1360 FIND v(dout0_72) AT=685.025n

.meas tran vdout0_73ck1360 FIND v(dout0_73) AT=685.025n

.meas tran vdout0_74ck1360 FIND v(dout0_74) AT=685.025n

.meas tran vdout0_75ck1360 FIND v(dout0_75) AT=685.025n

.meas tran vdout0_76ck1360 FIND v(dout0_76) AT=685.025n

.meas tran vdout0_77ck1360 FIND v(dout0_77) AT=685.025n

.meas tran vdout0_78ck1360 FIND v(dout0_78) AT=685.025n

.meas tran vdout0_79ck1360 FIND v(dout0_79) AT=685.025n

.meas tran vdout0_80ck1360 FIND v(dout0_80) AT=685.025n

.meas tran vdout0_81ck1360 FIND v(dout0_81) AT=685.025n

.meas tran vdout0_82ck1360 FIND v(dout0_82) AT=685.025n

.meas tran vdout0_83ck1360 FIND v(dout0_83) AT=685.025n

.meas tran vdout0_84ck1360 FIND v(dout0_84) AT=685.025n

.meas tran vdout0_85ck1360 FIND v(dout0_85) AT=685.025n

.meas tran vdout0_86ck1360 FIND v(dout0_86) AT=685.025n

.meas tran vdout0_87ck1360 FIND v(dout0_87) AT=685.025n

.meas tran vdout0_88ck1360 FIND v(dout0_88) AT=685.025n

.meas tran vdout0_89ck1360 FIND v(dout0_89) AT=685.025n

.meas tran vdout0_90ck1360 FIND v(dout0_90) AT=685.025n

.meas tran vdout0_91ck1360 FIND v(dout0_91) AT=685.025n

.meas tran vdout0_92ck1360 FIND v(dout0_92) AT=685.025n

.meas tran vdout0_93ck1360 FIND v(dout0_93) AT=685.025n

.meas tran vdout0_94ck1360 FIND v(dout0_94) AT=685.025n

.meas tran vdout0_95ck1360 FIND v(dout0_95) AT=685.025n

.meas tran vdout0_96ck1360 FIND v(dout0_96) AT=685.025n

.meas tran vdout0_97ck1360 FIND v(dout0_97) AT=685.025n

.meas tran vdout0_98ck1360 FIND v(dout0_98) AT=685.025n

.meas tran vdout0_99ck1360 FIND v(dout0_99) AT=685.025n

.meas tran vdout0_100ck1360 FIND v(dout0_100) AT=685.025n

.meas tran vdout0_101ck1360 FIND v(dout0_101) AT=685.025n

.meas tran vdout0_102ck1360 FIND v(dout0_102) AT=685.025n

.meas tran vdout0_103ck1360 FIND v(dout0_103) AT=685.025n

.meas tran vdout0_104ck1360 FIND v(dout0_104) AT=685.025n

.meas tran vdout0_105ck1360 FIND v(dout0_105) AT=685.025n

.meas tran vdout0_106ck1360 FIND v(dout0_106) AT=685.025n

.meas tran vdout0_107ck1360 FIND v(dout0_107) AT=685.025n

.meas tran vdout0_108ck1360 FIND v(dout0_108) AT=685.025n

.meas tran vdout0_109ck1360 FIND v(dout0_109) AT=685.025n

.meas tran vdout0_110ck1360 FIND v(dout0_110) AT=685.025n

.meas tran vdout0_111ck1360 FIND v(dout0_111) AT=685.025n

.meas tran vdout0_112ck1360 FIND v(dout0_112) AT=685.025n

.meas tran vdout0_113ck1360 FIND v(dout0_113) AT=685.025n

.meas tran vdout0_114ck1360 FIND v(dout0_114) AT=685.025n

.meas tran vdout0_115ck1360 FIND v(dout0_115) AT=685.025n

.meas tran vdout0_116ck1360 FIND v(dout0_116) AT=685.025n

.meas tran vdout0_117ck1360 FIND v(dout0_117) AT=685.025n

.meas tran vdout0_118ck1360 FIND v(dout0_118) AT=685.025n

.meas tran vdout0_119ck1360 FIND v(dout0_119) AT=685.025n

.meas tran vdout0_120ck1360 FIND v(dout0_120) AT=685.025n

.meas tran vdout0_121ck1360 FIND v(dout0_121) AT=685.025n

.meas tran vdout0_122ck1360 FIND v(dout0_122) AT=685.025n

.meas tran vdout0_123ck1360 FIND v(dout0_123) AT=685.025n

.meas tran vdout0_124ck1360 FIND v(dout0_124) AT=685.025n

.meas tran vdout0_125ck1360 FIND v(dout0_125) AT=685.025n

.meas tran vdout0_126ck1360 FIND v(dout0_126) AT=685.025n

.meas tran vdout0_127ck1360 FIND v(dout0_127) AT=685.025n

.meas tran vdout0_128ck1360 FIND v(dout0_128) AT=685.025n

.meas tran vdout0_129ck1360 FIND v(dout0_129) AT=685.025n

.meas tran vdout0_130ck1360 FIND v(dout0_130) AT=685.025n

.meas tran vdout0_131ck1360 FIND v(dout0_131) AT=685.025n

.meas tran vdout0_132ck1360 FIND v(dout0_132) AT=685.025n

.meas tran vdout0_133ck1360 FIND v(dout0_133) AT=685.025n

.meas tran vdout0_134ck1360 FIND v(dout0_134) AT=685.025n

.meas tran vdout0_135ck1360 FIND v(dout0_135) AT=685.025n

.meas tran vdout0_136ck1360 FIND v(dout0_136) AT=685.025n

.meas tran vdout0_137ck1360 FIND v(dout0_137) AT=685.025n

.meas tran vdout0_138ck1360 FIND v(dout0_138) AT=685.025n

.meas tran vdout0_139ck1360 FIND v(dout0_139) AT=685.025n

.meas tran vdout0_140ck1360 FIND v(dout0_140) AT=685.025n

.meas tran vdout0_141ck1360 FIND v(dout0_141) AT=685.025n

.meas tran vdout0_142ck1360 FIND v(dout0_142) AT=685.025n

.meas tran vdout0_143ck1360 FIND v(dout0_143) AT=685.025n

.meas tran vdout0_144ck1360 FIND v(dout0_144) AT=685.025n

.meas tran vdout0_145ck1360 FIND v(dout0_145) AT=685.025n

.meas tran vdout0_146ck1360 FIND v(dout0_146) AT=685.025n

.meas tran vdout0_147ck1360 FIND v(dout0_147) AT=685.025n

.meas tran vdout0_148ck1360 FIND v(dout0_148) AT=685.025n

.meas tran vdout0_149ck1360 FIND v(dout0_149) AT=685.025n

.meas tran vdout0_0ck1370 FIND v(dout0_0) AT=690.025n

.meas tran vdout0_1ck1370 FIND v(dout0_1) AT=690.025n

.meas tran vdout0_2ck1370 FIND v(dout0_2) AT=690.025n

.meas tran vdout0_3ck1370 FIND v(dout0_3) AT=690.025n

.meas tran vdout0_4ck1370 FIND v(dout0_4) AT=690.025n

.meas tran vdout0_5ck1370 FIND v(dout0_5) AT=690.025n

.meas tran vdout0_6ck1370 FIND v(dout0_6) AT=690.025n

.meas tran vdout0_7ck1370 FIND v(dout0_7) AT=690.025n

.meas tran vdout0_8ck1370 FIND v(dout0_8) AT=690.025n

.meas tran vdout0_9ck1370 FIND v(dout0_9) AT=690.025n

.meas tran vdout0_10ck1370 FIND v(dout0_10) AT=690.025n

.meas tran vdout0_11ck1370 FIND v(dout0_11) AT=690.025n

.meas tran vdout0_12ck1370 FIND v(dout0_12) AT=690.025n

.meas tran vdout0_13ck1370 FIND v(dout0_13) AT=690.025n

.meas tran vdout0_14ck1370 FIND v(dout0_14) AT=690.025n

.meas tran vdout0_15ck1370 FIND v(dout0_15) AT=690.025n

.meas tran vdout0_16ck1370 FIND v(dout0_16) AT=690.025n

.meas tran vdout0_17ck1370 FIND v(dout0_17) AT=690.025n

.meas tran vdout0_18ck1370 FIND v(dout0_18) AT=690.025n

.meas tran vdout0_19ck1370 FIND v(dout0_19) AT=690.025n

.meas tran vdout0_20ck1370 FIND v(dout0_20) AT=690.025n

.meas tran vdout0_21ck1370 FIND v(dout0_21) AT=690.025n

.meas tran vdout0_22ck1370 FIND v(dout0_22) AT=690.025n

.meas tran vdout0_23ck1370 FIND v(dout0_23) AT=690.025n

.meas tran vdout0_24ck1370 FIND v(dout0_24) AT=690.025n

.meas tran vdout0_25ck1370 FIND v(dout0_25) AT=690.025n

.meas tran vdout0_26ck1370 FIND v(dout0_26) AT=690.025n

.meas tran vdout0_27ck1370 FIND v(dout0_27) AT=690.025n

.meas tran vdout0_28ck1370 FIND v(dout0_28) AT=690.025n

.meas tran vdout0_29ck1370 FIND v(dout0_29) AT=690.025n

.meas tran vdout0_30ck1370 FIND v(dout0_30) AT=690.025n

.meas tran vdout0_31ck1370 FIND v(dout0_31) AT=690.025n

.meas tran vdout0_32ck1370 FIND v(dout0_32) AT=690.025n

.meas tran vdout0_33ck1370 FIND v(dout0_33) AT=690.025n

.meas tran vdout0_34ck1370 FIND v(dout0_34) AT=690.025n

.meas tran vdout0_35ck1370 FIND v(dout0_35) AT=690.025n

.meas tran vdout0_36ck1370 FIND v(dout0_36) AT=690.025n

.meas tran vdout0_37ck1370 FIND v(dout0_37) AT=690.025n

.meas tran vdout0_38ck1370 FIND v(dout0_38) AT=690.025n

.meas tran vdout0_39ck1370 FIND v(dout0_39) AT=690.025n

.meas tran vdout0_40ck1370 FIND v(dout0_40) AT=690.025n

.meas tran vdout0_41ck1370 FIND v(dout0_41) AT=690.025n

.meas tran vdout0_42ck1370 FIND v(dout0_42) AT=690.025n

.meas tran vdout0_43ck1370 FIND v(dout0_43) AT=690.025n

.meas tran vdout0_44ck1370 FIND v(dout0_44) AT=690.025n

.meas tran vdout0_45ck1370 FIND v(dout0_45) AT=690.025n

.meas tran vdout0_46ck1370 FIND v(dout0_46) AT=690.025n

.meas tran vdout0_47ck1370 FIND v(dout0_47) AT=690.025n

.meas tran vdout0_48ck1370 FIND v(dout0_48) AT=690.025n

.meas tran vdout0_49ck1370 FIND v(dout0_49) AT=690.025n

.meas tran vdout0_50ck1370 FIND v(dout0_50) AT=690.025n

.meas tran vdout0_51ck1370 FIND v(dout0_51) AT=690.025n

.meas tran vdout0_52ck1370 FIND v(dout0_52) AT=690.025n

.meas tran vdout0_53ck1370 FIND v(dout0_53) AT=690.025n

.meas tran vdout0_54ck1370 FIND v(dout0_54) AT=690.025n

.meas tran vdout0_55ck1370 FIND v(dout0_55) AT=690.025n

.meas tran vdout0_56ck1370 FIND v(dout0_56) AT=690.025n

.meas tran vdout0_57ck1370 FIND v(dout0_57) AT=690.025n

.meas tran vdout0_58ck1370 FIND v(dout0_58) AT=690.025n

.meas tran vdout0_59ck1370 FIND v(dout0_59) AT=690.025n

.meas tran vdout0_60ck1370 FIND v(dout0_60) AT=690.025n

.meas tran vdout0_61ck1370 FIND v(dout0_61) AT=690.025n

.meas tran vdout0_62ck1370 FIND v(dout0_62) AT=690.025n

.meas tran vdout0_63ck1370 FIND v(dout0_63) AT=690.025n

.meas tran vdout0_64ck1370 FIND v(dout0_64) AT=690.025n

.meas tran vdout0_65ck1370 FIND v(dout0_65) AT=690.025n

.meas tran vdout0_66ck1370 FIND v(dout0_66) AT=690.025n

.meas tran vdout0_67ck1370 FIND v(dout0_67) AT=690.025n

.meas tran vdout0_68ck1370 FIND v(dout0_68) AT=690.025n

.meas tran vdout0_69ck1370 FIND v(dout0_69) AT=690.025n

.meas tran vdout0_70ck1370 FIND v(dout0_70) AT=690.025n

.meas tran vdout0_71ck1370 FIND v(dout0_71) AT=690.025n

.meas tran vdout0_72ck1370 FIND v(dout0_72) AT=690.025n

.meas tran vdout0_73ck1370 FIND v(dout0_73) AT=690.025n

.meas tran vdout0_74ck1370 FIND v(dout0_74) AT=690.025n

.meas tran vdout0_75ck1370 FIND v(dout0_75) AT=690.025n

.meas tran vdout0_76ck1370 FIND v(dout0_76) AT=690.025n

.meas tran vdout0_77ck1370 FIND v(dout0_77) AT=690.025n

.meas tran vdout0_78ck1370 FIND v(dout0_78) AT=690.025n

.meas tran vdout0_79ck1370 FIND v(dout0_79) AT=690.025n

.meas tran vdout0_80ck1370 FIND v(dout0_80) AT=690.025n

.meas tran vdout0_81ck1370 FIND v(dout0_81) AT=690.025n

.meas tran vdout0_82ck1370 FIND v(dout0_82) AT=690.025n

.meas tran vdout0_83ck1370 FIND v(dout0_83) AT=690.025n

.meas tran vdout0_84ck1370 FIND v(dout0_84) AT=690.025n

.meas tran vdout0_85ck1370 FIND v(dout0_85) AT=690.025n

.meas tran vdout0_86ck1370 FIND v(dout0_86) AT=690.025n

.meas tran vdout0_87ck1370 FIND v(dout0_87) AT=690.025n

.meas tran vdout0_88ck1370 FIND v(dout0_88) AT=690.025n

.meas tran vdout0_89ck1370 FIND v(dout0_89) AT=690.025n

.meas tran vdout0_90ck1370 FIND v(dout0_90) AT=690.025n

.meas tran vdout0_91ck1370 FIND v(dout0_91) AT=690.025n

.meas tran vdout0_92ck1370 FIND v(dout0_92) AT=690.025n

.meas tran vdout0_93ck1370 FIND v(dout0_93) AT=690.025n

.meas tran vdout0_94ck1370 FIND v(dout0_94) AT=690.025n

.meas tran vdout0_95ck1370 FIND v(dout0_95) AT=690.025n

.meas tran vdout0_96ck1370 FIND v(dout0_96) AT=690.025n

.meas tran vdout0_97ck1370 FIND v(dout0_97) AT=690.025n

.meas tran vdout0_98ck1370 FIND v(dout0_98) AT=690.025n

.meas tran vdout0_99ck1370 FIND v(dout0_99) AT=690.025n

.meas tran vdout0_100ck1370 FIND v(dout0_100) AT=690.025n

.meas tran vdout0_101ck1370 FIND v(dout0_101) AT=690.025n

.meas tran vdout0_102ck1370 FIND v(dout0_102) AT=690.025n

.meas tran vdout0_103ck1370 FIND v(dout0_103) AT=690.025n

.meas tran vdout0_104ck1370 FIND v(dout0_104) AT=690.025n

.meas tran vdout0_105ck1370 FIND v(dout0_105) AT=690.025n

.meas tran vdout0_106ck1370 FIND v(dout0_106) AT=690.025n

.meas tran vdout0_107ck1370 FIND v(dout0_107) AT=690.025n

.meas tran vdout0_108ck1370 FIND v(dout0_108) AT=690.025n

.meas tran vdout0_109ck1370 FIND v(dout0_109) AT=690.025n

.meas tran vdout0_110ck1370 FIND v(dout0_110) AT=690.025n

.meas tran vdout0_111ck1370 FIND v(dout0_111) AT=690.025n

.meas tran vdout0_112ck1370 FIND v(dout0_112) AT=690.025n

.meas tran vdout0_113ck1370 FIND v(dout0_113) AT=690.025n

.meas tran vdout0_114ck1370 FIND v(dout0_114) AT=690.025n

.meas tran vdout0_115ck1370 FIND v(dout0_115) AT=690.025n

.meas tran vdout0_116ck1370 FIND v(dout0_116) AT=690.025n

.meas tran vdout0_117ck1370 FIND v(dout0_117) AT=690.025n

.meas tran vdout0_118ck1370 FIND v(dout0_118) AT=690.025n

.meas tran vdout0_119ck1370 FIND v(dout0_119) AT=690.025n

.meas tran vdout0_120ck1370 FIND v(dout0_120) AT=690.025n

.meas tran vdout0_121ck1370 FIND v(dout0_121) AT=690.025n

.meas tran vdout0_122ck1370 FIND v(dout0_122) AT=690.025n

.meas tran vdout0_123ck1370 FIND v(dout0_123) AT=690.025n

.meas tran vdout0_124ck1370 FIND v(dout0_124) AT=690.025n

.meas tran vdout0_125ck1370 FIND v(dout0_125) AT=690.025n

.meas tran vdout0_126ck1370 FIND v(dout0_126) AT=690.025n

.meas tran vdout0_127ck1370 FIND v(dout0_127) AT=690.025n

.meas tran vdout0_128ck1370 FIND v(dout0_128) AT=690.025n

.meas tran vdout0_129ck1370 FIND v(dout0_129) AT=690.025n

.meas tran vdout0_130ck1370 FIND v(dout0_130) AT=690.025n

.meas tran vdout0_131ck1370 FIND v(dout0_131) AT=690.025n

.meas tran vdout0_132ck1370 FIND v(dout0_132) AT=690.025n

.meas tran vdout0_133ck1370 FIND v(dout0_133) AT=690.025n

.meas tran vdout0_134ck1370 FIND v(dout0_134) AT=690.025n

.meas tran vdout0_135ck1370 FIND v(dout0_135) AT=690.025n

.meas tran vdout0_136ck1370 FIND v(dout0_136) AT=690.025n

.meas tran vdout0_137ck1370 FIND v(dout0_137) AT=690.025n

.meas tran vdout0_138ck1370 FIND v(dout0_138) AT=690.025n

.meas tran vdout0_139ck1370 FIND v(dout0_139) AT=690.025n

.meas tran vdout0_140ck1370 FIND v(dout0_140) AT=690.025n

.meas tran vdout0_141ck1370 FIND v(dout0_141) AT=690.025n

.meas tran vdout0_142ck1370 FIND v(dout0_142) AT=690.025n

.meas tran vdout0_143ck1370 FIND v(dout0_143) AT=690.025n

.meas tran vdout0_144ck1370 FIND v(dout0_144) AT=690.025n

.meas tran vdout0_145ck1370 FIND v(dout0_145) AT=690.025n

.meas tran vdout0_146ck1370 FIND v(dout0_146) AT=690.025n

.meas tran vdout0_147ck1370 FIND v(dout0_147) AT=690.025n

.meas tran vdout0_148ck1370 FIND v(dout0_148) AT=690.025n

.meas tran vdout0_149ck1370 FIND v(dout0_149) AT=690.025n

.meas tran vdout0_0ck1380 FIND v(dout0_0) AT=695.025n

.meas tran vdout0_1ck1380 FIND v(dout0_1) AT=695.025n

.meas tran vdout0_2ck1380 FIND v(dout0_2) AT=695.025n

.meas tran vdout0_3ck1380 FIND v(dout0_3) AT=695.025n

.meas tran vdout0_4ck1380 FIND v(dout0_4) AT=695.025n

.meas tran vdout0_5ck1380 FIND v(dout0_5) AT=695.025n

.meas tran vdout0_6ck1380 FIND v(dout0_6) AT=695.025n

.meas tran vdout0_7ck1380 FIND v(dout0_7) AT=695.025n

.meas tran vdout0_8ck1380 FIND v(dout0_8) AT=695.025n

.meas tran vdout0_9ck1380 FIND v(dout0_9) AT=695.025n

.meas tran vdout0_10ck1380 FIND v(dout0_10) AT=695.025n

.meas tran vdout0_11ck1380 FIND v(dout0_11) AT=695.025n

.meas tran vdout0_12ck1380 FIND v(dout0_12) AT=695.025n

.meas tran vdout0_13ck1380 FIND v(dout0_13) AT=695.025n

.meas tran vdout0_14ck1380 FIND v(dout0_14) AT=695.025n

.meas tran vdout0_15ck1380 FIND v(dout0_15) AT=695.025n

.meas tran vdout0_16ck1380 FIND v(dout0_16) AT=695.025n

.meas tran vdout0_17ck1380 FIND v(dout0_17) AT=695.025n

.meas tran vdout0_18ck1380 FIND v(dout0_18) AT=695.025n

.meas tran vdout0_19ck1380 FIND v(dout0_19) AT=695.025n

.meas tran vdout0_20ck1380 FIND v(dout0_20) AT=695.025n

.meas tran vdout0_21ck1380 FIND v(dout0_21) AT=695.025n

.meas tran vdout0_22ck1380 FIND v(dout0_22) AT=695.025n

.meas tran vdout0_23ck1380 FIND v(dout0_23) AT=695.025n

.meas tran vdout0_24ck1380 FIND v(dout0_24) AT=695.025n

.meas tran vdout0_25ck1380 FIND v(dout0_25) AT=695.025n

.meas tran vdout0_26ck1380 FIND v(dout0_26) AT=695.025n

.meas tran vdout0_27ck1380 FIND v(dout0_27) AT=695.025n

.meas tran vdout0_28ck1380 FIND v(dout0_28) AT=695.025n

.meas tran vdout0_29ck1380 FIND v(dout0_29) AT=695.025n

.meas tran vdout0_30ck1380 FIND v(dout0_30) AT=695.025n

.meas tran vdout0_31ck1380 FIND v(dout0_31) AT=695.025n

.meas tran vdout0_32ck1380 FIND v(dout0_32) AT=695.025n

.meas tran vdout0_33ck1380 FIND v(dout0_33) AT=695.025n

.meas tran vdout0_34ck1380 FIND v(dout0_34) AT=695.025n

.meas tran vdout0_35ck1380 FIND v(dout0_35) AT=695.025n

.meas tran vdout0_36ck1380 FIND v(dout0_36) AT=695.025n

.meas tran vdout0_37ck1380 FIND v(dout0_37) AT=695.025n

.meas tran vdout0_38ck1380 FIND v(dout0_38) AT=695.025n

.meas tran vdout0_39ck1380 FIND v(dout0_39) AT=695.025n

.meas tran vdout0_40ck1380 FIND v(dout0_40) AT=695.025n

.meas tran vdout0_41ck1380 FIND v(dout0_41) AT=695.025n

.meas tran vdout0_42ck1380 FIND v(dout0_42) AT=695.025n

.meas tran vdout0_43ck1380 FIND v(dout0_43) AT=695.025n

.meas tran vdout0_44ck1380 FIND v(dout0_44) AT=695.025n

.meas tran vdout0_45ck1380 FIND v(dout0_45) AT=695.025n

.meas tran vdout0_46ck1380 FIND v(dout0_46) AT=695.025n

.meas tran vdout0_47ck1380 FIND v(dout0_47) AT=695.025n

.meas tran vdout0_48ck1380 FIND v(dout0_48) AT=695.025n

.meas tran vdout0_49ck1380 FIND v(dout0_49) AT=695.025n

.meas tran vdout0_50ck1380 FIND v(dout0_50) AT=695.025n

.meas tran vdout0_51ck1380 FIND v(dout0_51) AT=695.025n

.meas tran vdout0_52ck1380 FIND v(dout0_52) AT=695.025n

.meas tran vdout0_53ck1380 FIND v(dout0_53) AT=695.025n

.meas tran vdout0_54ck1380 FIND v(dout0_54) AT=695.025n

.meas tran vdout0_55ck1380 FIND v(dout0_55) AT=695.025n

.meas tran vdout0_56ck1380 FIND v(dout0_56) AT=695.025n

.meas tran vdout0_57ck1380 FIND v(dout0_57) AT=695.025n

.meas tran vdout0_58ck1380 FIND v(dout0_58) AT=695.025n

.meas tran vdout0_59ck1380 FIND v(dout0_59) AT=695.025n

.meas tran vdout0_60ck1380 FIND v(dout0_60) AT=695.025n

.meas tran vdout0_61ck1380 FIND v(dout0_61) AT=695.025n

.meas tran vdout0_62ck1380 FIND v(dout0_62) AT=695.025n

.meas tran vdout0_63ck1380 FIND v(dout0_63) AT=695.025n

.meas tran vdout0_64ck1380 FIND v(dout0_64) AT=695.025n

.meas tran vdout0_65ck1380 FIND v(dout0_65) AT=695.025n

.meas tran vdout0_66ck1380 FIND v(dout0_66) AT=695.025n

.meas tran vdout0_67ck1380 FIND v(dout0_67) AT=695.025n

.meas tran vdout0_68ck1380 FIND v(dout0_68) AT=695.025n

.meas tran vdout0_69ck1380 FIND v(dout0_69) AT=695.025n

.meas tran vdout0_70ck1380 FIND v(dout0_70) AT=695.025n

.meas tran vdout0_71ck1380 FIND v(dout0_71) AT=695.025n

.meas tran vdout0_72ck1380 FIND v(dout0_72) AT=695.025n

.meas tran vdout0_73ck1380 FIND v(dout0_73) AT=695.025n

.meas tran vdout0_74ck1380 FIND v(dout0_74) AT=695.025n

.meas tran vdout0_75ck1380 FIND v(dout0_75) AT=695.025n

.meas tran vdout0_76ck1380 FIND v(dout0_76) AT=695.025n

.meas tran vdout0_77ck1380 FIND v(dout0_77) AT=695.025n

.meas tran vdout0_78ck1380 FIND v(dout0_78) AT=695.025n

.meas tran vdout0_79ck1380 FIND v(dout0_79) AT=695.025n

.meas tran vdout0_80ck1380 FIND v(dout0_80) AT=695.025n

.meas tran vdout0_81ck1380 FIND v(dout0_81) AT=695.025n

.meas tran vdout0_82ck1380 FIND v(dout0_82) AT=695.025n

.meas tran vdout0_83ck1380 FIND v(dout0_83) AT=695.025n

.meas tran vdout0_84ck1380 FIND v(dout0_84) AT=695.025n

.meas tran vdout0_85ck1380 FIND v(dout0_85) AT=695.025n

.meas tran vdout0_86ck1380 FIND v(dout0_86) AT=695.025n

.meas tran vdout0_87ck1380 FIND v(dout0_87) AT=695.025n

.meas tran vdout0_88ck1380 FIND v(dout0_88) AT=695.025n

.meas tran vdout0_89ck1380 FIND v(dout0_89) AT=695.025n

.meas tran vdout0_90ck1380 FIND v(dout0_90) AT=695.025n

.meas tran vdout0_91ck1380 FIND v(dout0_91) AT=695.025n

.meas tran vdout0_92ck1380 FIND v(dout0_92) AT=695.025n

.meas tran vdout0_93ck1380 FIND v(dout0_93) AT=695.025n

.meas tran vdout0_94ck1380 FIND v(dout0_94) AT=695.025n

.meas tran vdout0_95ck1380 FIND v(dout0_95) AT=695.025n

.meas tran vdout0_96ck1380 FIND v(dout0_96) AT=695.025n

.meas tran vdout0_97ck1380 FIND v(dout0_97) AT=695.025n

.meas tran vdout0_98ck1380 FIND v(dout0_98) AT=695.025n

.meas tran vdout0_99ck1380 FIND v(dout0_99) AT=695.025n

.meas tran vdout0_100ck1380 FIND v(dout0_100) AT=695.025n

.meas tran vdout0_101ck1380 FIND v(dout0_101) AT=695.025n

.meas tran vdout0_102ck1380 FIND v(dout0_102) AT=695.025n

.meas tran vdout0_103ck1380 FIND v(dout0_103) AT=695.025n

.meas tran vdout0_104ck1380 FIND v(dout0_104) AT=695.025n

.meas tran vdout0_105ck1380 FIND v(dout0_105) AT=695.025n

.meas tran vdout0_106ck1380 FIND v(dout0_106) AT=695.025n

.meas tran vdout0_107ck1380 FIND v(dout0_107) AT=695.025n

.meas tran vdout0_108ck1380 FIND v(dout0_108) AT=695.025n

.meas tran vdout0_109ck1380 FIND v(dout0_109) AT=695.025n

.meas tran vdout0_110ck1380 FIND v(dout0_110) AT=695.025n

.meas tran vdout0_111ck1380 FIND v(dout0_111) AT=695.025n

.meas tran vdout0_112ck1380 FIND v(dout0_112) AT=695.025n

.meas tran vdout0_113ck1380 FIND v(dout0_113) AT=695.025n

.meas tran vdout0_114ck1380 FIND v(dout0_114) AT=695.025n

.meas tran vdout0_115ck1380 FIND v(dout0_115) AT=695.025n

.meas tran vdout0_116ck1380 FIND v(dout0_116) AT=695.025n

.meas tran vdout0_117ck1380 FIND v(dout0_117) AT=695.025n

.meas tran vdout0_118ck1380 FIND v(dout0_118) AT=695.025n

.meas tran vdout0_119ck1380 FIND v(dout0_119) AT=695.025n

.meas tran vdout0_120ck1380 FIND v(dout0_120) AT=695.025n

.meas tran vdout0_121ck1380 FIND v(dout0_121) AT=695.025n

.meas tran vdout0_122ck1380 FIND v(dout0_122) AT=695.025n

.meas tran vdout0_123ck1380 FIND v(dout0_123) AT=695.025n

.meas tran vdout0_124ck1380 FIND v(dout0_124) AT=695.025n

.meas tran vdout0_125ck1380 FIND v(dout0_125) AT=695.025n

.meas tran vdout0_126ck1380 FIND v(dout0_126) AT=695.025n

.meas tran vdout0_127ck1380 FIND v(dout0_127) AT=695.025n

.meas tran vdout0_128ck1380 FIND v(dout0_128) AT=695.025n

.meas tran vdout0_129ck1380 FIND v(dout0_129) AT=695.025n

.meas tran vdout0_130ck1380 FIND v(dout0_130) AT=695.025n

.meas tran vdout0_131ck1380 FIND v(dout0_131) AT=695.025n

.meas tran vdout0_132ck1380 FIND v(dout0_132) AT=695.025n

.meas tran vdout0_133ck1380 FIND v(dout0_133) AT=695.025n

.meas tran vdout0_134ck1380 FIND v(dout0_134) AT=695.025n

.meas tran vdout0_135ck1380 FIND v(dout0_135) AT=695.025n

.meas tran vdout0_136ck1380 FIND v(dout0_136) AT=695.025n

.meas tran vdout0_137ck1380 FIND v(dout0_137) AT=695.025n

.meas tran vdout0_138ck1380 FIND v(dout0_138) AT=695.025n

.meas tran vdout0_139ck1380 FIND v(dout0_139) AT=695.025n

.meas tran vdout0_140ck1380 FIND v(dout0_140) AT=695.025n

.meas tran vdout0_141ck1380 FIND v(dout0_141) AT=695.025n

.meas tran vdout0_142ck1380 FIND v(dout0_142) AT=695.025n

.meas tran vdout0_143ck1380 FIND v(dout0_143) AT=695.025n

.meas tran vdout0_144ck1380 FIND v(dout0_144) AT=695.025n

.meas tran vdout0_145ck1380 FIND v(dout0_145) AT=695.025n

.meas tran vdout0_146ck1380 FIND v(dout0_146) AT=695.025n

.meas tran vdout0_147ck1380 FIND v(dout0_147) AT=695.025n

.meas tran vdout0_148ck1380 FIND v(dout0_148) AT=695.025n

.meas tran vdout0_149ck1380 FIND v(dout0_149) AT=695.025n

.meas tran vdout0_0ck1400 FIND v(dout0_0) AT=705.025n

.meas tran vdout0_1ck1400 FIND v(dout0_1) AT=705.025n

.meas tran vdout0_2ck1400 FIND v(dout0_2) AT=705.025n

.meas tran vdout0_3ck1400 FIND v(dout0_3) AT=705.025n

.meas tran vdout0_4ck1400 FIND v(dout0_4) AT=705.025n

.meas tran vdout0_5ck1400 FIND v(dout0_5) AT=705.025n

.meas tran vdout0_6ck1400 FIND v(dout0_6) AT=705.025n

.meas tran vdout0_7ck1400 FIND v(dout0_7) AT=705.025n

.meas tran vdout0_8ck1400 FIND v(dout0_8) AT=705.025n

.meas tran vdout0_9ck1400 FIND v(dout0_9) AT=705.025n

.meas tran vdout0_10ck1400 FIND v(dout0_10) AT=705.025n

.meas tran vdout0_11ck1400 FIND v(dout0_11) AT=705.025n

.meas tran vdout0_12ck1400 FIND v(dout0_12) AT=705.025n

.meas tran vdout0_13ck1400 FIND v(dout0_13) AT=705.025n

.meas tran vdout0_14ck1400 FIND v(dout0_14) AT=705.025n

.meas tran vdout0_15ck1400 FIND v(dout0_15) AT=705.025n

.meas tran vdout0_16ck1400 FIND v(dout0_16) AT=705.025n

.meas tran vdout0_17ck1400 FIND v(dout0_17) AT=705.025n

.meas tran vdout0_18ck1400 FIND v(dout0_18) AT=705.025n

.meas tran vdout0_19ck1400 FIND v(dout0_19) AT=705.025n

.meas tran vdout0_20ck1400 FIND v(dout0_20) AT=705.025n

.meas tran vdout0_21ck1400 FIND v(dout0_21) AT=705.025n

.meas tran vdout0_22ck1400 FIND v(dout0_22) AT=705.025n

.meas tran vdout0_23ck1400 FIND v(dout0_23) AT=705.025n

.meas tran vdout0_24ck1400 FIND v(dout0_24) AT=705.025n

.meas tran vdout0_25ck1400 FIND v(dout0_25) AT=705.025n

.meas tran vdout0_26ck1400 FIND v(dout0_26) AT=705.025n

.meas tran vdout0_27ck1400 FIND v(dout0_27) AT=705.025n

.meas tran vdout0_28ck1400 FIND v(dout0_28) AT=705.025n

.meas tran vdout0_29ck1400 FIND v(dout0_29) AT=705.025n

.meas tran vdout0_30ck1400 FIND v(dout0_30) AT=705.025n

.meas tran vdout0_31ck1400 FIND v(dout0_31) AT=705.025n

.meas tran vdout0_32ck1400 FIND v(dout0_32) AT=705.025n

.meas tran vdout0_33ck1400 FIND v(dout0_33) AT=705.025n

.meas tran vdout0_34ck1400 FIND v(dout0_34) AT=705.025n

.meas tran vdout0_35ck1400 FIND v(dout0_35) AT=705.025n

.meas tran vdout0_36ck1400 FIND v(dout0_36) AT=705.025n

.meas tran vdout0_37ck1400 FIND v(dout0_37) AT=705.025n

.meas tran vdout0_38ck1400 FIND v(dout0_38) AT=705.025n

.meas tran vdout0_39ck1400 FIND v(dout0_39) AT=705.025n

.meas tran vdout0_40ck1400 FIND v(dout0_40) AT=705.025n

.meas tran vdout0_41ck1400 FIND v(dout0_41) AT=705.025n

.meas tran vdout0_42ck1400 FIND v(dout0_42) AT=705.025n

.meas tran vdout0_43ck1400 FIND v(dout0_43) AT=705.025n

.meas tran vdout0_44ck1400 FIND v(dout0_44) AT=705.025n

.meas tran vdout0_45ck1400 FIND v(dout0_45) AT=705.025n

.meas tran vdout0_46ck1400 FIND v(dout0_46) AT=705.025n

.meas tran vdout0_47ck1400 FIND v(dout0_47) AT=705.025n

.meas tran vdout0_48ck1400 FIND v(dout0_48) AT=705.025n

.meas tran vdout0_49ck1400 FIND v(dout0_49) AT=705.025n

.meas tran vdout0_50ck1400 FIND v(dout0_50) AT=705.025n

.meas tran vdout0_51ck1400 FIND v(dout0_51) AT=705.025n

.meas tran vdout0_52ck1400 FIND v(dout0_52) AT=705.025n

.meas tran vdout0_53ck1400 FIND v(dout0_53) AT=705.025n

.meas tran vdout0_54ck1400 FIND v(dout0_54) AT=705.025n

.meas tran vdout0_55ck1400 FIND v(dout0_55) AT=705.025n

.meas tran vdout0_56ck1400 FIND v(dout0_56) AT=705.025n

.meas tran vdout0_57ck1400 FIND v(dout0_57) AT=705.025n

.meas tran vdout0_58ck1400 FIND v(dout0_58) AT=705.025n

.meas tran vdout0_59ck1400 FIND v(dout0_59) AT=705.025n

.meas tran vdout0_60ck1400 FIND v(dout0_60) AT=705.025n

.meas tran vdout0_61ck1400 FIND v(dout0_61) AT=705.025n

.meas tran vdout0_62ck1400 FIND v(dout0_62) AT=705.025n

.meas tran vdout0_63ck1400 FIND v(dout0_63) AT=705.025n

.meas tran vdout0_64ck1400 FIND v(dout0_64) AT=705.025n

.meas tran vdout0_65ck1400 FIND v(dout0_65) AT=705.025n

.meas tran vdout0_66ck1400 FIND v(dout0_66) AT=705.025n

.meas tran vdout0_67ck1400 FIND v(dout0_67) AT=705.025n

.meas tran vdout0_68ck1400 FIND v(dout0_68) AT=705.025n

.meas tran vdout0_69ck1400 FIND v(dout0_69) AT=705.025n

.meas tran vdout0_70ck1400 FIND v(dout0_70) AT=705.025n

.meas tran vdout0_71ck1400 FIND v(dout0_71) AT=705.025n

.meas tran vdout0_72ck1400 FIND v(dout0_72) AT=705.025n

.meas tran vdout0_73ck1400 FIND v(dout0_73) AT=705.025n

.meas tran vdout0_74ck1400 FIND v(dout0_74) AT=705.025n

.meas tran vdout0_75ck1400 FIND v(dout0_75) AT=705.025n

.meas tran vdout0_76ck1400 FIND v(dout0_76) AT=705.025n

.meas tran vdout0_77ck1400 FIND v(dout0_77) AT=705.025n

.meas tran vdout0_78ck1400 FIND v(dout0_78) AT=705.025n

.meas tran vdout0_79ck1400 FIND v(dout0_79) AT=705.025n

.meas tran vdout0_80ck1400 FIND v(dout0_80) AT=705.025n

.meas tran vdout0_81ck1400 FIND v(dout0_81) AT=705.025n

.meas tran vdout0_82ck1400 FIND v(dout0_82) AT=705.025n

.meas tran vdout0_83ck1400 FIND v(dout0_83) AT=705.025n

.meas tran vdout0_84ck1400 FIND v(dout0_84) AT=705.025n

.meas tran vdout0_85ck1400 FIND v(dout0_85) AT=705.025n

.meas tran vdout0_86ck1400 FIND v(dout0_86) AT=705.025n

.meas tran vdout0_87ck1400 FIND v(dout0_87) AT=705.025n

.meas tran vdout0_88ck1400 FIND v(dout0_88) AT=705.025n

.meas tran vdout0_89ck1400 FIND v(dout0_89) AT=705.025n

.meas tran vdout0_90ck1400 FIND v(dout0_90) AT=705.025n

.meas tran vdout0_91ck1400 FIND v(dout0_91) AT=705.025n

.meas tran vdout0_92ck1400 FIND v(dout0_92) AT=705.025n

.meas tran vdout0_93ck1400 FIND v(dout0_93) AT=705.025n

.meas tran vdout0_94ck1400 FIND v(dout0_94) AT=705.025n

.meas tran vdout0_95ck1400 FIND v(dout0_95) AT=705.025n

.meas tran vdout0_96ck1400 FIND v(dout0_96) AT=705.025n

.meas tran vdout0_97ck1400 FIND v(dout0_97) AT=705.025n

.meas tran vdout0_98ck1400 FIND v(dout0_98) AT=705.025n

.meas tran vdout0_99ck1400 FIND v(dout0_99) AT=705.025n

.meas tran vdout0_100ck1400 FIND v(dout0_100) AT=705.025n

.meas tran vdout0_101ck1400 FIND v(dout0_101) AT=705.025n

.meas tran vdout0_102ck1400 FIND v(dout0_102) AT=705.025n

.meas tran vdout0_103ck1400 FIND v(dout0_103) AT=705.025n

.meas tran vdout0_104ck1400 FIND v(dout0_104) AT=705.025n

.meas tran vdout0_105ck1400 FIND v(dout0_105) AT=705.025n

.meas tran vdout0_106ck1400 FIND v(dout0_106) AT=705.025n

.meas tran vdout0_107ck1400 FIND v(dout0_107) AT=705.025n

.meas tran vdout0_108ck1400 FIND v(dout0_108) AT=705.025n

.meas tran vdout0_109ck1400 FIND v(dout0_109) AT=705.025n

.meas tran vdout0_110ck1400 FIND v(dout0_110) AT=705.025n

.meas tran vdout0_111ck1400 FIND v(dout0_111) AT=705.025n

.meas tran vdout0_112ck1400 FIND v(dout0_112) AT=705.025n

.meas tran vdout0_113ck1400 FIND v(dout0_113) AT=705.025n

.meas tran vdout0_114ck1400 FIND v(dout0_114) AT=705.025n

.meas tran vdout0_115ck1400 FIND v(dout0_115) AT=705.025n

.meas tran vdout0_116ck1400 FIND v(dout0_116) AT=705.025n

.meas tran vdout0_117ck1400 FIND v(dout0_117) AT=705.025n

.meas tran vdout0_118ck1400 FIND v(dout0_118) AT=705.025n

.meas tran vdout0_119ck1400 FIND v(dout0_119) AT=705.025n

.meas tran vdout0_120ck1400 FIND v(dout0_120) AT=705.025n

.meas tran vdout0_121ck1400 FIND v(dout0_121) AT=705.025n

.meas tran vdout0_122ck1400 FIND v(dout0_122) AT=705.025n

.meas tran vdout0_123ck1400 FIND v(dout0_123) AT=705.025n

.meas tran vdout0_124ck1400 FIND v(dout0_124) AT=705.025n

.meas tran vdout0_125ck1400 FIND v(dout0_125) AT=705.025n

.meas tran vdout0_126ck1400 FIND v(dout0_126) AT=705.025n

.meas tran vdout0_127ck1400 FIND v(dout0_127) AT=705.025n

.meas tran vdout0_128ck1400 FIND v(dout0_128) AT=705.025n

.meas tran vdout0_129ck1400 FIND v(dout0_129) AT=705.025n

.meas tran vdout0_130ck1400 FIND v(dout0_130) AT=705.025n

.meas tran vdout0_131ck1400 FIND v(dout0_131) AT=705.025n

.meas tran vdout0_132ck1400 FIND v(dout0_132) AT=705.025n

.meas tran vdout0_133ck1400 FIND v(dout0_133) AT=705.025n

.meas tran vdout0_134ck1400 FIND v(dout0_134) AT=705.025n

.meas tran vdout0_135ck1400 FIND v(dout0_135) AT=705.025n

.meas tran vdout0_136ck1400 FIND v(dout0_136) AT=705.025n

.meas tran vdout0_137ck1400 FIND v(dout0_137) AT=705.025n

.meas tran vdout0_138ck1400 FIND v(dout0_138) AT=705.025n

.meas tran vdout0_139ck1400 FIND v(dout0_139) AT=705.025n

.meas tran vdout0_140ck1400 FIND v(dout0_140) AT=705.025n

.meas tran vdout0_141ck1400 FIND v(dout0_141) AT=705.025n

.meas tran vdout0_142ck1400 FIND v(dout0_142) AT=705.025n

.meas tran vdout0_143ck1400 FIND v(dout0_143) AT=705.025n

.meas tran vdout0_144ck1400 FIND v(dout0_144) AT=705.025n

.meas tran vdout0_145ck1400 FIND v(dout0_145) AT=705.025n

.meas tran vdout0_146ck1400 FIND v(dout0_146) AT=705.025n

.meas tran vdout0_147ck1400 FIND v(dout0_147) AT=705.025n

.meas tran vdout0_148ck1400 FIND v(dout0_148) AT=705.025n

.meas tran vdout0_149ck1400 FIND v(dout0_149) AT=705.025n

.meas tran vdout0_0ck1440 FIND v(dout0_0) AT=725.025n

.meas tran vdout0_1ck1440 FIND v(dout0_1) AT=725.025n

.meas tran vdout0_2ck1440 FIND v(dout0_2) AT=725.025n

.meas tran vdout0_3ck1440 FIND v(dout0_3) AT=725.025n

.meas tran vdout0_4ck1440 FIND v(dout0_4) AT=725.025n

.meas tran vdout0_5ck1440 FIND v(dout0_5) AT=725.025n

.meas tran vdout0_6ck1440 FIND v(dout0_6) AT=725.025n

.meas tran vdout0_7ck1440 FIND v(dout0_7) AT=725.025n

.meas tran vdout0_8ck1440 FIND v(dout0_8) AT=725.025n

.meas tran vdout0_9ck1440 FIND v(dout0_9) AT=725.025n

.meas tran vdout0_10ck1440 FIND v(dout0_10) AT=725.025n

.meas tran vdout0_11ck1440 FIND v(dout0_11) AT=725.025n

.meas tran vdout0_12ck1440 FIND v(dout0_12) AT=725.025n

.meas tran vdout0_13ck1440 FIND v(dout0_13) AT=725.025n

.meas tran vdout0_14ck1440 FIND v(dout0_14) AT=725.025n

.meas tran vdout0_15ck1440 FIND v(dout0_15) AT=725.025n

.meas tran vdout0_16ck1440 FIND v(dout0_16) AT=725.025n

.meas tran vdout0_17ck1440 FIND v(dout0_17) AT=725.025n

.meas tran vdout0_18ck1440 FIND v(dout0_18) AT=725.025n

.meas tran vdout0_19ck1440 FIND v(dout0_19) AT=725.025n

.meas tran vdout0_20ck1440 FIND v(dout0_20) AT=725.025n

.meas tran vdout0_21ck1440 FIND v(dout0_21) AT=725.025n

.meas tran vdout0_22ck1440 FIND v(dout0_22) AT=725.025n

.meas tran vdout0_23ck1440 FIND v(dout0_23) AT=725.025n

.meas tran vdout0_24ck1440 FIND v(dout0_24) AT=725.025n

.meas tran vdout0_25ck1440 FIND v(dout0_25) AT=725.025n

.meas tran vdout0_26ck1440 FIND v(dout0_26) AT=725.025n

.meas tran vdout0_27ck1440 FIND v(dout0_27) AT=725.025n

.meas tran vdout0_28ck1440 FIND v(dout0_28) AT=725.025n

.meas tran vdout0_29ck1440 FIND v(dout0_29) AT=725.025n

.meas tran vdout0_30ck1440 FIND v(dout0_30) AT=725.025n

.meas tran vdout0_31ck1440 FIND v(dout0_31) AT=725.025n

.meas tran vdout0_32ck1440 FIND v(dout0_32) AT=725.025n

.meas tran vdout0_33ck1440 FIND v(dout0_33) AT=725.025n

.meas tran vdout0_34ck1440 FIND v(dout0_34) AT=725.025n

.meas tran vdout0_35ck1440 FIND v(dout0_35) AT=725.025n

.meas tran vdout0_36ck1440 FIND v(dout0_36) AT=725.025n

.meas tran vdout0_37ck1440 FIND v(dout0_37) AT=725.025n

.meas tran vdout0_38ck1440 FIND v(dout0_38) AT=725.025n

.meas tran vdout0_39ck1440 FIND v(dout0_39) AT=725.025n

.meas tran vdout0_40ck1440 FIND v(dout0_40) AT=725.025n

.meas tran vdout0_41ck1440 FIND v(dout0_41) AT=725.025n

.meas tran vdout0_42ck1440 FIND v(dout0_42) AT=725.025n

.meas tran vdout0_43ck1440 FIND v(dout0_43) AT=725.025n

.meas tran vdout0_44ck1440 FIND v(dout0_44) AT=725.025n

.meas tran vdout0_45ck1440 FIND v(dout0_45) AT=725.025n

.meas tran vdout0_46ck1440 FIND v(dout0_46) AT=725.025n

.meas tran vdout0_47ck1440 FIND v(dout0_47) AT=725.025n

.meas tran vdout0_48ck1440 FIND v(dout0_48) AT=725.025n

.meas tran vdout0_49ck1440 FIND v(dout0_49) AT=725.025n

.meas tran vdout0_50ck1440 FIND v(dout0_50) AT=725.025n

.meas tran vdout0_51ck1440 FIND v(dout0_51) AT=725.025n

.meas tran vdout0_52ck1440 FIND v(dout0_52) AT=725.025n

.meas tran vdout0_53ck1440 FIND v(dout0_53) AT=725.025n

.meas tran vdout0_54ck1440 FIND v(dout0_54) AT=725.025n

.meas tran vdout0_55ck1440 FIND v(dout0_55) AT=725.025n

.meas tran vdout0_56ck1440 FIND v(dout0_56) AT=725.025n

.meas tran vdout0_57ck1440 FIND v(dout0_57) AT=725.025n

.meas tran vdout0_58ck1440 FIND v(dout0_58) AT=725.025n

.meas tran vdout0_59ck1440 FIND v(dout0_59) AT=725.025n

.meas tran vdout0_60ck1440 FIND v(dout0_60) AT=725.025n

.meas tran vdout0_61ck1440 FIND v(dout0_61) AT=725.025n

.meas tran vdout0_62ck1440 FIND v(dout0_62) AT=725.025n

.meas tran vdout0_63ck1440 FIND v(dout0_63) AT=725.025n

.meas tran vdout0_64ck1440 FIND v(dout0_64) AT=725.025n

.meas tran vdout0_65ck1440 FIND v(dout0_65) AT=725.025n

.meas tran vdout0_66ck1440 FIND v(dout0_66) AT=725.025n

.meas tran vdout0_67ck1440 FIND v(dout0_67) AT=725.025n

.meas tran vdout0_68ck1440 FIND v(dout0_68) AT=725.025n

.meas tran vdout0_69ck1440 FIND v(dout0_69) AT=725.025n

.meas tran vdout0_70ck1440 FIND v(dout0_70) AT=725.025n

.meas tran vdout0_71ck1440 FIND v(dout0_71) AT=725.025n

.meas tran vdout0_72ck1440 FIND v(dout0_72) AT=725.025n

.meas tran vdout0_73ck1440 FIND v(dout0_73) AT=725.025n

.meas tran vdout0_74ck1440 FIND v(dout0_74) AT=725.025n

.meas tran vdout0_75ck1440 FIND v(dout0_75) AT=725.025n

.meas tran vdout0_76ck1440 FIND v(dout0_76) AT=725.025n

.meas tran vdout0_77ck1440 FIND v(dout0_77) AT=725.025n

.meas tran vdout0_78ck1440 FIND v(dout0_78) AT=725.025n

.meas tran vdout0_79ck1440 FIND v(dout0_79) AT=725.025n

.meas tran vdout0_80ck1440 FIND v(dout0_80) AT=725.025n

.meas tran vdout0_81ck1440 FIND v(dout0_81) AT=725.025n

.meas tran vdout0_82ck1440 FIND v(dout0_82) AT=725.025n

.meas tran vdout0_83ck1440 FIND v(dout0_83) AT=725.025n

.meas tran vdout0_84ck1440 FIND v(dout0_84) AT=725.025n

.meas tran vdout0_85ck1440 FIND v(dout0_85) AT=725.025n

.meas tran vdout0_86ck1440 FIND v(dout0_86) AT=725.025n

.meas tran vdout0_87ck1440 FIND v(dout0_87) AT=725.025n

.meas tran vdout0_88ck1440 FIND v(dout0_88) AT=725.025n

.meas tran vdout0_89ck1440 FIND v(dout0_89) AT=725.025n

.meas tran vdout0_90ck1440 FIND v(dout0_90) AT=725.025n

.meas tran vdout0_91ck1440 FIND v(dout0_91) AT=725.025n

.meas tran vdout0_92ck1440 FIND v(dout0_92) AT=725.025n

.meas tran vdout0_93ck1440 FIND v(dout0_93) AT=725.025n

.meas tran vdout0_94ck1440 FIND v(dout0_94) AT=725.025n

.meas tran vdout0_95ck1440 FIND v(dout0_95) AT=725.025n

.meas tran vdout0_96ck1440 FIND v(dout0_96) AT=725.025n

.meas tran vdout0_97ck1440 FIND v(dout0_97) AT=725.025n

.meas tran vdout0_98ck1440 FIND v(dout0_98) AT=725.025n

.meas tran vdout0_99ck1440 FIND v(dout0_99) AT=725.025n

.meas tran vdout0_100ck1440 FIND v(dout0_100) AT=725.025n

.meas tran vdout0_101ck1440 FIND v(dout0_101) AT=725.025n

.meas tran vdout0_102ck1440 FIND v(dout0_102) AT=725.025n

.meas tran vdout0_103ck1440 FIND v(dout0_103) AT=725.025n

.meas tran vdout0_104ck1440 FIND v(dout0_104) AT=725.025n

.meas tran vdout0_105ck1440 FIND v(dout0_105) AT=725.025n

.meas tran vdout0_106ck1440 FIND v(dout0_106) AT=725.025n

.meas tran vdout0_107ck1440 FIND v(dout0_107) AT=725.025n

.meas tran vdout0_108ck1440 FIND v(dout0_108) AT=725.025n

.meas tran vdout0_109ck1440 FIND v(dout0_109) AT=725.025n

.meas tran vdout0_110ck1440 FIND v(dout0_110) AT=725.025n

.meas tran vdout0_111ck1440 FIND v(dout0_111) AT=725.025n

.meas tran vdout0_112ck1440 FIND v(dout0_112) AT=725.025n

.meas tran vdout0_113ck1440 FIND v(dout0_113) AT=725.025n

.meas tran vdout0_114ck1440 FIND v(dout0_114) AT=725.025n

.meas tran vdout0_115ck1440 FIND v(dout0_115) AT=725.025n

.meas tran vdout0_116ck1440 FIND v(dout0_116) AT=725.025n

.meas tran vdout0_117ck1440 FIND v(dout0_117) AT=725.025n

.meas tran vdout0_118ck1440 FIND v(dout0_118) AT=725.025n

.meas tran vdout0_119ck1440 FIND v(dout0_119) AT=725.025n

.meas tran vdout0_120ck1440 FIND v(dout0_120) AT=725.025n

.meas tran vdout0_121ck1440 FIND v(dout0_121) AT=725.025n

.meas tran vdout0_122ck1440 FIND v(dout0_122) AT=725.025n

.meas tran vdout0_123ck1440 FIND v(dout0_123) AT=725.025n

.meas tran vdout0_124ck1440 FIND v(dout0_124) AT=725.025n

.meas tran vdout0_125ck1440 FIND v(dout0_125) AT=725.025n

.meas tran vdout0_126ck1440 FIND v(dout0_126) AT=725.025n

.meas tran vdout0_127ck1440 FIND v(dout0_127) AT=725.025n

.meas tran vdout0_128ck1440 FIND v(dout0_128) AT=725.025n

.meas tran vdout0_129ck1440 FIND v(dout0_129) AT=725.025n

.meas tran vdout0_130ck1440 FIND v(dout0_130) AT=725.025n

.meas tran vdout0_131ck1440 FIND v(dout0_131) AT=725.025n

.meas tran vdout0_132ck1440 FIND v(dout0_132) AT=725.025n

.meas tran vdout0_133ck1440 FIND v(dout0_133) AT=725.025n

.meas tran vdout0_134ck1440 FIND v(dout0_134) AT=725.025n

.meas tran vdout0_135ck1440 FIND v(dout0_135) AT=725.025n

.meas tran vdout0_136ck1440 FIND v(dout0_136) AT=725.025n

.meas tran vdout0_137ck1440 FIND v(dout0_137) AT=725.025n

.meas tran vdout0_138ck1440 FIND v(dout0_138) AT=725.025n

.meas tran vdout0_139ck1440 FIND v(dout0_139) AT=725.025n

.meas tran vdout0_140ck1440 FIND v(dout0_140) AT=725.025n

.meas tran vdout0_141ck1440 FIND v(dout0_141) AT=725.025n

.meas tran vdout0_142ck1440 FIND v(dout0_142) AT=725.025n

.meas tran vdout0_143ck1440 FIND v(dout0_143) AT=725.025n

.meas tran vdout0_144ck1440 FIND v(dout0_144) AT=725.025n

.meas tran vdout0_145ck1440 FIND v(dout0_145) AT=725.025n

.meas tran vdout0_146ck1440 FIND v(dout0_146) AT=725.025n

.meas tran vdout0_147ck1440 FIND v(dout0_147) AT=725.025n

.meas tran vdout0_148ck1440 FIND v(dout0_148) AT=725.025n

.meas tran vdout0_149ck1440 FIND v(dout0_149) AT=725.025n

.meas tran vdout0_0ck1450 FIND v(dout0_0) AT=730.025n

.meas tran vdout0_1ck1450 FIND v(dout0_1) AT=730.025n

.meas tran vdout0_2ck1450 FIND v(dout0_2) AT=730.025n

.meas tran vdout0_3ck1450 FIND v(dout0_3) AT=730.025n

.meas tran vdout0_4ck1450 FIND v(dout0_4) AT=730.025n

.meas tran vdout0_5ck1450 FIND v(dout0_5) AT=730.025n

.meas tran vdout0_6ck1450 FIND v(dout0_6) AT=730.025n

.meas tran vdout0_7ck1450 FIND v(dout0_7) AT=730.025n

.meas tran vdout0_8ck1450 FIND v(dout0_8) AT=730.025n

.meas tran vdout0_9ck1450 FIND v(dout0_9) AT=730.025n

.meas tran vdout0_10ck1450 FIND v(dout0_10) AT=730.025n

.meas tran vdout0_11ck1450 FIND v(dout0_11) AT=730.025n

.meas tran vdout0_12ck1450 FIND v(dout0_12) AT=730.025n

.meas tran vdout0_13ck1450 FIND v(dout0_13) AT=730.025n

.meas tran vdout0_14ck1450 FIND v(dout0_14) AT=730.025n

.meas tran vdout0_15ck1450 FIND v(dout0_15) AT=730.025n

.meas tran vdout0_16ck1450 FIND v(dout0_16) AT=730.025n

.meas tran vdout0_17ck1450 FIND v(dout0_17) AT=730.025n

.meas tran vdout0_18ck1450 FIND v(dout0_18) AT=730.025n

.meas tran vdout0_19ck1450 FIND v(dout0_19) AT=730.025n

.meas tran vdout0_20ck1450 FIND v(dout0_20) AT=730.025n

.meas tran vdout0_21ck1450 FIND v(dout0_21) AT=730.025n

.meas tran vdout0_22ck1450 FIND v(dout0_22) AT=730.025n

.meas tran vdout0_23ck1450 FIND v(dout0_23) AT=730.025n

.meas tran vdout0_24ck1450 FIND v(dout0_24) AT=730.025n

.meas tran vdout0_25ck1450 FIND v(dout0_25) AT=730.025n

.meas tran vdout0_26ck1450 FIND v(dout0_26) AT=730.025n

.meas tran vdout0_27ck1450 FIND v(dout0_27) AT=730.025n

.meas tran vdout0_28ck1450 FIND v(dout0_28) AT=730.025n

.meas tran vdout0_29ck1450 FIND v(dout0_29) AT=730.025n

.meas tran vdout0_30ck1450 FIND v(dout0_30) AT=730.025n

.meas tran vdout0_31ck1450 FIND v(dout0_31) AT=730.025n

.meas tran vdout0_32ck1450 FIND v(dout0_32) AT=730.025n

.meas tran vdout0_33ck1450 FIND v(dout0_33) AT=730.025n

.meas tran vdout0_34ck1450 FIND v(dout0_34) AT=730.025n

.meas tran vdout0_35ck1450 FIND v(dout0_35) AT=730.025n

.meas tran vdout0_36ck1450 FIND v(dout0_36) AT=730.025n

.meas tran vdout0_37ck1450 FIND v(dout0_37) AT=730.025n

.meas tran vdout0_38ck1450 FIND v(dout0_38) AT=730.025n

.meas tran vdout0_39ck1450 FIND v(dout0_39) AT=730.025n

.meas tran vdout0_40ck1450 FIND v(dout0_40) AT=730.025n

.meas tran vdout0_41ck1450 FIND v(dout0_41) AT=730.025n

.meas tran vdout0_42ck1450 FIND v(dout0_42) AT=730.025n

.meas tran vdout0_43ck1450 FIND v(dout0_43) AT=730.025n

.meas tran vdout0_44ck1450 FIND v(dout0_44) AT=730.025n

.meas tran vdout0_45ck1450 FIND v(dout0_45) AT=730.025n

.meas tran vdout0_46ck1450 FIND v(dout0_46) AT=730.025n

.meas tran vdout0_47ck1450 FIND v(dout0_47) AT=730.025n

.meas tran vdout0_48ck1450 FIND v(dout0_48) AT=730.025n

.meas tran vdout0_49ck1450 FIND v(dout0_49) AT=730.025n

.meas tran vdout0_50ck1450 FIND v(dout0_50) AT=730.025n

.meas tran vdout0_51ck1450 FIND v(dout0_51) AT=730.025n

.meas tran vdout0_52ck1450 FIND v(dout0_52) AT=730.025n

.meas tran vdout0_53ck1450 FIND v(dout0_53) AT=730.025n

.meas tran vdout0_54ck1450 FIND v(dout0_54) AT=730.025n

.meas tran vdout0_55ck1450 FIND v(dout0_55) AT=730.025n

.meas tran vdout0_56ck1450 FIND v(dout0_56) AT=730.025n

.meas tran vdout0_57ck1450 FIND v(dout0_57) AT=730.025n

.meas tran vdout0_58ck1450 FIND v(dout0_58) AT=730.025n

.meas tran vdout0_59ck1450 FIND v(dout0_59) AT=730.025n

.meas tran vdout0_60ck1450 FIND v(dout0_60) AT=730.025n

.meas tran vdout0_61ck1450 FIND v(dout0_61) AT=730.025n

.meas tran vdout0_62ck1450 FIND v(dout0_62) AT=730.025n

.meas tran vdout0_63ck1450 FIND v(dout0_63) AT=730.025n

.meas tran vdout0_64ck1450 FIND v(dout0_64) AT=730.025n

.meas tran vdout0_65ck1450 FIND v(dout0_65) AT=730.025n

.meas tran vdout0_66ck1450 FIND v(dout0_66) AT=730.025n

.meas tran vdout0_67ck1450 FIND v(dout0_67) AT=730.025n

.meas tran vdout0_68ck1450 FIND v(dout0_68) AT=730.025n

.meas tran vdout0_69ck1450 FIND v(dout0_69) AT=730.025n

.meas tran vdout0_70ck1450 FIND v(dout0_70) AT=730.025n

.meas tran vdout0_71ck1450 FIND v(dout0_71) AT=730.025n

.meas tran vdout0_72ck1450 FIND v(dout0_72) AT=730.025n

.meas tran vdout0_73ck1450 FIND v(dout0_73) AT=730.025n

.meas tran vdout0_74ck1450 FIND v(dout0_74) AT=730.025n

.meas tran vdout0_75ck1450 FIND v(dout0_75) AT=730.025n

.meas tran vdout0_76ck1450 FIND v(dout0_76) AT=730.025n

.meas tran vdout0_77ck1450 FIND v(dout0_77) AT=730.025n

.meas tran vdout0_78ck1450 FIND v(dout0_78) AT=730.025n

.meas tran vdout0_79ck1450 FIND v(dout0_79) AT=730.025n

.meas tran vdout0_80ck1450 FIND v(dout0_80) AT=730.025n

.meas tran vdout0_81ck1450 FIND v(dout0_81) AT=730.025n

.meas tran vdout0_82ck1450 FIND v(dout0_82) AT=730.025n

.meas tran vdout0_83ck1450 FIND v(dout0_83) AT=730.025n

.meas tran vdout0_84ck1450 FIND v(dout0_84) AT=730.025n

.meas tran vdout0_85ck1450 FIND v(dout0_85) AT=730.025n

.meas tran vdout0_86ck1450 FIND v(dout0_86) AT=730.025n

.meas tran vdout0_87ck1450 FIND v(dout0_87) AT=730.025n

.meas tran vdout0_88ck1450 FIND v(dout0_88) AT=730.025n

.meas tran vdout0_89ck1450 FIND v(dout0_89) AT=730.025n

.meas tran vdout0_90ck1450 FIND v(dout0_90) AT=730.025n

.meas tran vdout0_91ck1450 FIND v(dout0_91) AT=730.025n

.meas tran vdout0_92ck1450 FIND v(dout0_92) AT=730.025n

.meas tran vdout0_93ck1450 FIND v(dout0_93) AT=730.025n

.meas tran vdout0_94ck1450 FIND v(dout0_94) AT=730.025n

.meas tran vdout0_95ck1450 FIND v(dout0_95) AT=730.025n

.meas tran vdout0_96ck1450 FIND v(dout0_96) AT=730.025n

.meas tran vdout0_97ck1450 FIND v(dout0_97) AT=730.025n

.meas tran vdout0_98ck1450 FIND v(dout0_98) AT=730.025n

.meas tran vdout0_99ck1450 FIND v(dout0_99) AT=730.025n

.meas tran vdout0_100ck1450 FIND v(dout0_100) AT=730.025n

.meas tran vdout0_101ck1450 FIND v(dout0_101) AT=730.025n

.meas tran vdout0_102ck1450 FIND v(dout0_102) AT=730.025n

.meas tran vdout0_103ck1450 FIND v(dout0_103) AT=730.025n

.meas tran vdout0_104ck1450 FIND v(dout0_104) AT=730.025n

.meas tran vdout0_105ck1450 FIND v(dout0_105) AT=730.025n

.meas tran vdout0_106ck1450 FIND v(dout0_106) AT=730.025n

.meas tran vdout0_107ck1450 FIND v(dout0_107) AT=730.025n

.meas tran vdout0_108ck1450 FIND v(dout0_108) AT=730.025n

.meas tran vdout0_109ck1450 FIND v(dout0_109) AT=730.025n

.meas tran vdout0_110ck1450 FIND v(dout0_110) AT=730.025n

.meas tran vdout0_111ck1450 FIND v(dout0_111) AT=730.025n

.meas tran vdout0_112ck1450 FIND v(dout0_112) AT=730.025n

.meas tran vdout0_113ck1450 FIND v(dout0_113) AT=730.025n

.meas tran vdout0_114ck1450 FIND v(dout0_114) AT=730.025n

.meas tran vdout0_115ck1450 FIND v(dout0_115) AT=730.025n

.meas tran vdout0_116ck1450 FIND v(dout0_116) AT=730.025n

.meas tran vdout0_117ck1450 FIND v(dout0_117) AT=730.025n

.meas tran vdout0_118ck1450 FIND v(dout0_118) AT=730.025n

.meas tran vdout0_119ck1450 FIND v(dout0_119) AT=730.025n

.meas tran vdout0_120ck1450 FIND v(dout0_120) AT=730.025n

.meas tran vdout0_121ck1450 FIND v(dout0_121) AT=730.025n

.meas tran vdout0_122ck1450 FIND v(dout0_122) AT=730.025n

.meas tran vdout0_123ck1450 FIND v(dout0_123) AT=730.025n

.meas tran vdout0_124ck1450 FIND v(dout0_124) AT=730.025n

.meas tran vdout0_125ck1450 FIND v(dout0_125) AT=730.025n

.meas tran vdout0_126ck1450 FIND v(dout0_126) AT=730.025n

.meas tran vdout0_127ck1450 FIND v(dout0_127) AT=730.025n

.meas tran vdout0_128ck1450 FIND v(dout0_128) AT=730.025n

.meas tran vdout0_129ck1450 FIND v(dout0_129) AT=730.025n

.meas tran vdout0_130ck1450 FIND v(dout0_130) AT=730.025n

.meas tran vdout0_131ck1450 FIND v(dout0_131) AT=730.025n

.meas tran vdout0_132ck1450 FIND v(dout0_132) AT=730.025n

.meas tran vdout0_133ck1450 FIND v(dout0_133) AT=730.025n

.meas tran vdout0_134ck1450 FIND v(dout0_134) AT=730.025n

.meas tran vdout0_135ck1450 FIND v(dout0_135) AT=730.025n

.meas tran vdout0_136ck1450 FIND v(dout0_136) AT=730.025n

.meas tran vdout0_137ck1450 FIND v(dout0_137) AT=730.025n

.meas tran vdout0_138ck1450 FIND v(dout0_138) AT=730.025n

.meas tran vdout0_139ck1450 FIND v(dout0_139) AT=730.025n

.meas tran vdout0_140ck1450 FIND v(dout0_140) AT=730.025n

.meas tran vdout0_141ck1450 FIND v(dout0_141) AT=730.025n

.meas tran vdout0_142ck1450 FIND v(dout0_142) AT=730.025n

.meas tran vdout0_143ck1450 FIND v(dout0_143) AT=730.025n

.meas tran vdout0_144ck1450 FIND v(dout0_144) AT=730.025n

.meas tran vdout0_145ck1450 FIND v(dout0_145) AT=730.025n

.meas tran vdout0_146ck1450 FIND v(dout0_146) AT=730.025n

.meas tran vdout0_147ck1450 FIND v(dout0_147) AT=730.025n

.meas tran vdout0_148ck1450 FIND v(dout0_148) AT=730.025n

.meas tran vdout0_149ck1450 FIND v(dout0_149) AT=730.025n

.meas tran vdout0_0ck1460 FIND v(dout0_0) AT=735.025n

.meas tran vdout0_1ck1460 FIND v(dout0_1) AT=735.025n

.meas tran vdout0_2ck1460 FIND v(dout0_2) AT=735.025n

.meas tran vdout0_3ck1460 FIND v(dout0_3) AT=735.025n

.meas tran vdout0_4ck1460 FIND v(dout0_4) AT=735.025n

.meas tran vdout0_5ck1460 FIND v(dout0_5) AT=735.025n

.meas tran vdout0_6ck1460 FIND v(dout0_6) AT=735.025n

.meas tran vdout0_7ck1460 FIND v(dout0_7) AT=735.025n

.meas tran vdout0_8ck1460 FIND v(dout0_8) AT=735.025n

.meas tran vdout0_9ck1460 FIND v(dout0_9) AT=735.025n

.meas tran vdout0_10ck1460 FIND v(dout0_10) AT=735.025n

.meas tran vdout0_11ck1460 FIND v(dout0_11) AT=735.025n

.meas tran vdout0_12ck1460 FIND v(dout0_12) AT=735.025n

.meas tran vdout0_13ck1460 FIND v(dout0_13) AT=735.025n

.meas tran vdout0_14ck1460 FIND v(dout0_14) AT=735.025n

.meas tran vdout0_15ck1460 FIND v(dout0_15) AT=735.025n

.meas tran vdout0_16ck1460 FIND v(dout0_16) AT=735.025n

.meas tran vdout0_17ck1460 FIND v(dout0_17) AT=735.025n

.meas tran vdout0_18ck1460 FIND v(dout0_18) AT=735.025n

.meas tran vdout0_19ck1460 FIND v(dout0_19) AT=735.025n

.meas tran vdout0_20ck1460 FIND v(dout0_20) AT=735.025n

.meas tran vdout0_21ck1460 FIND v(dout0_21) AT=735.025n

.meas tran vdout0_22ck1460 FIND v(dout0_22) AT=735.025n

.meas tran vdout0_23ck1460 FIND v(dout0_23) AT=735.025n

.meas tran vdout0_24ck1460 FIND v(dout0_24) AT=735.025n

.meas tran vdout0_25ck1460 FIND v(dout0_25) AT=735.025n

.meas tran vdout0_26ck1460 FIND v(dout0_26) AT=735.025n

.meas tran vdout0_27ck1460 FIND v(dout0_27) AT=735.025n

.meas tran vdout0_28ck1460 FIND v(dout0_28) AT=735.025n

.meas tran vdout0_29ck1460 FIND v(dout0_29) AT=735.025n

.meas tran vdout0_30ck1460 FIND v(dout0_30) AT=735.025n

.meas tran vdout0_31ck1460 FIND v(dout0_31) AT=735.025n

.meas tran vdout0_32ck1460 FIND v(dout0_32) AT=735.025n

.meas tran vdout0_33ck1460 FIND v(dout0_33) AT=735.025n

.meas tran vdout0_34ck1460 FIND v(dout0_34) AT=735.025n

.meas tran vdout0_35ck1460 FIND v(dout0_35) AT=735.025n

.meas tran vdout0_36ck1460 FIND v(dout0_36) AT=735.025n

.meas tran vdout0_37ck1460 FIND v(dout0_37) AT=735.025n

.meas tran vdout0_38ck1460 FIND v(dout0_38) AT=735.025n

.meas tran vdout0_39ck1460 FIND v(dout0_39) AT=735.025n

.meas tran vdout0_40ck1460 FIND v(dout0_40) AT=735.025n

.meas tran vdout0_41ck1460 FIND v(dout0_41) AT=735.025n

.meas tran vdout0_42ck1460 FIND v(dout0_42) AT=735.025n

.meas tran vdout0_43ck1460 FIND v(dout0_43) AT=735.025n

.meas tran vdout0_44ck1460 FIND v(dout0_44) AT=735.025n

.meas tran vdout0_45ck1460 FIND v(dout0_45) AT=735.025n

.meas tran vdout0_46ck1460 FIND v(dout0_46) AT=735.025n

.meas tran vdout0_47ck1460 FIND v(dout0_47) AT=735.025n

.meas tran vdout0_48ck1460 FIND v(dout0_48) AT=735.025n

.meas tran vdout0_49ck1460 FIND v(dout0_49) AT=735.025n

.meas tran vdout0_50ck1460 FIND v(dout0_50) AT=735.025n

.meas tran vdout0_51ck1460 FIND v(dout0_51) AT=735.025n

.meas tran vdout0_52ck1460 FIND v(dout0_52) AT=735.025n

.meas tran vdout0_53ck1460 FIND v(dout0_53) AT=735.025n

.meas tran vdout0_54ck1460 FIND v(dout0_54) AT=735.025n

.meas tran vdout0_55ck1460 FIND v(dout0_55) AT=735.025n

.meas tran vdout0_56ck1460 FIND v(dout0_56) AT=735.025n

.meas tran vdout0_57ck1460 FIND v(dout0_57) AT=735.025n

.meas tran vdout0_58ck1460 FIND v(dout0_58) AT=735.025n

.meas tran vdout0_59ck1460 FIND v(dout0_59) AT=735.025n

.meas tran vdout0_60ck1460 FIND v(dout0_60) AT=735.025n

.meas tran vdout0_61ck1460 FIND v(dout0_61) AT=735.025n

.meas tran vdout0_62ck1460 FIND v(dout0_62) AT=735.025n

.meas tran vdout0_63ck1460 FIND v(dout0_63) AT=735.025n

.meas tran vdout0_64ck1460 FIND v(dout0_64) AT=735.025n

.meas tran vdout0_65ck1460 FIND v(dout0_65) AT=735.025n

.meas tran vdout0_66ck1460 FIND v(dout0_66) AT=735.025n

.meas tran vdout0_67ck1460 FIND v(dout0_67) AT=735.025n

.meas tran vdout0_68ck1460 FIND v(dout0_68) AT=735.025n

.meas tran vdout0_69ck1460 FIND v(dout0_69) AT=735.025n

.meas tran vdout0_70ck1460 FIND v(dout0_70) AT=735.025n

.meas tran vdout0_71ck1460 FIND v(dout0_71) AT=735.025n

.meas tran vdout0_72ck1460 FIND v(dout0_72) AT=735.025n

.meas tran vdout0_73ck1460 FIND v(dout0_73) AT=735.025n

.meas tran vdout0_74ck1460 FIND v(dout0_74) AT=735.025n

.meas tran vdout0_75ck1460 FIND v(dout0_75) AT=735.025n

.meas tran vdout0_76ck1460 FIND v(dout0_76) AT=735.025n

.meas tran vdout0_77ck1460 FIND v(dout0_77) AT=735.025n

.meas tran vdout0_78ck1460 FIND v(dout0_78) AT=735.025n

.meas tran vdout0_79ck1460 FIND v(dout0_79) AT=735.025n

.meas tran vdout0_80ck1460 FIND v(dout0_80) AT=735.025n

.meas tran vdout0_81ck1460 FIND v(dout0_81) AT=735.025n

.meas tran vdout0_82ck1460 FIND v(dout0_82) AT=735.025n

.meas tran vdout0_83ck1460 FIND v(dout0_83) AT=735.025n

.meas tran vdout0_84ck1460 FIND v(dout0_84) AT=735.025n

.meas tran vdout0_85ck1460 FIND v(dout0_85) AT=735.025n

.meas tran vdout0_86ck1460 FIND v(dout0_86) AT=735.025n

.meas tran vdout0_87ck1460 FIND v(dout0_87) AT=735.025n

.meas tran vdout0_88ck1460 FIND v(dout0_88) AT=735.025n

.meas tran vdout0_89ck1460 FIND v(dout0_89) AT=735.025n

.meas tran vdout0_90ck1460 FIND v(dout0_90) AT=735.025n

.meas tran vdout0_91ck1460 FIND v(dout0_91) AT=735.025n

.meas tran vdout0_92ck1460 FIND v(dout0_92) AT=735.025n

.meas tran vdout0_93ck1460 FIND v(dout0_93) AT=735.025n

.meas tran vdout0_94ck1460 FIND v(dout0_94) AT=735.025n

.meas tran vdout0_95ck1460 FIND v(dout0_95) AT=735.025n

.meas tran vdout0_96ck1460 FIND v(dout0_96) AT=735.025n

.meas tran vdout0_97ck1460 FIND v(dout0_97) AT=735.025n

.meas tran vdout0_98ck1460 FIND v(dout0_98) AT=735.025n

.meas tran vdout0_99ck1460 FIND v(dout0_99) AT=735.025n

.meas tran vdout0_100ck1460 FIND v(dout0_100) AT=735.025n

.meas tran vdout0_101ck1460 FIND v(dout0_101) AT=735.025n

.meas tran vdout0_102ck1460 FIND v(dout0_102) AT=735.025n

.meas tran vdout0_103ck1460 FIND v(dout0_103) AT=735.025n

.meas tran vdout0_104ck1460 FIND v(dout0_104) AT=735.025n

.meas tran vdout0_105ck1460 FIND v(dout0_105) AT=735.025n

.meas tran vdout0_106ck1460 FIND v(dout0_106) AT=735.025n

.meas tran vdout0_107ck1460 FIND v(dout0_107) AT=735.025n

.meas tran vdout0_108ck1460 FIND v(dout0_108) AT=735.025n

.meas tran vdout0_109ck1460 FIND v(dout0_109) AT=735.025n

.meas tran vdout0_110ck1460 FIND v(dout0_110) AT=735.025n

.meas tran vdout0_111ck1460 FIND v(dout0_111) AT=735.025n

.meas tran vdout0_112ck1460 FIND v(dout0_112) AT=735.025n

.meas tran vdout0_113ck1460 FIND v(dout0_113) AT=735.025n

.meas tran vdout0_114ck1460 FIND v(dout0_114) AT=735.025n

.meas tran vdout0_115ck1460 FIND v(dout0_115) AT=735.025n

.meas tran vdout0_116ck1460 FIND v(dout0_116) AT=735.025n

.meas tran vdout0_117ck1460 FIND v(dout0_117) AT=735.025n

.meas tran vdout0_118ck1460 FIND v(dout0_118) AT=735.025n

.meas tran vdout0_119ck1460 FIND v(dout0_119) AT=735.025n

.meas tran vdout0_120ck1460 FIND v(dout0_120) AT=735.025n

.meas tran vdout0_121ck1460 FIND v(dout0_121) AT=735.025n

.meas tran vdout0_122ck1460 FIND v(dout0_122) AT=735.025n

.meas tran vdout0_123ck1460 FIND v(dout0_123) AT=735.025n

.meas tran vdout0_124ck1460 FIND v(dout0_124) AT=735.025n

.meas tran vdout0_125ck1460 FIND v(dout0_125) AT=735.025n

.meas tran vdout0_126ck1460 FIND v(dout0_126) AT=735.025n

.meas tran vdout0_127ck1460 FIND v(dout0_127) AT=735.025n

.meas tran vdout0_128ck1460 FIND v(dout0_128) AT=735.025n

.meas tran vdout0_129ck1460 FIND v(dout0_129) AT=735.025n

.meas tran vdout0_130ck1460 FIND v(dout0_130) AT=735.025n

.meas tran vdout0_131ck1460 FIND v(dout0_131) AT=735.025n

.meas tran vdout0_132ck1460 FIND v(dout0_132) AT=735.025n

.meas tran vdout0_133ck1460 FIND v(dout0_133) AT=735.025n

.meas tran vdout0_134ck1460 FIND v(dout0_134) AT=735.025n

.meas tran vdout0_135ck1460 FIND v(dout0_135) AT=735.025n

.meas tran vdout0_136ck1460 FIND v(dout0_136) AT=735.025n

.meas tran vdout0_137ck1460 FIND v(dout0_137) AT=735.025n

.meas tran vdout0_138ck1460 FIND v(dout0_138) AT=735.025n

.meas tran vdout0_139ck1460 FIND v(dout0_139) AT=735.025n

.meas tran vdout0_140ck1460 FIND v(dout0_140) AT=735.025n

.meas tran vdout0_141ck1460 FIND v(dout0_141) AT=735.025n

.meas tran vdout0_142ck1460 FIND v(dout0_142) AT=735.025n

.meas tran vdout0_143ck1460 FIND v(dout0_143) AT=735.025n

.meas tran vdout0_144ck1460 FIND v(dout0_144) AT=735.025n

.meas tran vdout0_145ck1460 FIND v(dout0_145) AT=735.025n

.meas tran vdout0_146ck1460 FIND v(dout0_146) AT=735.025n

.meas tran vdout0_147ck1460 FIND v(dout0_147) AT=735.025n

.meas tran vdout0_148ck1460 FIND v(dout0_148) AT=735.025n

.meas tran vdout0_149ck1460 FIND v(dout0_149) AT=735.025n

.meas tran vdout0_0ck1480 FIND v(dout0_0) AT=745.025n

.meas tran vdout0_1ck1480 FIND v(dout0_1) AT=745.025n

.meas tran vdout0_2ck1480 FIND v(dout0_2) AT=745.025n

.meas tran vdout0_3ck1480 FIND v(dout0_3) AT=745.025n

.meas tran vdout0_4ck1480 FIND v(dout0_4) AT=745.025n

.meas tran vdout0_5ck1480 FIND v(dout0_5) AT=745.025n

.meas tran vdout0_6ck1480 FIND v(dout0_6) AT=745.025n

.meas tran vdout0_7ck1480 FIND v(dout0_7) AT=745.025n

.meas tran vdout0_8ck1480 FIND v(dout0_8) AT=745.025n

.meas tran vdout0_9ck1480 FIND v(dout0_9) AT=745.025n

.meas tran vdout0_10ck1480 FIND v(dout0_10) AT=745.025n

.meas tran vdout0_11ck1480 FIND v(dout0_11) AT=745.025n

.meas tran vdout0_12ck1480 FIND v(dout0_12) AT=745.025n

.meas tran vdout0_13ck1480 FIND v(dout0_13) AT=745.025n

.meas tran vdout0_14ck1480 FIND v(dout0_14) AT=745.025n

.meas tran vdout0_15ck1480 FIND v(dout0_15) AT=745.025n

.meas tran vdout0_16ck1480 FIND v(dout0_16) AT=745.025n

.meas tran vdout0_17ck1480 FIND v(dout0_17) AT=745.025n

.meas tran vdout0_18ck1480 FIND v(dout0_18) AT=745.025n

.meas tran vdout0_19ck1480 FIND v(dout0_19) AT=745.025n

.meas tran vdout0_20ck1480 FIND v(dout0_20) AT=745.025n

.meas tran vdout0_21ck1480 FIND v(dout0_21) AT=745.025n

.meas tran vdout0_22ck1480 FIND v(dout0_22) AT=745.025n

.meas tran vdout0_23ck1480 FIND v(dout0_23) AT=745.025n

.meas tran vdout0_24ck1480 FIND v(dout0_24) AT=745.025n

.meas tran vdout0_25ck1480 FIND v(dout0_25) AT=745.025n

.meas tran vdout0_26ck1480 FIND v(dout0_26) AT=745.025n

.meas tran vdout0_27ck1480 FIND v(dout0_27) AT=745.025n

.meas tran vdout0_28ck1480 FIND v(dout0_28) AT=745.025n

.meas tran vdout0_29ck1480 FIND v(dout0_29) AT=745.025n

.meas tran vdout0_30ck1480 FIND v(dout0_30) AT=745.025n

.meas tran vdout0_31ck1480 FIND v(dout0_31) AT=745.025n

.meas tran vdout0_32ck1480 FIND v(dout0_32) AT=745.025n

.meas tran vdout0_33ck1480 FIND v(dout0_33) AT=745.025n

.meas tran vdout0_34ck1480 FIND v(dout0_34) AT=745.025n

.meas tran vdout0_35ck1480 FIND v(dout0_35) AT=745.025n

.meas tran vdout0_36ck1480 FIND v(dout0_36) AT=745.025n

.meas tran vdout0_37ck1480 FIND v(dout0_37) AT=745.025n

.meas tran vdout0_38ck1480 FIND v(dout0_38) AT=745.025n

.meas tran vdout0_39ck1480 FIND v(dout0_39) AT=745.025n

.meas tran vdout0_40ck1480 FIND v(dout0_40) AT=745.025n

.meas tran vdout0_41ck1480 FIND v(dout0_41) AT=745.025n

.meas tran vdout0_42ck1480 FIND v(dout0_42) AT=745.025n

.meas tran vdout0_43ck1480 FIND v(dout0_43) AT=745.025n

.meas tran vdout0_44ck1480 FIND v(dout0_44) AT=745.025n

.meas tran vdout0_45ck1480 FIND v(dout0_45) AT=745.025n

.meas tran vdout0_46ck1480 FIND v(dout0_46) AT=745.025n

.meas tran vdout0_47ck1480 FIND v(dout0_47) AT=745.025n

.meas tran vdout0_48ck1480 FIND v(dout0_48) AT=745.025n

.meas tran vdout0_49ck1480 FIND v(dout0_49) AT=745.025n

.meas tran vdout0_50ck1480 FIND v(dout0_50) AT=745.025n

.meas tran vdout0_51ck1480 FIND v(dout0_51) AT=745.025n

.meas tran vdout0_52ck1480 FIND v(dout0_52) AT=745.025n

.meas tran vdout0_53ck1480 FIND v(dout0_53) AT=745.025n

.meas tran vdout0_54ck1480 FIND v(dout0_54) AT=745.025n

.meas tran vdout0_55ck1480 FIND v(dout0_55) AT=745.025n

.meas tran vdout0_56ck1480 FIND v(dout0_56) AT=745.025n

.meas tran vdout0_57ck1480 FIND v(dout0_57) AT=745.025n

.meas tran vdout0_58ck1480 FIND v(dout0_58) AT=745.025n

.meas tran vdout0_59ck1480 FIND v(dout0_59) AT=745.025n

.meas tran vdout0_60ck1480 FIND v(dout0_60) AT=745.025n

.meas tran vdout0_61ck1480 FIND v(dout0_61) AT=745.025n

.meas tran vdout0_62ck1480 FIND v(dout0_62) AT=745.025n

.meas tran vdout0_63ck1480 FIND v(dout0_63) AT=745.025n

.meas tran vdout0_64ck1480 FIND v(dout0_64) AT=745.025n

.meas tran vdout0_65ck1480 FIND v(dout0_65) AT=745.025n

.meas tran vdout0_66ck1480 FIND v(dout0_66) AT=745.025n

.meas tran vdout0_67ck1480 FIND v(dout0_67) AT=745.025n

.meas tran vdout0_68ck1480 FIND v(dout0_68) AT=745.025n

.meas tran vdout0_69ck1480 FIND v(dout0_69) AT=745.025n

.meas tran vdout0_70ck1480 FIND v(dout0_70) AT=745.025n

.meas tran vdout0_71ck1480 FIND v(dout0_71) AT=745.025n

.meas tran vdout0_72ck1480 FIND v(dout0_72) AT=745.025n

.meas tran vdout0_73ck1480 FIND v(dout0_73) AT=745.025n

.meas tran vdout0_74ck1480 FIND v(dout0_74) AT=745.025n

.meas tran vdout0_75ck1480 FIND v(dout0_75) AT=745.025n

.meas tran vdout0_76ck1480 FIND v(dout0_76) AT=745.025n

.meas tran vdout0_77ck1480 FIND v(dout0_77) AT=745.025n

.meas tran vdout0_78ck1480 FIND v(dout0_78) AT=745.025n

.meas tran vdout0_79ck1480 FIND v(dout0_79) AT=745.025n

.meas tran vdout0_80ck1480 FIND v(dout0_80) AT=745.025n

.meas tran vdout0_81ck1480 FIND v(dout0_81) AT=745.025n

.meas tran vdout0_82ck1480 FIND v(dout0_82) AT=745.025n

.meas tran vdout0_83ck1480 FIND v(dout0_83) AT=745.025n

.meas tran vdout0_84ck1480 FIND v(dout0_84) AT=745.025n

.meas tran vdout0_85ck1480 FIND v(dout0_85) AT=745.025n

.meas tran vdout0_86ck1480 FIND v(dout0_86) AT=745.025n

.meas tran vdout0_87ck1480 FIND v(dout0_87) AT=745.025n

.meas tran vdout0_88ck1480 FIND v(dout0_88) AT=745.025n

.meas tran vdout0_89ck1480 FIND v(dout0_89) AT=745.025n

.meas tran vdout0_90ck1480 FIND v(dout0_90) AT=745.025n

.meas tran vdout0_91ck1480 FIND v(dout0_91) AT=745.025n

.meas tran vdout0_92ck1480 FIND v(dout0_92) AT=745.025n

.meas tran vdout0_93ck1480 FIND v(dout0_93) AT=745.025n

.meas tran vdout0_94ck1480 FIND v(dout0_94) AT=745.025n

.meas tran vdout0_95ck1480 FIND v(dout0_95) AT=745.025n

.meas tran vdout0_96ck1480 FIND v(dout0_96) AT=745.025n

.meas tran vdout0_97ck1480 FIND v(dout0_97) AT=745.025n

.meas tran vdout0_98ck1480 FIND v(dout0_98) AT=745.025n

.meas tran vdout0_99ck1480 FIND v(dout0_99) AT=745.025n

.meas tran vdout0_100ck1480 FIND v(dout0_100) AT=745.025n

.meas tran vdout0_101ck1480 FIND v(dout0_101) AT=745.025n

.meas tran vdout0_102ck1480 FIND v(dout0_102) AT=745.025n

.meas tran vdout0_103ck1480 FIND v(dout0_103) AT=745.025n

.meas tran vdout0_104ck1480 FIND v(dout0_104) AT=745.025n

.meas tran vdout0_105ck1480 FIND v(dout0_105) AT=745.025n

.meas tran vdout0_106ck1480 FIND v(dout0_106) AT=745.025n

.meas tran vdout0_107ck1480 FIND v(dout0_107) AT=745.025n

.meas tran vdout0_108ck1480 FIND v(dout0_108) AT=745.025n

.meas tran vdout0_109ck1480 FIND v(dout0_109) AT=745.025n

.meas tran vdout0_110ck1480 FIND v(dout0_110) AT=745.025n

.meas tran vdout0_111ck1480 FIND v(dout0_111) AT=745.025n

.meas tran vdout0_112ck1480 FIND v(dout0_112) AT=745.025n

.meas tran vdout0_113ck1480 FIND v(dout0_113) AT=745.025n

.meas tran vdout0_114ck1480 FIND v(dout0_114) AT=745.025n

.meas tran vdout0_115ck1480 FIND v(dout0_115) AT=745.025n

.meas tran vdout0_116ck1480 FIND v(dout0_116) AT=745.025n

.meas tran vdout0_117ck1480 FIND v(dout0_117) AT=745.025n

.meas tran vdout0_118ck1480 FIND v(dout0_118) AT=745.025n

.meas tran vdout0_119ck1480 FIND v(dout0_119) AT=745.025n

.meas tran vdout0_120ck1480 FIND v(dout0_120) AT=745.025n

.meas tran vdout0_121ck1480 FIND v(dout0_121) AT=745.025n

.meas tran vdout0_122ck1480 FIND v(dout0_122) AT=745.025n

.meas tran vdout0_123ck1480 FIND v(dout0_123) AT=745.025n

.meas tran vdout0_124ck1480 FIND v(dout0_124) AT=745.025n

.meas tran vdout0_125ck1480 FIND v(dout0_125) AT=745.025n

.meas tran vdout0_126ck1480 FIND v(dout0_126) AT=745.025n

.meas tran vdout0_127ck1480 FIND v(dout0_127) AT=745.025n

.meas tran vdout0_128ck1480 FIND v(dout0_128) AT=745.025n

.meas tran vdout0_129ck1480 FIND v(dout0_129) AT=745.025n

.meas tran vdout0_130ck1480 FIND v(dout0_130) AT=745.025n

.meas tran vdout0_131ck1480 FIND v(dout0_131) AT=745.025n

.meas tran vdout0_132ck1480 FIND v(dout0_132) AT=745.025n

.meas tran vdout0_133ck1480 FIND v(dout0_133) AT=745.025n

.meas tran vdout0_134ck1480 FIND v(dout0_134) AT=745.025n

.meas tran vdout0_135ck1480 FIND v(dout0_135) AT=745.025n

.meas tran vdout0_136ck1480 FIND v(dout0_136) AT=745.025n

.meas tran vdout0_137ck1480 FIND v(dout0_137) AT=745.025n

.meas tran vdout0_138ck1480 FIND v(dout0_138) AT=745.025n

.meas tran vdout0_139ck1480 FIND v(dout0_139) AT=745.025n

.meas tran vdout0_140ck1480 FIND v(dout0_140) AT=745.025n

.meas tran vdout0_141ck1480 FIND v(dout0_141) AT=745.025n

.meas tran vdout0_142ck1480 FIND v(dout0_142) AT=745.025n

.meas tran vdout0_143ck1480 FIND v(dout0_143) AT=745.025n

.meas tran vdout0_144ck1480 FIND v(dout0_144) AT=745.025n

.meas tran vdout0_145ck1480 FIND v(dout0_145) AT=745.025n

.meas tran vdout0_146ck1480 FIND v(dout0_146) AT=745.025n

.meas tran vdout0_147ck1480 FIND v(dout0_147) AT=745.025n

.meas tran vdout0_148ck1480 FIND v(dout0_148) AT=745.025n

.meas tran vdout0_149ck1480 FIND v(dout0_149) AT=745.025n

.meas tran vdout0_0ck1490 FIND v(dout0_0) AT=750.025n

.meas tran vdout0_1ck1490 FIND v(dout0_1) AT=750.025n

.meas tran vdout0_2ck1490 FIND v(dout0_2) AT=750.025n

.meas tran vdout0_3ck1490 FIND v(dout0_3) AT=750.025n

.meas tran vdout0_4ck1490 FIND v(dout0_4) AT=750.025n

.meas tran vdout0_5ck1490 FIND v(dout0_5) AT=750.025n

.meas tran vdout0_6ck1490 FIND v(dout0_6) AT=750.025n

.meas tran vdout0_7ck1490 FIND v(dout0_7) AT=750.025n

.meas tran vdout0_8ck1490 FIND v(dout0_8) AT=750.025n

.meas tran vdout0_9ck1490 FIND v(dout0_9) AT=750.025n

.meas tran vdout0_10ck1490 FIND v(dout0_10) AT=750.025n

.meas tran vdout0_11ck1490 FIND v(dout0_11) AT=750.025n

.meas tran vdout0_12ck1490 FIND v(dout0_12) AT=750.025n

.meas tran vdout0_13ck1490 FIND v(dout0_13) AT=750.025n

.meas tran vdout0_14ck1490 FIND v(dout0_14) AT=750.025n

.meas tran vdout0_15ck1490 FIND v(dout0_15) AT=750.025n

.meas tran vdout0_16ck1490 FIND v(dout0_16) AT=750.025n

.meas tran vdout0_17ck1490 FIND v(dout0_17) AT=750.025n

.meas tran vdout0_18ck1490 FIND v(dout0_18) AT=750.025n

.meas tran vdout0_19ck1490 FIND v(dout0_19) AT=750.025n

.meas tran vdout0_20ck1490 FIND v(dout0_20) AT=750.025n

.meas tran vdout0_21ck1490 FIND v(dout0_21) AT=750.025n

.meas tran vdout0_22ck1490 FIND v(dout0_22) AT=750.025n

.meas tran vdout0_23ck1490 FIND v(dout0_23) AT=750.025n

.meas tran vdout0_24ck1490 FIND v(dout0_24) AT=750.025n

.meas tran vdout0_25ck1490 FIND v(dout0_25) AT=750.025n

.meas tran vdout0_26ck1490 FIND v(dout0_26) AT=750.025n

.meas tran vdout0_27ck1490 FIND v(dout0_27) AT=750.025n

.meas tran vdout0_28ck1490 FIND v(dout0_28) AT=750.025n

.meas tran vdout0_29ck1490 FIND v(dout0_29) AT=750.025n

.meas tran vdout0_30ck1490 FIND v(dout0_30) AT=750.025n

.meas tran vdout0_31ck1490 FIND v(dout0_31) AT=750.025n

.meas tran vdout0_32ck1490 FIND v(dout0_32) AT=750.025n

.meas tran vdout0_33ck1490 FIND v(dout0_33) AT=750.025n

.meas tran vdout0_34ck1490 FIND v(dout0_34) AT=750.025n

.meas tran vdout0_35ck1490 FIND v(dout0_35) AT=750.025n

.meas tran vdout0_36ck1490 FIND v(dout0_36) AT=750.025n

.meas tran vdout0_37ck1490 FIND v(dout0_37) AT=750.025n

.meas tran vdout0_38ck1490 FIND v(dout0_38) AT=750.025n

.meas tran vdout0_39ck1490 FIND v(dout0_39) AT=750.025n

.meas tran vdout0_40ck1490 FIND v(dout0_40) AT=750.025n

.meas tran vdout0_41ck1490 FIND v(dout0_41) AT=750.025n

.meas tran vdout0_42ck1490 FIND v(dout0_42) AT=750.025n

.meas tran vdout0_43ck1490 FIND v(dout0_43) AT=750.025n

.meas tran vdout0_44ck1490 FIND v(dout0_44) AT=750.025n

.meas tran vdout0_45ck1490 FIND v(dout0_45) AT=750.025n

.meas tran vdout0_46ck1490 FIND v(dout0_46) AT=750.025n

.meas tran vdout0_47ck1490 FIND v(dout0_47) AT=750.025n

.meas tran vdout0_48ck1490 FIND v(dout0_48) AT=750.025n

.meas tran vdout0_49ck1490 FIND v(dout0_49) AT=750.025n

.meas tran vdout0_50ck1490 FIND v(dout0_50) AT=750.025n

.meas tran vdout0_51ck1490 FIND v(dout0_51) AT=750.025n

.meas tran vdout0_52ck1490 FIND v(dout0_52) AT=750.025n

.meas tran vdout0_53ck1490 FIND v(dout0_53) AT=750.025n

.meas tran vdout0_54ck1490 FIND v(dout0_54) AT=750.025n

.meas tran vdout0_55ck1490 FIND v(dout0_55) AT=750.025n

.meas tran vdout0_56ck1490 FIND v(dout0_56) AT=750.025n

.meas tran vdout0_57ck1490 FIND v(dout0_57) AT=750.025n

.meas tran vdout0_58ck1490 FIND v(dout0_58) AT=750.025n

.meas tran vdout0_59ck1490 FIND v(dout0_59) AT=750.025n

.meas tran vdout0_60ck1490 FIND v(dout0_60) AT=750.025n

.meas tran vdout0_61ck1490 FIND v(dout0_61) AT=750.025n

.meas tran vdout0_62ck1490 FIND v(dout0_62) AT=750.025n

.meas tran vdout0_63ck1490 FIND v(dout0_63) AT=750.025n

.meas tran vdout0_64ck1490 FIND v(dout0_64) AT=750.025n

.meas tran vdout0_65ck1490 FIND v(dout0_65) AT=750.025n

.meas tran vdout0_66ck1490 FIND v(dout0_66) AT=750.025n

.meas tran vdout0_67ck1490 FIND v(dout0_67) AT=750.025n

.meas tran vdout0_68ck1490 FIND v(dout0_68) AT=750.025n

.meas tran vdout0_69ck1490 FIND v(dout0_69) AT=750.025n

.meas tran vdout0_70ck1490 FIND v(dout0_70) AT=750.025n

.meas tran vdout0_71ck1490 FIND v(dout0_71) AT=750.025n

.meas tran vdout0_72ck1490 FIND v(dout0_72) AT=750.025n

.meas tran vdout0_73ck1490 FIND v(dout0_73) AT=750.025n

.meas tran vdout0_74ck1490 FIND v(dout0_74) AT=750.025n

.meas tran vdout0_75ck1490 FIND v(dout0_75) AT=750.025n

.meas tran vdout0_76ck1490 FIND v(dout0_76) AT=750.025n

.meas tran vdout0_77ck1490 FIND v(dout0_77) AT=750.025n

.meas tran vdout0_78ck1490 FIND v(dout0_78) AT=750.025n

.meas tran vdout0_79ck1490 FIND v(dout0_79) AT=750.025n

.meas tran vdout0_80ck1490 FIND v(dout0_80) AT=750.025n

.meas tran vdout0_81ck1490 FIND v(dout0_81) AT=750.025n

.meas tran vdout0_82ck1490 FIND v(dout0_82) AT=750.025n

.meas tran vdout0_83ck1490 FIND v(dout0_83) AT=750.025n

.meas tran vdout0_84ck1490 FIND v(dout0_84) AT=750.025n

.meas tran vdout0_85ck1490 FIND v(dout0_85) AT=750.025n

.meas tran vdout0_86ck1490 FIND v(dout0_86) AT=750.025n

.meas tran vdout0_87ck1490 FIND v(dout0_87) AT=750.025n

.meas tran vdout0_88ck1490 FIND v(dout0_88) AT=750.025n

.meas tran vdout0_89ck1490 FIND v(dout0_89) AT=750.025n

.meas tran vdout0_90ck1490 FIND v(dout0_90) AT=750.025n

.meas tran vdout0_91ck1490 FIND v(dout0_91) AT=750.025n

.meas tran vdout0_92ck1490 FIND v(dout0_92) AT=750.025n

.meas tran vdout0_93ck1490 FIND v(dout0_93) AT=750.025n

.meas tran vdout0_94ck1490 FIND v(dout0_94) AT=750.025n

.meas tran vdout0_95ck1490 FIND v(dout0_95) AT=750.025n

.meas tran vdout0_96ck1490 FIND v(dout0_96) AT=750.025n

.meas tran vdout0_97ck1490 FIND v(dout0_97) AT=750.025n

.meas tran vdout0_98ck1490 FIND v(dout0_98) AT=750.025n

.meas tran vdout0_99ck1490 FIND v(dout0_99) AT=750.025n

.meas tran vdout0_100ck1490 FIND v(dout0_100) AT=750.025n

.meas tran vdout0_101ck1490 FIND v(dout0_101) AT=750.025n

.meas tran vdout0_102ck1490 FIND v(dout0_102) AT=750.025n

.meas tran vdout0_103ck1490 FIND v(dout0_103) AT=750.025n

.meas tran vdout0_104ck1490 FIND v(dout0_104) AT=750.025n

.meas tran vdout0_105ck1490 FIND v(dout0_105) AT=750.025n

.meas tran vdout0_106ck1490 FIND v(dout0_106) AT=750.025n

.meas tran vdout0_107ck1490 FIND v(dout0_107) AT=750.025n

.meas tran vdout0_108ck1490 FIND v(dout0_108) AT=750.025n

.meas tran vdout0_109ck1490 FIND v(dout0_109) AT=750.025n

.meas tran vdout0_110ck1490 FIND v(dout0_110) AT=750.025n

.meas tran vdout0_111ck1490 FIND v(dout0_111) AT=750.025n

.meas tran vdout0_112ck1490 FIND v(dout0_112) AT=750.025n

.meas tran vdout0_113ck1490 FIND v(dout0_113) AT=750.025n

.meas tran vdout0_114ck1490 FIND v(dout0_114) AT=750.025n

.meas tran vdout0_115ck1490 FIND v(dout0_115) AT=750.025n

.meas tran vdout0_116ck1490 FIND v(dout0_116) AT=750.025n

.meas tran vdout0_117ck1490 FIND v(dout0_117) AT=750.025n

.meas tran vdout0_118ck1490 FIND v(dout0_118) AT=750.025n

.meas tran vdout0_119ck1490 FIND v(dout0_119) AT=750.025n

.meas tran vdout0_120ck1490 FIND v(dout0_120) AT=750.025n

.meas tran vdout0_121ck1490 FIND v(dout0_121) AT=750.025n

.meas tran vdout0_122ck1490 FIND v(dout0_122) AT=750.025n

.meas tran vdout0_123ck1490 FIND v(dout0_123) AT=750.025n

.meas tran vdout0_124ck1490 FIND v(dout0_124) AT=750.025n

.meas tran vdout0_125ck1490 FIND v(dout0_125) AT=750.025n

.meas tran vdout0_126ck1490 FIND v(dout0_126) AT=750.025n

.meas tran vdout0_127ck1490 FIND v(dout0_127) AT=750.025n

.meas tran vdout0_128ck1490 FIND v(dout0_128) AT=750.025n

.meas tran vdout0_129ck1490 FIND v(dout0_129) AT=750.025n

.meas tran vdout0_130ck1490 FIND v(dout0_130) AT=750.025n

.meas tran vdout0_131ck1490 FIND v(dout0_131) AT=750.025n

.meas tran vdout0_132ck1490 FIND v(dout0_132) AT=750.025n

.meas tran vdout0_133ck1490 FIND v(dout0_133) AT=750.025n

.meas tran vdout0_134ck1490 FIND v(dout0_134) AT=750.025n

.meas tran vdout0_135ck1490 FIND v(dout0_135) AT=750.025n

.meas tran vdout0_136ck1490 FIND v(dout0_136) AT=750.025n

.meas tran vdout0_137ck1490 FIND v(dout0_137) AT=750.025n

.meas tran vdout0_138ck1490 FIND v(dout0_138) AT=750.025n

.meas tran vdout0_139ck1490 FIND v(dout0_139) AT=750.025n

.meas tran vdout0_140ck1490 FIND v(dout0_140) AT=750.025n

.meas tran vdout0_141ck1490 FIND v(dout0_141) AT=750.025n

.meas tran vdout0_142ck1490 FIND v(dout0_142) AT=750.025n

.meas tran vdout0_143ck1490 FIND v(dout0_143) AT=750.025n

.meas tran vdout0_144ck1490 FIND v(dout0_144) AT=750.025n

.meas tran vdout0_145ck1490 FIND v(dout0_145) AT=750.025n

.meas tran vdout0_146ck1490 FIND v(dout0_146) AT=750.025n

.meas tran vdout0_147ck1490 FIND v(dout0_147) AT=750.025n

.meas tran vdout0_148ck1490 FIND v(dout0_148) AT=750.025n

.meas tran vdout0_149ck1490 FIND v(dout0_149) AT=750.025n

.meas tran vdout0_0ck1530 FIND v(dout0_0) AT=770.025n

.meas tran vdout0_1ck1530 FIND v(dout0_1) AT=770.025n

.meas tran vdout0_2ck1530 FIND v(dout0_2) AT=770.025n

.meas tran vdout0_3ck1530 FIND v(dout0_3) AT=770.025n

.meas tran vdout0_4ck1530 FIND v(dout0_4) AT=770.025n

.meas tran vdout0_5ck1530 FIND v(dout0_5) AT=770.025n

.meas tran vdout0_6ck1530 FIND v(dout0_6) AT=770.025n

.meas tran vdout0_7ck1530 FIND v(dout0_7) AT=770.025n

.meas tran vdout0_8ck1530 FIND v(dout0_8) AT=770.025n

.meas tran vdout0_9ck1530 FIND v(dout0_9) AT=770.025n

.meas tran vdout0_10ck1530 FIND v(dout0_10) AT=770.025n

.meas tran vdout0_11ck1530 FIND v(dout0_11) AT=770.025n

.meas tran vdout0_12ck1530 FIND v(dout0_12) AT=770.025n

.meas tran vdout0_13ck1530 FIND v(dout0_13) AT=770.025n

.meas tran vdout0_14ck1530 FIND v(dout0_14) AT=770.025n

.meas tran vdout0_15ck1530 FIND v(dout0_15) AT=770.025n

.meas tran vdout0_16ck1530 FIND v(dout0_16) AT=770.025n

.meas tran vdout0_17ck1530 FIND v(dout0_17) AT=770.025n

.meas tran vdout0_18ck1530 FIND v(dout0_18) AT=770.025n

.meas tran vdout0_19ck1530 FIND v(dout0_19) AT=770.025n

.meas tran vdout0_20ck1530 FIND v(dout0_20) AT=770.025n

.meas tran vdout0_21ck1530 FIND v(dout0_21) AT=770.025n

.meas tran vdout0_22ck1530 FIND v(dout0_22) AT=770.025n

.meas tran vdout0_23ck1530 FIND v(dout0_23) AT=770.025n

.meas tran vdout0_24ck1530 FIND v(dout0_24) AT=770.025n

.meas tran vdout0_25ck1530 FIND v(dout0_25) AT=770.025n

.meas tran vdout0_26ck1530 FIND v(dout0_26) AT=770.025n

.meas tran vdout0_27ck1530 FIND v(dout0_27) AT=770.025n

.meas tran vdout0_28ck1530 FIND v(dout0_28) AT=770.025n

.meas tran vdout0_29ck1530 FIND v(dout0_29) AT=770.025n

.meas tran vdout0_30ck1530 FIND v(dout0_30) AT=770.025n

.meas tran vdout0_31ck1530 FIND v(dout0_31) AT=770.025n

.meas tran vdout0_32ck1530 FIND v(dout0_32) AT=770.025n

.meas tran vdout0_33ck1530 FIND v(dout0_33) AT=770.025n

.meas tran vdout0_34ck1530 FIND v(dout0_34) AT=770.025n

.meas tran vdout0_35ck1530 FIND v(dout0_35) AT=770.025n

.meas tran vdout0_36ck1530 FIND v(dout0_36) AT=770.025n

.meas tran vdout0_37ck1530 FIND v(dout0_37) AT=770.025n

.meas tran vdout0_38ck1530 FIND v(dout0_38) AT=770.025n

.meas tran vdout0_39ck1530 FIND v(dout0_39) AT=770.025n

.meas tran vdout0_40ck1530 FIND v(dout0_40) AT=770.025n

.meas tran vdout0_41ck1530 FIND v(dout0_41) AT=770.025n

.meas tran vdout0_42ck1530 FIND v(dout0_42) AT=770.025n

.meas tran vdout0_43ck1530 FIND v(dout0_43) AT=770.025n

.meas tran vdout0_44ck1530 FIND v(dout0_44) AT=770.025n

.meas tran vdout0_45ck1530 FIND v(dout0_45) AT=770.025n

.meas tran vdout0_46ck1530 FIND v(dout0_46) AT=770.025n

.meas tran vdout0_47ck1530 FIND v(dout0_47) AT=770.025n

.meas tran vdout0_48ck1530 FIND v(dout0_48) AT=770.025n

.meas tran vdout0_49ck1530 FIND v(dout0_49) AT=770.025n

.meas tran vdout0_50ck1530 FIND v(dout0_50) AT=770.025n

.meas tran vdout0_51ck1530 FIND v(dout0_51) AT=770.025n

.meas tran vdout0_52ck1530 FIND v(dout0_52) AT=770.025n

.meas tran vdout0_53ck1530 FIND v(dout0_53) AT=770.025n

.meas tran vdout0_54ck1530 FIND v(dout0_54) AT=770.025n

.meas tran vdout0_55ck1530 FIND v(dout0_55) AT=770.025n

.meas tran vdout0_56ck1530 FIND v(dout0_56) AT=770.025n

.meas tran vdout0_57ck1530 FIND v(dout0_57) AT=770.025n

.meas tran vdout0_58ck1530 FIND v(dout0_58) AT=770.025n

.meas tran vdout0_59ck1530 FIND v(dout0_59) AT=770.025n

.meas tran vdout0_60ck1530 FIND v(dout0_60) AT=770.025n

.meas tran vdout0_61ck1530 FIND v(dout0_61) AT=770.025n

.meas tran vdout0_62ck1530 FIND v(dout0_62) AT=770.025n

.meas tran vdout0_63ck1530 FIND v(dout0_63) AT=770.025n

.meas tran vdout0_64ck1530 FIND v(dout0_64) AT=770.025n

.meas tran vdout0_65ck1530 FIND v(dout0_65) AT=770.025n

.meas tran vdout0_66ck1530 FIND v(dout0_66) AT=770.025n

.meas tran vdout0_67ck1530 FIND v(dout0_67) AT=770.025n

.meas tran vdout0_68ck1530 FIND v(dout0_68) AT=770.025n

.meas tran vdout0_69ck1530 FIND v(dout0_69) AT=770.025n

.meas tran vdout0_70ck1530 FIND v(dout0_70) AT=770.025n

.meas tran vdout0_71ck1530 FIND v(dout0_71) AT=770.025n

.meas tran vdout0_72ck1530 FIND v(dout0_72) AT=770.025n

.meas tran vdout0_73ck1530 FIND v(dout0_73) AT=770.025n

.meas tran vdout0_74ck1530 FIND v(dout0_74) AT=770.025n

.meas tran vdout0_75ck1530 FIND v(dout0_75) AT=770.025n

.meas tran vdout0_76ck1530 FIND v(dout0_76) AT=770.025n

.meas tran vdout0_77ck1530 FIND v(dout0_77) AT=770.025n

.meas tran vdout0_78ck1530 FIND v(dout0_78) AT=770.025n

.meas tran vdout0_79ck1530 FIND v(dout0_79) AT=770.025n

.meas tran vdout0_80ck1530 FIND v(dout0_80) AT=770.025n

.meas tran vdout0_81ck1530 FIND v(dout0_81) AT=770.025n

.meas tran vdout0_82ck1530 FIND v(dout0_82) AT=770.025n

.meas tran vdout0_83ck1530 FIND v(dout0_83) AT=770.025n

.meas tran vdout0_84ck1530 FIND v(dout0_84) AT=770.025n

.meas tran vdout0_85ck1530 FIND v(dout0_85) AT=770.025n

.meas tran vdout0_86ck1530 FIND v(dout0_86) AT=770.025n

.meas tran vdout0_87ck1530 FIND v(dout0_87) AT=770.025n

.meas tran vdout0_88ck1530 FIND v(dout0_88) AT=770.025n

.meas tran vdout0_89ck1530 FIND v(dout0_89) AT=770.025n

.meas tran vdout0_90ck1530 FIND v(dout0_90) AT=770.025n

.meas tran vdout0_91ck1530 FIND v(dout0_91) AT=770.025n

.meas tran vdout0_92ck1530 FIND v(dout0_92) AT=770.025n

.meas tran vdout0_93ck1530 FIND v(dout0_93) AT=770.025n

.meas tran vdout0_94ck1530 FIND v(dout0_94) AT=770.025n

.meas tran vdout0_95ck1530 FIND v(dout0_95) AT=770.025n

.meas tran vdout0_96ck1530 FIND v(dout0_96) AT=770.025n

.meas tran vdout0_97ck1530 FIND v(dout0_97) AT=770.025n

.meas tran vdout0_98ck1530 FIND v(dout0_98) AT=770.025n

.meas tran vdout0_99ck1530 FIND v(dout0_99) AT=770.025n

.meas tran vdout0_100ck1530 FIND v(dout0_100) AT=770.025n

.meas tran vdout0_101ck1530 FIND v(dout0_101) AT=770.025n

.meas tran vdout0_102ck1530 FIND v(dout0_102) AT=770.025n

.meas tran vdout0_103ck1530 FIND v(dout0_103) AT=770.025n

.meas tran vdout0_104ck1530 FIND v(dout0_104) AT=770.025n

.meas tran vdout0_105ck1530 FIND v(dout0_105) AT=770.025n

.meas tran vdout0_106ck1530 FIND v(dout0_106) AT=770.025n

.meas tran vdout0_107ck1530 FIND v(dout0_107) AT=770.025n

.meas tran vdout0_108ck1530 FIND v(dout0_108) AT=770.025n

.meas tran vdout0_109ck1530 FIND v(dout0_109) AT=770.025n

.meas tran vdout0_110ck1530 FIND v(dout0_110) AT=770.025n

.meas tran vdout0_111ck1530 FIND v(dout0_111) AT=770.025n

.meas tran vdout0_112ck1530 FIND v(dout0_112) AT=770.025n

.meas tran vdout0_113ck1530 FIND v(dout0_113) AT=770.025n

.meas tran vdout0_114ck1530 FIND v(dout0_114) AT=770.025n

.meas tran vdout0_115ck1530 FIND v(dout0_115) AT=770.025n

.meas tran vdout0_116ck1530 FIND v(dout0_116) AT=770.025n

.meas tran vdout0_117ck1530 FIND v(dout0_117) AT=770.025n

.meas tran vdout0_118ck1530 FIND v(dout0_118) AT=770.025n

.meas tran vdout0_119ck1530 FIND v(dout0_119) AT=770.025n

.meas tran vdout0_120ck1530 FIND v(dout0_120) AT=770.025n

.meas tran vdout0_121ck1530 FIND v(dout0_121) AT=770.025n

.meas tran vdout0_122ck1530 FIND v(dout0_122) AT=770.025n

.meas tran vdout0_123ck1530 FIND v(dout0_123) AT=770.025n

.meas tran vdout0_124ck1530 FIND v(dout0_124) AT=770.025n

.meas tran vdout0_125ck1530 FIND v(dout0_125) AT=770.025n

.meas tran vdout0_126ck1530 FIND v(dout0_126) AT=770.025n

.meas tran vdout0_127ck1530 FIND v(dout0_127) AT=770.025n

.meas tran vdout0_128ck1530 FIND v(dout0_128) AT=770.025n

.meas tran vdout0_129ck1530 FIND v(dout0_129) AT=770.025n

.meas tran vdout0_130ck1530 FIND v(dout0_130) AT=770.025n

.meas tran vdout0_131ck1530 FIND v(dout0_131) AT=770.025n

.meas tran vdout0_132ck1530 FIND v(dout0_132) AT=770.025n

.meas tran vdout0_133ck1530 FIND v(dout0_133) AT=770.025n

.meas tran vdout0_134ck1530 FIND v(dout0_134) AT=770.025n

.meas tran vdout0_135ck1530 FIND v(dout0_135) AT=770.025n

.meas tran vdout0_136ck1530 FIND v(dout0_136) AT=770.025n

.meas tran vdout0_137ck1530 FIND v(dout0_137) AT=770.025n

.meas tran vdout0_138ck1530 FIND v(dout0_138) AT=770.025n

.meas tran vdout0_139ck1530 FIND v(dout0_139) AT=770.025n

.meas tran vdout0_140ck1530 FIND v(dout0_140) AT=770.025n

.meas tran vdout0_141ck1530 FIND v(dout0_141) AT=770.025n

.meas tran vdout0_142ck1530 FIND v(dout0_142) AT=770.025n

.meas tran vdout0_143ck1530 FIND v(dout0_143) AT=770.025n

.meas tran vdout0_144ck1530 FIND v(dout0_144) AT=770.025n

.meas tran vdout0_145ck1530 FIND v(dout0_145) AT=770.025n

.meas tran vdout0_146ck1530 FIND v(dout0_146) AT=770.025n

.meas tran vdout0_147ck1530 FIND v(dout0_147) AT=770.025n

.meas tran vdout0_148ck1530 FIND v(dout0_148) AT=770.025n

.meas tran vdout0_149ck1530 FIND v(dout0_149) AT=770.025n

.meas tran vdout0_0ck1550 FIND v(dout0_0) AT=780.025n

.meas tran vdout0_1ck1550 FIND v(dout0_1) AT=780.025n

.meas tran vdout0_2ck1550 FIND v(dout0_2) AT=780.025n

.meas tran vdout0_3ck1550 FIND v(dout0_3) AT=780.025n

.meas tran vdout0_4ck1550 FIND v(dout0_4) AT=780.025n

.meas tran vdout0_5ck1550 FIND v(dout0_5) AT=780.025n

.meas tran vdout0_6ck1550 FIND v(dout0_6) AT=780.025n

.meas tran vdout0_7ck1550 FIND v(dout0_7) AT=780.025n

.meas tran vdout0_8ck1550 FIND v(dout0_8) AT=780.025n

.meas tran vdout0_9ck1550 FIND v(dout0_9) AT=780.025n

.meas tran vdout0_10ck1550 FIND v(dout0_10) AT=780.025n

.meas tran vdout0_11ck1550 FIND v(dout0_11) AT=780.025n

.meas tran vdout0_12ck1550 FIND v(dout0_12) AT=780.025n

.meas tran vdout0_13ck1550 FIND v(dout0_13) AT=780.025n

.meas tran vdout0_14ck1550 FIND v(dout0_14) AT=780.025n

.meas tran vdout0_15ck1550 FIND v(dout0_15) AT=780.025n

.meas tran vdout0_16ck1550 FIND v(dout0_16) AT=780.025n

.meas tran vdout0_17ck1550 FIND v(dout0_17) AT=780.025n

.meas tran vdout0_18ck1550 FIND v(dout0_18) AT=780.025n

.meas tran vdout0_19ck1550 FIND v(dout0_19) AT=780.025n

.meas tran vdout0_20ck1550 FIND v(dout0_20) AT=780.025n

.meas tran vdout0_21ck1550 FIND v(dout0_21) AT=780.025n

.meas tran vdout0_22ck1550 FIND v(dout0_22) AT=780.025n

.meas tran vdout0_23ck1550 FIND v(dout0_23) AT=780.025n

.meas tran vdout0_24ck1550 FIND v(dout0_24) AT=780.025n

.meas tran vdout0_25ck1550 FIND v(dout0_25) AT=780.025n

.meas tran vdout0_26ck1550 FIND v(dout0_26) AT=780.025n

.meas tran vdout0_27ck1550 FIND v(dout0_27) AT=780.025n

.meas tran vdout0_28ck1550 FIND v(dout0_28) AT=780.025n

.meas tran vdout0_29ck1550 FIND v(dout0_29) AT=780.025n

.meas tran vdout0_30ck1550 FIND v(dout0_30) AT=780.025n

.meas tran vdout0_31ck1550 FIND v(dout0_31) AT=780.025n

.meas tran vdout0_32ck1550 FIND v(dout0_32) AT=780.025n

.meas tran vdout0_33ck1550 FIND v(dout0_33) AT=780.025n

.meas tran vdout0_34ck1550 FIND v(dout0_34) AT=780.025n

.meas tran vdout0_35ck1550 FIND v(dout0_35) AT=780.025n

.meas tran vdout0_36ck1550 FIND v(dout0_36) AT=780.025n

.meas tran vdout0_37ck1550 FIND v(dout0_37) AT=780.025n

.meas tran vdout0_38ck1550 FIND v(dout0_38) AT=780.025n

.meas tran vdout0_39ck1550 FIND v(dout0_39) AT=780.025n

.meas tran vdout0_40ck1550 FIND v(dout0_40) AT=780.025n

.meas tran vdout0_41ck1550 FIND v(dout0_41) AT=780.025n

.meas tran vdout0_42ck1550 FIND v(dout0_42) AT=780.025n

.meas tran vdout0_43ck1550 FIND v(dout0_43) AT=780.025n

.meas tran vdout0_44ck1550 FIND v(dout0_44) AT=780.025n

.meas tran vdout0_45ck1550 FIND v(dout0_45) AT=780.025n

.meas tran vdout0_46ck1550 FIND v(dout0_46) AT=780.025n

.meas tran vdout0_47ck1550 FIND v(dout0_47) AT=780.025n

.meas tran vdout0_48ck1550 FIND v(dout0_48) AT=780.025n

.meas tran vdout0_49ck1550 FIND v(dout0_49) AT=780.025n

.meas tran vdout0_50ck1550 FIND v(dout0_50) AT=780.025n

.meas tran vdout0_51ck1550 FIND v(dout0_51) AT=780.025n

.meas tran vdout0_52ck1550 FIND v(dout0_52) AT=780.025n

.meas tran vdout0_53ck1550 FIND v(dout0_53) AT=780.025n

.meas tran vdout0_54ck1550 FIND v(dout0_54) AT=780.025n

.meas tran vdout0_55ck1550 FIND v(dout0_55) AT=780.025n

.meas tran vdout0_56ck1550 FIND v(dout0_56) AT=780.025n

.meas tran vdout0_57ck1550 FIND v(dout0_57) AT=780.025n

.meas tran vdout0_58ck1550 FIND v(dout0_58) AT=780.025n

.meas tran vdout0_59ck1550 FIND v(dout0_59) AT=780.025n

.meas tran vdout0_60ck1550 FIND v(dout0_60) AT=780.025n

.meas tran vdout0_61ck1550 FIND v(dout0_61) AT=780.025n

.meas tran vdout0_62ck1550 FIND v(dout0_62) AT=780.025n

.meas tran vdout0_63ck1550 FIND v(dout0_63) AT=780.025n

.meas tran vdout0_64ck1550 FIND v(dout0_64) AT=780.025n

.meas tran vdout0_65ck1550 FIND v(dout0_65) AT=780.025n

.meas tran vdout0_66ck1550 FIND v(dout0_66) AT=780.025n

.meas tran vdout0_67ck1550 FIND v(dout0_67) AT=780.025n

.meas tran vdout0_68ck1550 FIND v(dout0_68) AT=780.025n

.meas tran vdout0_69ck1550 FIND v(dout0_69) AT=780.025n

.meas tran vdout0_70ck1550 FIND v(dout0_70) AT=780.025n

.meas tran vdout0_71ck1550 FIND v(dout0_71) AT=780.025n

.meas tran vdout0_72ck1550 FIND v(dout0_72) AT=780.025n

.meas tran vdout0_73ck1550 FIND v(dout0_73) AT=780.025n

.meas tran vdout0_74ck1550 FIND v(dout0_74) AT=780.025n

.meas tran vdout0_75ck1550 FIND v(dout0_75) AT=780.025n

.meas tran vdout0_76ck1550 FIND v(dout0_76) AT=780.025n

.meas tran vdout0_77ck1550 FIND v(dout0_77) AT=780.025n

.meas tran vdout0_78ck1550 FIND v(dout0_78) AT=780.025n

.meas tran vdout0_79ck1550 FIND v(dout0_79) AT=780.025n

.meas tran vdout0_80ck1550 FIND v(dout0_80) AT=780.025n

.meas tran vdout0_81ck1550 FIND v(dout0_81) AT=780.025n

.meas tran vdout0_82ck1550 FIND v(dout0_82) AT=780.025n

.meas tran vdout0_83ck1550 FIND v(dout0_83) AT=780.025n

.meas tran vdout0_84ck1550 FIND v(dout0_84) AT=780.025n

.meas tran vdout0_85ck1550 FIND v(dout0_85) AT=780.025n

.meas tran vdout0_86ck1550 FIND v(dout0_86) AT=780.025n

.meas tran vdout0_87ck1550 FIND v(dout0_87) AT=780.025n

.meas tran vdout0_88ck1550 FIND v(dout0_88) AT=780.025n

.meas tran vdout0_89ck1550 FIND v(dout0_89) AT=780.025n

.meas tran vdout0_90ck1550 FIND v(dout0_90) AT=780.025n

.meas tran vdout0_91ck1550 FIND v(dout0_91) AT=780.025n

.meas tran vdout0_92ck1550 FIND v(dout0_92) AT=780.025n

.meas tran vdout0_93ck1550 FIND v(dout0_93) AT=780.025n

.meas tran vdout0_94ck1550 FIND v(dout0_94) AT=780.025n

.meas tran vdout0_95ck1550 FIND v(dout0_95) AT=780.025n

.meas tran vdout0_96ck1550 FIND v(dout0_96) AT=780.025n

.meas tran vdout0_97ck1550 FIND v(dout0_97) AT=780.025n

.meas tran vdout0_98ck1550 FIND v(dout0_98) AT=780.025n

.meas tran vdout0_99ck1550 FIND v(dout0_99) AT=780.025n

.meas tran vdout0_100ck1550 FIND v(dout0_100) AT=780.025n

.meas tran vdout0_101ck1550 FIND v(dout0_101) AT=780.025n

.meas tran vdout0_102ck1550 FIND v(dout0_102) AT=780.025n

.meas tran vdout0_103ck1550 FIND v(dout0_103) AT=780.025n

.meas tran vdout0_104ck1550 FIND v(dout0_104) AT=780.025n

.meas tran vdout0_105ck1550 FIND v(dout0_105) AT=780.025n

.meas tran vdout0_106ck1550 FIND v(dout0_106) AT=780.025n

.meas tran vdout0_107ck1550 FIND v(dout0_107) AT=780.025n

.meas tran vdout0_108ck1550 FIND v(dout0_108) AT=780.025n

.meas tran vdout0_109ck1550 FIND v(dout0_109) AT=780.025n

.meas tran vdout0_110ck1550 FIND v(dout0_110) AT=780.025n

.meas tran vdout0_111ck1550 FIND v(dout0_111) AT=780.025n

.meas tran vdout0_112ck1550 FIND v(dout0_112) AT=780.025n

.meas tran vdout0_113ck1550 FIND v(dout0_113) AT=780.025n

.meas tran vdout0_114ck1550 FIND v(dout0_114) AT=780.025n

.meas tran vdout0_115ck1550 FIND v(dout0_115) AT=780.025n

.meas tran vdout0_116ck1550 FIND v(dout0_116) AT=780.025n

.meas tran vdout0_117ck1550 FIND v(dout0_117) AT=780.025n

.meas tran vdout0_118ck1550 FIND v(dout0_118) AT=780.025n

.meas tran vdout0_119ck1550 FIND v(dout0_119) AT=780.025n

.meas tran vdout0_120ck1550 FIND v(dout0_120) AT=780.025n

.meas tran vdout0_121ck1550 FIND v(dout0_121) AT=780.025n

.meas tran vdout0_122ck1550 FIND v(dout0_122) AT=780.025n

.meas tran vdout0_123ck1550 FIND v(dout0_123) AT=780.025n

.meas tran vdout0_124ck1550 FIND v(dout0_124) AT=780.025n

.meas tran vdout0_125ck1550 FIND v(dout0_125) AT=780.025n

.meas tran vdout0_126ck1550 FIND v(dout0_126) AT=780.025n

.meas tran vdout0_127ck1550 FIND v(dout0_127) AT=780.025n

.meas tran vdout0_128ck1550 FIND v(dout0_128) AT=780.025n

.meas tran vdout0_129ck1550 FIND v(dout0_129) AT=780.025n

.meas tran vdout0_130ck1550 FIND v(dout0_130) AT=780.025n

.meas tran vdout0_131ck1550 FIND v(dout0_131) AT=780.025n

.meas tran vdout0_132ck1550 FIND v(dout0_132) AT=780.025n

.meas tran vdout0_133ck1550 FIND v(dout0_133) AT=780.025n

.meas tran vdout0_134ck1550 FIND v(dout0_134) AT=780.025n

.meas tran vdout0_135ck1550 FIND v(dout0_135) AT=780.025n

.meas tran vdout0_136ck1550 FIND v(dout0_136) AT=780.025n

.meas tran vdout0_137ck1550 FIND v(dout0_137) AT=780.025n

.meas tran vdout0_138ck1550 FIND v(dout0_138) AT=780.025n

.meas tran vdout0_139ck1550 FIND v(dout0_139) AT=780.025n

.meas tran vdout0_140ck1550 FIND v(dout0_140) AT=780.025n

.meas tran vdout0_141ck1550 FIND v(dout0_141) AT=780.025n

.meas tran vdout0_142ck1550 FIND v(dout0_142) AT=780.025n

.meas tran vdout0_143ck1550 FIND v(dout0_143) AT=780.025n

.meas tran vdout0_144ck1550 FIND v(dout0_144) AT=780.025n

.meas tran vdout0_145ck1550 FIND v(dout0_145) AT=780.025n

.meas tran vdout0_146ck1550 FIND v(dout0_146) AT=780.025n

.meas tran vdout0_147ck1550 FIND v(dout0_147) AT=780.025n

.meas tran vdout0_148ck1550 FIND v(dout0_148) AT=780.025n

.meas tran vdout0_149ck1550 FIND v(dout0_149) AT=780.025n

.meas tran vdout0_0ck1570 FIND v(dout0_0) AT=790.025n

.meas tran vdout0_1ck1570 FIND v(dout0_1) AT=790.025n

.meas tran vdout0_2ck1570 FIND v(dout0_2) AT=790.025n

.meas tran vdout0_3ck1570 FIND v(dout0_3) AT=790.025n

.meas tran vdout0_4ck1570 FIND v(dout0_4) AT=790.025n

.meas tran vdout0_5ck1570 FIND v(dout0_5) AT=790.025n

.meas tran vdout0_6ck1570 FIND v(dout0_6) AT=790.025n

.meas tran vdout0_7ck1570 FIND v(dout0_7) AT=790.025n

.meas tran vdout0_8ck1570 FIND v(dout0_8) AT=790.025n

.meas tran vdout0_9ck1570 FIND v(dout0_9) AT=790.025n

.meas tran vdout0_10ck1570 FIND v(dout0_10) AT=790.025n

.meas tran vdout0_11ck1570 FIND v(dout0_11) AT=790.025n

.meas tran vdout0_12ck1570 FIND v(dout0_12) AT=790.025n

.meas tran vdout0_13ck1570 FIND v(dout0_13) AT=790.025n

.meas tran vdout0_14ck1570 FIND v(dout0_14) AT=790.025n

.meas tran vdout0_15ck1570 FIND v(dout0_15) AT=790.025n

.meas tran vdout0_16ck1570 FIND v(dout0_16) AT=790.025n

.meas tran vdout0_17ck1570 FIND v(dout0_17) AT=790.025n

.meas tran vdout0_18ck1570 FIND v(dout0_18) AT=790.025n

.meas tran vdout0_19ck1570 FIND v(dout0_19) AT=790.025n

.meas tran vdout0_20ck1570 FIND v(dout0_20) AT=790.025n

.meas tran vdout0_21ck1570 FIND v(dout0_21) AT=790.025n

.meas tran vdout0_22ck1570 FIND v(dout0_22) AT=790.025n

.meas tran vdout0_23ck1570 FIND v(dout0_23) AT=790.025n

.meas tran vdout0_24ck1570 FIND v(dout0_24) AT=790.025n

.meas tran vdout0_25ck1570 FIND v(dout0_25) AT=790.025n

.meas tran vdout0_26ck1570 FIND v(dout0_26) AT=790.025n

.meas tran vdout0_27ck1570 FIND v(dout0_27) AT=790.025n

.meas tran vdout0_28ck1570 FIND v(dout0_28) AT=790.025n

.meas tran vdout0_29ck1570 FIND v(dout0_29) AT=790.025n

.meas tran vdout0_30ck1570 FIND v(dout0_30) AT=790.025n

.meas tran vdout0_31ck1570 FIND v(dout0_31) AT=790.025n

.meas tran vdout0_32ck1570 FIND v(dout0_32) AT=790.025n

.meas tran vdout0_33ck1570 FIND v(dout0_33) AT=790.025n

.meas tran vdout0_34ck1570 FIND v(dout0_34) AT=790.025n

.meas tran vdout0_35ck1570 FIND v(dout0_35) AT=790.025n

.meas tran vdout0_36ck1570 FIND v(dout0_36) AT=790.025n

.meas tran vdout0_37ck1570 FIND v(dout0_37) AT=790.025n

.meas tran vdout0_38ck1570 FIND v(dout0_38) AT=790.025n

.meas tran vdout0_39ck1570 FIND v(dout0_39) AT=790.025n

.meas tran vdout0_40ck1570 FIND v(dout0_40) AT=790.025n

.meas tran vdout0_41ck1570 FIND v(dout0_41) AT=790.025n

.meas tran vdout0_42ck1570 FIND v(dout0_42) AT=790.025n

.meas tran vdout0_43ck1570 FIND v(dout0_43) AT=790.025n

.meas tran vdout0_44ck1570 FIND v(dout0_44) AT=790.025n

.meas tran vdout0_45ck1570 FIND v(dout0_45) AT=790.025n

.meas tran vdout0_46ck1570 FIND v(dout0_46) AT=790.025n

.meas tran vdout0_47ck1570 FIND v(dout0_47) AT=790.025n

.meas tran vdout0_48ck1570 FIND v(dout0_48) AT=790.025n

.meas tran vdout0_49ck1570 FIND v(dout0_49) AT=790.025n

.meas tran vdout0_50ck1570 FIND v(dout0_50) AT=790.025n

.meas tran vdout0_51ck1570 FIND v(dout0_51) AT=790.025n

.meas tran vdout0_52ck1570 FIND v(dout0_52) AT=790.025n

.meas tran vdout0_53ck1570 FIND v(dout0_53) AT=790.025n

.meas tran vdout0_54ck1570 FIND v(dout0_54) AT=790.025n

.meas tran vdout0_55ck1570 FIND v(dout0_55) AT=790.025n

.meas tran vdout0_56ck1570 FIND v(dout0_56) AT=790.025n

.meas tran vdout0_57ck1570 FIND v(dout0_57) AT=790.025n

.meas tran vdout0_58ck1570 FIND v(dout0_58) AT=790.025n

.meas tran vdout0_59ck1570 FIND v(dout0_59) AT=790.025n

.meas tran vdout0_60ck1570 FIND v(dout0_60) AT=790.025n

.meas tran vdout0_61ck1570 FIND v(dout0_61) AT=790.025n

.meas tran vdout0_62ck1570 FIND v(dout0_62) AT=790.025n

.meas tran vdout0_63ck1570 FIND v(dout0_63) AT=790.025n

.meas tran vdout0_64ck1570 FIND v(dout0_64) AT=790.025n

.meas tran vdout0_65ck1570 FIND v(dout0_65) AT=790.025n

.meas tran vdout0_66ck1570 FIND v(dout0_66) AT=790.025n

.meas tran vdout0_67ck1570 FIND v(dout0_67) AT=790.025n

.meas tran vdout0_68ck1570 FIND v(dout0_68) AT=790.025n

.meas tran vdout0_69ck1570 FIND v(dout0_69) AT=790.025n

.meas tran vdout0_70ck1570 FIND v(dout0_70) AT=790.025n

.meas tran vdout0_71ck1570 FIND v(dout0_71) AT=790.025n

.meas tran vdout0_72ck1570 FIND v(dout0_72) AT=790.025n

.meas tran vdout0_73ck1570 FIND v(dout0_73) AT=790.025n

.meas tran vdout0_74ck1570 FIND v(dout0_74) AT=790.025n

.meas tran vdout0_75ck1570 FIND v(dout0_75) AT=790.025n

.meas tran vdout0_76ck1570 FIND v(dout0_76) AT=790.025n

.meas tran vdout0_77ck1570 FIND v(dout0_77) AT=790.025n

.meas tran vdout0_78ck1570 FIND v(dout0_78) AT=790.025n

.meas tran vdout0_79ck1570 FIND v(dout0_79) AT=790.025n

.meas tran vdout0_80ck1570 FIND v(dout0_80) AT=790.025n

.meas tran vdout0_81ck1570 FIND v(dout0_81) AT=790.025n

.meas tran vdout0_82ck1570 FIND v(dout0_82) AT=790.025n

.meas tran vdout0_83ck1570 FIND v(dout0_83) AT=790.025n

.meas tran vdout0_84ck1570 FIND v(dout0_84) AT=790.025n

.meas tran vdout0_85ck1570 FIND v(dout0_85) AT=790.025n

.meas tran vdout0_86ck1570 FIND v(dout0_86) AT=790.025n

.meas tran vdout0_87ck1570 FIND v(dout0_87) AT=790.025n

.meas tran vdout0_88ck1570 FIND v(dout0_88) AT=790.025n

.meas tran vdout0_89ck1570 FIND v(dout0_89) AT=790.025n

.meas tran vdout0_90ck1570 FIND v(dout0_90) AT=790.025n

.meas tran vdout0_91ck1570 FIND v(dout0_91) AT=790.025n

.meas tran vdout0_92ck1570 FIND v(dout0_92) AT=790.025n

.meas tran vdout0_93ck1570 FIND v(dout0_93) AT=790.025n

.meas tran vdout0_94ck1570 FIND v(dout0_94) AT=790.025n

.meas tran vdout0_95ck1570 FIND v(dout0_95) AT=790.025n

.meas tran vdout0_96ck1570 FIND v(dout0_96) AT=790.025n

.meas tran vdout0_97ck1570 FIND v(dout0_97) AT=790.025n

.meas tran vdout0_98ck1570 FIND v(dout0_98) AT=790.025n

.meas tran vdout0_99ck1570 FIND v(dout0_99) AT=790.025n

.meas tran vdout0_100ck1570 FIND v(dout0_100) AT=790.025n

.meas tran vdout0_101ck1570 FIND v(dout0_101) AT=790.025n

.meas tran vdout0_102ck1570 FIND v(dout0_102) AT=790.025n

.meas tran vdout0_103ck1570 FIND v(dout0_103) AT=790.025n

.meas tran vdout0_104ck1570 FIND v(dout0_104) AT=790.025n

.meas tran vdout0_105ck1570 FIND v(dout0_105) AT=790.025n

.meas tran vdout0_106ck1570 FIND v(dout0_106) AT=790.025n

.meas tran vdout0_107ck1570 FIND v(dout0_107) AT=790.025n

.meas tran vdout0_108ck1570 FIND v(dout0_108) AT=790.025n

.meas tran vdout0_109ck1570 FIND v(dout0_109) AT=790.025n

.meas tran vdout0_110ck1570 FIND v(dout0_110) AT=790.025n

.meas tran vdout0_111ck1570 FIND v(dout0_111) AT=790.025n

.meas tran vdout0_112ck1570 FIND v(dout0_112) AT=790.025n

.meas tran vdout0_113ck1570 FIND v(dout0_113) AT=790.025n

.meas tran vdout0_114ck1570 FIND v(dout0_114) AT=790.025n

.meas tran vdout0_115ck1570 FIND v(dout0_115) AT=790.025n

.meas tran vdout0_116ck1570 FIND v(dout0_116) AT=790.025n

.meas tran vdout0_117ck1570 FIND v(dout0_117) AT=790.025n

.meas tran vdout0_118ck1570 FIND v(dout0_118) AT=790.025n

.meas tran vdout0_119ck1570 FIND v(dout0_119) AT=790.025n

.meas tran vdout0_120ck1570 FIND v(dout0_120) AT=790.025n

.meas tran vdout0_121ck1570 FIND v(dout0_121) AT=790.025n

.meas tran vdout0_122ck1570 FIND v(dout0_122) AT=790.025n

.meas tran vdout0_123ck1570 FIND v(dout0_123) AT=790.025n

.meas tran vdout0_124ck1570 FIND v(dout0_124) AT=790.025n

.meas tran vdout0_125ck1570 FIND v(dout0_125) AT=790.025n

.meas tran vdout0_126ck1570 FIND v(dout0_126) AT=790.025n

.meas tran vdout0_127ck1570 FIND v(dout0_127) AT=790.025n

.meas tran vdout0_128ck1570 FIND v(dout0_128) AT=790.025n

.meas tran vdout0_129ck1570 FIND v(dout0_129) AT=790.025n

.meas tran vdout0_130ck1570 FIND v(dout0_130) AT=790.025n

.meas tran vdout0_131ck1570 FIND v(dout0_131) AT=790.025n

.meas tran vdout0_132ck1570 FIND v(dout0_132) AT=790.025n

.meas tran vdout0_133ck1570 FIND v(dout0_133) AT=790.025n

.meas tran vdout0_134ck1570 FIND v(dout0_134) AT=790.025n

.meas tran vdout0_135ck1570 FIND v(dout0_135) AT=790.025n

.meas tran vdout0_136ck1570 FIND v(dout0_136) AT=790.025n

.meas tran vdout0_137ck1570 FIND v(dout0_137) AT=790.025n

.meas tran vdout0_138ck1570 FIND v(dout0_138) AT=790.025n

.meas tran vdout0_139ck1570 FIND v(dout0_139) AT=790.025n

.meas tran vdout0_140ck1570 FIND v(dout0_140) AT=790.025n

.meas tran vdout0_141ck1570 FIND v(dout0_141) AT=790.025n

.meas tran vdout0_142ck1570 FIND v(dout0_142) AT=790.025n

.meas tran vdout0_143ck1570 FIND v(dout0_143) AT=790.025n

.meas tran vdout0_144ck1570 FIND v(dout0_144) AT=790.025n

.meas tran vdout0_145ck1570 FIND v(dout0_145) AT=790.025n

.meas tran vdout0_146ck1570 FIND v(dout0_146) AT=790.025n

.meas tran vdout0_147ck1570 FIND v(dout0_147) AT=790.025n

.meas tran vdout0_148ck1570 FIND v(dout0_148) AT=790.025n

.meas tran vdout0_149ck1570 FIND v(dout0_149) AT=790.025n

.meas tran vdout0_0ck1600 FIND v(dout0_0) AT=805.025n

.meas tran vdout0_1ck1600 FIND v(dout0_1) AT=805.025n

.meas tran vdout0_2ck1600 FIND v(dout0_2) AT=805.025n

.meas tran vdout0_3ck1600 FIND v(dout0_3) AT=805.025n

.meas tran vdout0_4ck1600 FIND v(dout0_4) AT=805.025n

.meas tran vdout0_5ck1600 FIND v(dout0_5) AT=805.025n

.meas tran vdout0_6ck1600 FIND v(dout0_6) AT=805.025n

.meas tran vdout0_7ck1600 FIND v(dout0_7) AT=805.025n

.meas tran vdout0_8ck1600 FIND v(dout0_8) AT=805.025n

.meas tran vdout0_9ck1600 FIND v(dout0_9) AT=805.025n

.meas tran vdout0_10ck1600 FIND v(dout0_10) AT=805.025n

.meas tran vdout0_11ck1600 FIND v(dout0_11) AT=805.025n

.meas tran vdout0_12ck1600 FIND v(dout0_12) AT=805.025n

.meas tran vdout0_13ck1600 FIND v(dout0_13) AT=805.025n

.meas tran vdout0_14ck1600 FIND v(dout0_14) AT=805.025n

.meas tran vdout0_15ck1600 FIND v(dout0_15) AT=805.025n

.meas tran vdout0_16ck1600 FIND v(dout0_16) AT=805.025n

.meas tran vdout0_17ck1600 FIND v(dout0_17) AT=805.025n

.meas tran vdout0_18ck1600 FIND v(dout0_18) AT=805.025n

.meas tran vdout0_19ck1600 FIND v(dout0_19) AT=805.025n

.meas tran vdout0_20ck1600 FIND v(dout0_20) AT=805.025n

.meas tran vdout0_21ck1600 FIND v(dout0_21) AT=805.025n

.meas tran vdout0_22ck1600 FIND v(dout0_22) AT=805.025n

.meas tran vdout0_23ck1600 FIND v(dout0_23) AT=805.025n

.meas tran vdout0_24ck1600 FIND v(dout0_24) AT=805.025n

.meas tran vdout0_25ck1600 FIND v(dout0_25) AT=805.025n

.meas tran vdout0_26ck1600 FIND v(dout0_26) AT=805.025n

.meas tran vdout0_27ck1600 FIND v(dout0_27) AT=805.025n

.meas tran vdout0_28ck1600 FIND v(dout0_28) AT=805.025n

.meas tran vdout0_29ck1600 FIND v(dout0_29) AT=805.025n

.meas tran vdout0_30ck1600 FIND v(dout0_30) AT=805.025n

.meas tran vdout0_31ck1600 FIND v(dout0_31) AT=805.025n

.meas tran vdout0_32ck1600 FIND v(dout0_32) AT=805.025n

.meas tran vdout0_33ck1600 FIND v(dout0_33) AT=805.025n

.meas tran vdout0_34ck1600 FIND v(dout0_34) AT=805.025n

.meas tran vdout0_35ck1600 FIND v(dout0_35) AT=805.025n

.meas tran vdout0_36ck1600 FIND v(dout0_36) AT=805.025n

.meas tran vdout0_37ck1600 FIND v(dout0_37) AT=805.025n

.meas tran vdout0_38ck1600 FIND v(dout0_38) AT=805.025n

.meas tran vdout0_39ck1600 FIND v(dout0_39) AT=805.025n

.meas tran vdout0_40ck1600 FIND v(dout0_40) AT=805.025n

.meas tran vdout0_41ck1600 FIND v(dout0_41) AT=805.025n

.meas tran vdout0_42ck1600 FIND v(dout0_42) AT=805.025n

.meas tran vdout0_43ck1600 FIND v(dout0_43) AT=805.025n

.meas tran vdout0_44ck1600 FIND v(dout0_44) AT=805.025n

.meas tran vdout0_45ck1600 FIND v(dout0_45) AT=805.025n

.meas tran vdout0_46ck1600 FIND v(dout0_46) AT=805.025n

.meas tran vdout0_47ck1600 FIND v(dout0_47) AT=805.025n

.meas tran vdout0_48ck1600 FIND v(dout0_48) AT=805.025n

.meas tran vdout0_49ck1600 FIND v(dout0_49) AT=805.025n

.meas tran vdout0_50ck1600 FIND v(dout0_50) AT=805.025n

.meas tran vdout0_51ck1600 FIND v(dout0_51) AT=805.025n

.meas tran vdout0_52ck1600 FIND v(dout0_52) AT=805.025n

.meas tran vdout0_53ck1600 FIND v(dout0_53) AT=805.025n

.meas tran vdout0_54ck1600 FIND v(dout0_54) AT=805.025n

.meas tran vdout0_55ck1600 FIND v(dout0_55) AT=805.025n

.meas tran vdout0_56ck1600 FIND v(dout0_56) AT=805.025n

.meas tran vdout0_57ck1600 FIND v(dout0_57) AT=805.025n

.meas tran vdout0_58ck1600 FIND v(dout0_58) AT=805.025n

.meas tran vdout0_59ck1600 FIND v(dout0_59) AT=805.025n

.meas tran vdout0_60ck1600 FIND v(dout0_60) AT=805.025n

.meas tran vdout0_61ck1600 FIND v(dout0_61) AT=805.025n

.meas tran vdout0_62ck1600 FIND v(dout0_62) AT=805.025n

.meas tran vdout0_63ck1600 FIND v(dout0_63) AT=805.025n

.meas tran vdout0_64ck1600 FIND v(dout0_64) AT=805.025n

.meas tran vdout0_65ck1600 FIND v(dout0_65) AT=805.025n

.meas tran vdout0_66ck1600 FIND v(dout0_66) AT=805.025n

.meas tran vdout0_67ck1600 FIND v(dout0_67) AT=805.025n

.meas tran vdout0_68ck1600 FIND v(dout0_68) AT=805.025n

.meas tran vdout0_69ck1600 FIND v(dout0_69) AT=805.025n

.meas tran vdout0_70ck1600 FIND v(dout0_70) AT=805.025n

.meas tran vdout0_71ck1600 FIND v(dout0_71) AT=805.025n

.meas tran vdout0_72ck1600 FIND v(dout0_72) AT=805.025n

.meas tran vdout0_73ck1600 FIND v(dout0_73) AT=805.025n

.meas tran vdout0_74ck1600 FIND v(dout0_74) AT=805.025n

.meas tran vdout0_75ck1600 FIND v(dout0_75) AT=805.025n

.meas tran vdout0_76ck1600 FIND v(dout0_76) AT=805.025n

.meas tran vdout0_77ck1600 FIND v(dout0_77) AT=805.025n

.meas tran vdout0_78ck1600 FIND v(dout0_78) AT=805.025n

.meas tran vdout0_79ck1600 FIND v(dout0_79) AT=805.025n

.meas tran vdout0_80ck1600 FIND v(dout0_80) AT=805.025n

.meas tran vdout0_81ck1600 FIND v(dout0_81) AT=805.025n

.meas tran vdout0_82ck1600 FIND v(dout0_82) AT=805.025n

.meas tran vdout0_83ck1600 FIND v(dout0_83) AT=805.025n

.meas tran vdout0_84ck1600 FIND v(dout0_84) AT=805.025n

.meas tran vdout0_85ck1600 FIND v(dout0_85) AT=805.025n

.meas tran vdout0_86ck1600 FIND v(dout0_86) AT=805.025n

.meas tran vdout0_87ck1600 FIND v(dout0_87) AT=805.025n

.meas tran vdout0_88ck1600 FIND v(dout0_88) AT=805.025n

.meas tran vdout0_89ck1600 FIND v(dout0_89) AT=805.025n

.meas tran vdout0_90ck1600 FIND v(dout0_90) AT=805.025n

.meas tran vdout0_91ck1600 FIND v(dout0_91) AT=805.025n

.meas tran vdout0_92ck1600 FIND v(dout0_92) AT=805.025n

.meas tran vdout0_93ck1600 FIND v(dout0_93) AT=805.025n

.meas tran vdout0_94ck1600 FIND v(dout0_94) AT=805.025n

.meas tran vdout0_95ck1600 FIND v(dout0_95) AT=805.025n

.meas tran vdout0_96ck1600 FIND v(dout0_96) AT=805.025n

.meas tran vdout0_97ck1600 FIND v(dout0_97) AT=805.025n

.meas tran vdout0_98ck1600 FIND v(dout0_98) AT=805.025n

.meas tran vdout0_99ck1600 FIND v(dout0_99) AT=805.025n

.meas tran vdout0_100ck1600 FIND v(dout0_100) AT=805.025n

.meas tran vdout0_101ck1600 FIND v(dout0_101) AT=805.025n

.meas tran vdout0_102ck1600 FIND v(dout0_102) AT=805.025n

.meas tran vdout0_103ck1600 FIND v(dout0_103) AT=805.025n

.meas tran vdout0_104ck1600 FIND v(dout0_104) AT=805.025n

.meas tran vdout0_105ck1600 FIND v(dout0_105) AT=805.025n

.meas tran vdout0_106ck1600 FIND v(dout0_106) AT=805.025n

.meas tran vdout0_107ck1600 FIND v(dout0_107) AT=805.025n

.meas tran vdout0_108ck1600 FIND v(dout0_108) AT=805.025n

.meas tran vdout0_109ck1600 FIND v(dout0_109) AT=805.025n

.meas tran vdout0_110ck1600 FIND v(dout0_110) AT=805.025n

.meas tran vdout0_111ck1600 FIND v(dout0_111) AT=805.025n

.meas tran vdout0_112ck1600 FIND v(dout0_112) AT=805.025n

.meas tran vdout0_113ck1600 FIND v(dout0_113) AT=805.025n

.meas tran vdout0_114ck1600 FIND v(dout0_114) AT=805.025n

.meas tran vdout0_115ck1600 FIND v(dout0_115) AT=805.025n

.meas tran vdout0_116ck1600 FIND v(dout0_116) AT=805.025n

.meas tran vdout0_117ck1600 FIND v(dout0_117) AT=805.025n

.meas tran vdout0_118ck1600 FIND v(dout0_118) AT=805.025n

.meas tran vdout0_119ck1600 FIND v(dout0_119) AT=805.025n

.meas tran vdout0_120ck1600 FIND v(dout0_120) AT=805.025n

.meas tran vdout0_121ck1600 FIND v(dout0_121) AT=805.025n

.meas tran vdout0_122ck1600 FIND v(dout0_122) AT=805.025n

.meas tran vdout0_123ck1600 FIND v(dout0_123) AT=805.025n

.meas tran vdout0_124ck1600 FIND v(dout0_124) AT=805.025n

.meas tran vdout0_125ck1600 FIND v(dout0_125) AT=805.025n

.meas tran vdout0_126ck1600 FIND v(dout0_126) AT=805.025n

.meas tran vdout0_127ck1600 FIND v(dout0_127) AT=805.025n

.meas tran vdout0_128ck1600 FIND v(dout0_128) AT=805.025n

.meas tran vdout0_129ck1600 FIND v(dout0_129) AT=805.025n

.meas tran vdout0_130ck1600 FIND v(dout0_130) AT=805.025n

.meas tran vdout0_131ck1600 FIND v(dout0_131) AT=805.025n

.meas tran vdout0_132ck1600 FIND v(dout0_132) AT=805.025n

.meas tran vdout0_133ck1600 FIND v(dout0_133) AT=805.025n

.meas tran vdout0_134ck1600 FIND v(dout0_134) AT=805.025n

.meas tran vdout0_135ck1600 FIND v(dout0_135) AT=805.025n

.meas tran vdout0_136ck1600 FIND v(dout0_136) AT=805.025n

.meas tran vdout0_137ck1600 FIND v(dout0_137) AT=805.025n

.meas tran vdout0_138ck1600 FIND v(dout0_138) AT=805.025n

.meas tran vdout0_139ck1600 FIND v(dout0_139) AT=805.025n

.meas tran vdout0_140ck1600 FIND v(dout0_140) AT=805.025n

.meas tran vdout0_141ck1600 FIND v(dout0_141) AT=805.025n

.meas tran vdout0_142ck1600 FIND v(dout0_142) AT=805.025n

.meas tran vdout0_143ck1600 FIND v(dout0_143) AT=805.025n

.meas tran vdout0_144ck1600 FIND v(dout0_144) AT=805.025n

.meas tran vdout0_145ck1600 FIND v(dout0_145) AT=805.025n

.meas tran vdout0_146ck1600 FIND v(dout0_146) AT=805.025n

.meas tran vdout0_147ck1600 FIND v(dout0_147) AT=805.025n

.meas tran vdout0_148ck1600 FIND v(dout0_148) AT=805.025n

.meas tran vdout0_149ck1600 FIND v(dout0_149) AT=805.025n

.meas tran vdout0_0ck1610 FIND v(dout0_0) AT=810.025n

.meas tran vdout0_1ck1610 FIND v(dout0_1) AT=810.025n

.meas tran vdout0_2ck1610 FIND v(dout0_2) AT=810.025n

.meas tran vdout0_3ck1610 FIND v(dout0_3) AT=810.025n

.meas tran vdout0_4ck1610 FIND v(dout0_4) AT=810.025n

.meas tran vdout0_5ck1610 FIND v(dout0_5) AT=810.025n

.meas tran vdout0_6ck1610 FIND v(dout0_6) AT=810.025n

.meas tran vdout0_7ck1610 FIND v(dout0_7) AT=810.025n

.meas tran vdout0_8ck1610 FIND v(dout0_8) AT=810.025n

.meas tran vdout0_9ck1610 FIND v(dout0_9) AT=810.025n

.meas tran vdout0_10ck1610 FIND v(dout0_10) AT=810.025n

.meas tran vdout0_11ck1610 FIND v(dout0_11) AT=810.025n

.meas tran vdout0_12ck1610 FIND v(dout0_12) AT=810.025n

.meas tran vdout0_13ck1610 FIND v(dout0_13) AT=810.025n

.meas tran vdout0_14ck1610 FIND v(dout0_14) AT=810.025n

.meas tran vdout0_15ck1610 FIND v(dout0_15) AT=810.025n

.meas tran vdout0_16ck1610 FIND v(dout0_16) AT=810.025n

.meas tran vdout0_17ck1610 FIND v(dout0_17) AT=810.025n

.meas tran vdout0_18ck1610 FIND v(dout0_18) AT=810.025n

.meas tran vdout0_19ck1610 FIND v(dout0_19) AT=810.025n

.meas tran vdout0_20ck1610 FIND v(dout0_20) AT=810.025n

.meas tran vdout0_21ck1610 FIND v(dout0_21) AT=810.025n

.meas tran vdout0_22ck1610 FIND v(dout0_22) AT=810.025n

.meas tran vdout0_23ck1610 FIND v(dout0_23) AT=810.025n

.meas tran vdout0_24ck1610 FIND v(dout0_24) AT=810.025n

.meas tran vdout0_25ck1610 FIND v(dout0_25) AT=810.025n

.meas tran vdout0_26ck1610 FIND v(dout0_26) AT=810.025n

.meas tran vdout0_27ck1610 FIND v(dout0_27) AT=810.025n

.meas tran vdout0_28ck1610 FIND v(dout0_28) AT=810.025n

.meas tran vdout0_29ck1610 FIND v(dout0_29) AT=810.025n

.meas tran vdout0_30ck1610 FIND v(dout0_30) AT=810.025n

.meas tran vdout0_31ck1610 FIND v(dout0_31) AT=810.025n

.meas tran vdout0_32ck1610 FIND v(dout0_32) AT=810.025n

.meas tran vdout0_33ck1610 FIND v(dout0_33) AT=810.025n

.meas tran vdout0_34ck1610 FIND v(dout0_34) AT=810.025n

.meas tran vdout0_35ck1610 FIND v(dout0_35) AT=810.025n

.meas tran vdout0_36ck1610 FIND v(dout0_36) AT=810.025n

.meas tran vdout0_37ck1610 FIND v(dout0_37) AT=810.025n

.meas tran vdout0_38ck1610 FIND v(dout0_38) AT=810.025n

.meas tran vdout0_39ck1610 FIND v(dout0_39) AT=810.025n

.meas tran vdout0_40ck1610 FIND v(dout0_40) AT=810.025n

.meas tran vdout0_41ck1610 FIND v(dout0_41) AT=810.025n

.meas tran vdout0_42ck1610 FIND v(dout0_42) AT=810.025n

.meas tran vdout0_43ck1610 FIND v(dout0_43) AT=810.025n

.meas tran vdout0_44ck1610 FIND v(dout0_44) AT=810.025n

.meas tran vdout0_45ck1610 FIND v(dout0_45) AT=810.025n

.meas tran vdout0_46ck1610 FIND v(dout0_46) AT=810.025n

.meas tran vdout0_47ck1610 FIND v(dout0_47) AT=810.025n

.meas tran vdout0_48ck1610 FIND v(dout0_48) AT=810.025n

.meas tran vdout0_49ck1610 FIND v(dout0_49) AT=810.025n

.meas tran vdout0_50ck1610 FIND v(dout0_50) AT=810.025n

.meas tran vdout0_51ck1610 FIND v(dout0_51) AT=810.025n

.meas tran vdout0_52ck1610 FIND v(dout0_52) AT=810.025n

.meas tran vdout0_53ck1610 FIND v(dout0_53) AT=810.025n

.meas tran vdout0_54ck1610 FIND v(dout0_54) AT=810.025n

.meas tran vdout0_55ck1610 FIND v(dout0_55) AT=810.025n

.meas tran vdout0_56ck1610 FIND v(dout0_56) AT=810.025n

.meas tran vdout0_57ck1610 FIND v(dout0_57) AT=810.025n

.meas tran vdout0_58ck1610 FIND v(dout0_58) AT=810.025n

.meas tran vdout0_59ck1610 FIND v(dout0_59) AT=810.025n

.meas tran vdout0_60ck1610 FIND v(dout0_60) AT=810.025n

.meas tran vdout0_61ck1610 FIND v(dout0_61) AT=810.025n

.meas tran vdout0_62ck1610 FIND v(dout0_62) AT=810.025n

.meas tran vdout0_63ck1610 FIND v(dout0_63) AT=810.025n

.meas tran vdout0_64ck1610 FIND v(dout0_64) AT=810.025n

.meas tran vdout0_65ck1610 FIND v(dout0_65) AT=810.025n

.meas tran vdout0_66ck1610 FIND v(dout0_66) AT=810.025n

.meas tran vdout0_67ck1610 FIND v(dout0_67) AT=810.025n

.meas tran vdout0_68ck1610 FIND v(dout0_68) AT=810.025n

.meas tran vdout0_69ck1610 FIND v(dout0_69) AT=810.025n

.meas tran vdout0_70ck1610 FIND v(dout0_70) AT=810.025n

.meas tran vdout0_71ck1610 FIND v(dout0_71) AT=810.025n

.meas tran vdout0_72ck1610 FIND v(dout0_72) AT=810.025n

.meas tran vdout0_73ck1610 FIND v(dout0_73) AT=810.025n

.meas tran vdout0_74ck1610 FIND v(dout0_74) AT=810.025n

.meas tran vdout0_75ck1610 FIND v(dout0_75) AT=810.025n

.meas tran vdout0_76ck1610 FIND v(dout0_76) AT=810.025n

.meas tran vdout0_77ck1610 FIND v(dout0_77) AT=810.025n

.meas tran vdout0_78ck1610 FIND v(dout0_78) AT=810.025n

.meas tran vdout0_79ck1610 FIND v(dout0_79) AT=810.025n

.meas tran vdout0_80ck1610 FIND v(dout0_80) AT=810.025n

.meas tran vdout0_81ck1610 FIND v(dout0_81) AT=810.025n

.meas tran vdout0_82ck1610 FIND v(dout0_82) AT=810.025n

.meas tran vdout0_83ck1610 FIND v(dout0_83) AT=810.025n

.meas tran vdout0_84ck1610 FIND v(dout0_84) AT=810.025n

.meas tran vdout0_85ck1610 FIND v(dout0_85) AT=810.025n

.meas tran vdout0_86ck1610 FIND v(dout0_86) AT=810.025n

.meas tran vdout0_87ck1610 FIND v(dout0_87) AT=810.025n

.meas tran vdout0_88ck1610 FIND v(dout0_88) AT=810.025n

.meas tran vdout0_89ck1610 FIND v(dout0_89) AT=810.025n

.meas tran vdout0_90ck1610 FIND v(dout0_90) AT=810.025n

.meas tran vdout0_91ck1610 FIND v(dout0_91) AT=810.025n

.meas tran vdout0_92ck1610 FIND v(dout0_92) AT=810.025n

.meas tran vdout0_93ck1610 FIND v(dout0_93) AT=810.025n

.meas tran vdout0_94ck1610 FIND v(dout0_94) AT=810.025n

.meas tran vdout0_95ck1610 FIND v(dout0_95) AT=810.025n

.meas tran vdout0_96ck1610 FIND v(dout0_96) AT=810.025n

.meas tran vdout0_97ck1610 FIND v(dout0_97) AT=810.025n

.meas tran vdout0_98ck1610 FIND v(dout0_98) AT=810.025n

.meas tran vdout0_99ck1610 FIND v(dout0_99) AT=810.025n

.meas tran vdout0_100ck1610 FIND v(dout0_100) AT=810.025n

.meas tran vdout0_101ck1610 FIND v(dout0_101) AT=810.025n

.meas tran vdout0_102ck1610 FIND v(dout0_102) AT=810.025n

.meas tran vdout0_103ck1610 FIND v(dout0_103) AT=810.025n

.meas tran vdout0_104ck1610 FIND v(dout0_104) AT=810.025n

.meas tran vdout0_105ck1610 FIND v(dout0_105) AT=810.025n

.meas tran vdout0_106ck1610 FIND v(dout0_106) AT=810.025n

.meas tran vdout0_107ck1610 FIND v(dout0_107) AT=810.025n

.meas tran vdout0_108ck1610 FIND v(dout0_108) AT=810.025n

.meas tran vdout0_109ck1610 FIND v(dout0_109) AT=810.025n

.meas tran vdout0_110ck1610 FIND v(dout0_110) AT=810.025n

.meas tran vdout0_111ck1610 FIND v(dout0_111) AT=810.025n

.meas tran vdout0_112ck1610 FIND v(dout0_112) AT=810.025n

.meas tran vdout0_113ck1610 FIND v(dout0_113) AT=810.025n

.meas tran vdout0_114ck1610 FIND v(dout0_114) AT=810.025n

.meas tran vdout0_115ck1610 FIND v(dout0_115) AT=810.025n

.meas tran vdout0_116ck1610 FIND v(dout0_116) AT=810.025n

.meas tran vdout0_117ck1610 FIND v(dout0_117) AT=810.025n

.meas tran vdout0_118ck1610 FIND v(dout0_118) AT=810.025n

.meas tran vdout0_119ck1610 FIND v(dout0_119) AT=810.025n

.meas tran vdout0_120ck1610 FIND v(dout0_120) AT=810.025n

.meas tran vdout0_121ck1610 FIND v(dout0_121) AT=810.025n

.meas tran vdout0_122ck1610 FIND v(dout0_122) AT=810.025n

.meas tran vdout0_123ck1610 FIND v(dout0_123) AT=810.025n

.meas tran vdout0_124ck1610 FIND v(dout0_124) AT=810.025n

.meas tran vdout0_125ck1610 FIND v(dout0_125) AT=810.025n

.meas tran vdout0_126ck1610 FIND v(dout0_126) AT=810.025n

.meas tran vdout0_127ck1610 FIND v(dout0_127) AT=810.025n

.meas tran vdout0_128ck1610 FIND v(dout0_128) AT=810.025n

.meas tran vdout0_129ck1610 FIND v(dout0_129) AT=810.025n

.meas tran vdout0_130ck1610 FIND v(dout0_130) AT=810.025n

.meas tran vdout0_131ck1610 FIND v(dout0_131) AT=810.025n

.meas tran vdout0_132ck1610 FIND v(dout0_132) AT=810.025n

.meas tran vdout0_133ck1610 FIND v(dout0_133) AT=810.025n

.meas tran vdout0_134ck1610 FIND v(dout0_134) AT=810.025n

.meas tran vdout0_135ck1610 FIND v(dout0_135) AT=810.025n

.meas tran vdout0_136ck1610 FIND v(dout0_136) AT=810.025n

.meas tran vdout0_137ck1610 FIND v(dout0_137) AT=810.025n

.meas tran vdout0_138ck1610 FIND v(dout0_138) AT=810.025n

.meas tran vdout0_139ck1610 FIND v(dout0_139) AT=810.025n

.meas tran vdout0_140ck1610 FIND v(dout0_140) AT=810.025n

.meas tran vdout0_141ck1610 FIND v(dout0_141) AT=810.025n

.meas tran vdout0_142ck1610 FIND v(dout0_142) AT=810.025n

.meas tran vdout0_143ck1610 FIND v(dout0_143) AT=810.025n

.meas tran vdout0_144ck1610 FIND v(dout0_144) AT=810.025n

.meas tran vdout0_145ck1610 FIND v(dout0_145) AT=810.025n

.meas tran vdout0_146ck1610 FIND v(dout0_146) AT=810.025n

.meas tran vdout0_147ck1610 FIND v(dout0_147) AT=810.025n

.meas tran vdout0_148ck1610 FIND v(dout0_148) AT=810.025n

.meas tran vdout0_149ck1610 FIND v(dout0_149) AT=810.025n

.meas tran vdout0_0ck1630 FIND v(dout0_0) AT=820.025n

.meas tran vdout0_1ck1630 FIND v(dout0_1) AT=820.025n

.meas tran vdout0_2ck1630 FIND v(dout0_2) AT=820.025n

.meas tran vdout0_3ck1630 FIND v(dout0_3) AT=820.025n

.meas tran vdout0_4ck1630 FIND v(dout0_4) AT=820.025n

.meas tran vdout0_5ck1630 FIND v(dout0_5) AT=820.025n

.meas tran vdout0_6ck1630 FIND v(dout0_6) AT=820.025n

.meas tran vdout0_7ck1630 FIND v(dout0_7) AT=820.025n

.meas tran vdout0_8ck1630 FIND v(dout0_8) AT=820.025n

.meas tran vdout0_9ck1630 FIND v(dout0_9) AT=820.025n

.meas tran vdout0_10ck1630 FIND v(dout0_10) AT=820.025n

.meas tran vdout0_11ck1630 FIND v(dout0_11) AT=820.025n

.meas tran vdout0_12ck1630 FIND v(dout0_12) AT=820.025n

.meas tran vdout0_13ck1630 FIND v(dout0_13) AT=820.025n

.meas tran vdout0_14ck1630 FIND v(dout0_14) AT=820.025n

.meas tran vdout0_15ck1630 FIND v(dout0_15) AT=820.025n

.meas tran vdout0_16ck1630 FIND v(dout0_16) AT=820.025n

.meas tran vdout0_17ck1630 FIND v(dout0_17) AT=820.025n

.meas tran vdout0_18ck1630 FIND v(dout0_18) AT=820.025n

.meas tran vdout0_19ck1630 FIND v(dout0_19) AT=820.025n

.meas tran vdout0_20ck1630 FIND v(dout0_20) AT=820.025n

.meas tran vdout0_21ck1630 FIND v(dout0_21) AT=820.025n

.meas tran vdout0_22ck1630 FIND v(dout0_22) AT=820.025n

.meas tran vdout0_23ck1630 FIND v(dout0_23) AT=820.025n

.meas tran vdout0_24ck1630 FIND v(dout0_24) AT=820.025n

.meas tran vdout0_25ck1630 FIND v(dout0_25) AT=820.025n

.meas tran vdout0_26ck1630 FIND v(dout0_26) AT=820.025n

.meas tran vdout0_27ck1630 FIND v(dout0_27) AT=820.025n

.meas tran vdout0_28ck1630 FIND v(dout0_28) AT=820.025n

.meas tran vdout0_29ck1630 FIND v(dout0_29) AT=820.025n

.meas tran vdout0_30ck1630 FIND v(dout0_30) AT=820.025n

.meas tran vdout0_31ck1630 FIND v(dout0_31) AT=820.025n

.meas tran vdout0_32ck1630 FIND v(dout0_32) AT=820.025n

.meas tran vdout0_33ck1630 FIND v(dout0_33) AT=820.025n

.meas tran vdout0_34ck1630 FIND v(dout0_34) AT=820.025n

.meas tran vdout0_35ck1630 FIND v(dout0_35) AT=820.025n

.meas tran vdout0_36ck1630 FIND v(dout0_36) AT=820.025n

.meas tran vdout0_37ck1630 FIND v(dout0_37) AT=820.025n

.meas tran vdout0_38ck1630 FIND v(dout0_38) AT=820.025n

.meas tran vdout0_39ck1630 FIND v(dout0_39) AT=820.025n

.meas tran vdout0_40ck1630 FIND v(dout0_40) AT=820.025n

.meas tran vdout0_41ck1630 FIND v(dout0_41) AT=820.025n

.meas tran vdout0_42ck1630 FIND v(dout0_42) AT=820.025n

.meas tran vdout0_43ck1630 FIND v(dout0_43) AT=820.025n

.meas tran vdout0_44ck1630 FIND v(dout0_44) AT=820.025n

.meas tran vdout0_45ck1630 FIND v(dout0_45) AT=820.025n

.meas tran vdout0_46ck1630 FIND v(dout0_46) AT=820.025n

.meas tran vdout0_47ck1630 FIND v(dout0_47) AT=820.025n

.meas tran vdout0_48ck1630 FIND v(dout0_48) AT=820.025n

.meas tran vdout0_49ck1630 FIND v(dout0_49) AT=820.025n

.meas tran vdout0_50ck1630 FIND v(dout0_50) AT=820.025n

.meas tran vdout0_51ck1630 FIND v(dout0_51) AT=820.025n

.meas tran vdout0_52ck1630 FIND v(dout0_52) AT=820.025n

.meas tran vdout0_53ck1630 FIND v(dout0_53) AT=820.025n

.meas tran vdout0_54ck1630 FIND v(dout0_54) AT=820.025n

.meas tran vdout0_55ck1630 FIND v(dout0_55) AT=820.025n

.meas tran vdout0_56ck1630 FIND v(dout0_56) AT=820.025n

.meas tran vdout0_57ck1630 FIND v(dout0_57) AT=820.025n

.meas tran vdout0_58ck1630 FIND v(dout0_58) AT=820.025n

.meas tran vdout0_59ck1630 FIND v(dout0_59) AT=820.025n

.meas tran vdout0_60ck1630 FIND v(dout0_60) AT=820.025n

.meas tran vdout0_61ck1630 FIND v(dout0_61) AT=820.025n

.meas tran vdout0_62ck1630 FIND v(dout0_62) AT=820.025n

.meas tran vdout0_63ck1630 FIND v(dout0_63) AT=820.025n

.meas tran vdout0_64ck1630 FIND v(dout0_64) AT=820.025n

.meas tran vdout0_65ck1630 FIND v(dout0_65) AT=820.025n

.meas tran vdout0_66ck1630 FIND v(dout0_66) AT=820.025n

.meas tran vdout0_67ck1630 FIND v(dout0_67) AT=820.025n

.meas tran vdout0_68ck1630 FIND v(dout0_68) AT=820.025n

.meas tran vdout0_69ck1630 FIND v(dout0_69) AT=820.025n

.meas tran vdout0_70ck1630 FIND v(dout0_70) AT=820.025n

.meas tran vdout0_71ck1630 FIND v(dout0_71) AT=820.025n

.meas tran vdout0_72ck1630 FIND v(dout0_72) AT=820.025n

.meas tran vdout0_73ck1630 FIND v(dout0_73) AT=820.025n

.meas tran vdout0_74ck1630 FIND v(dout0_74) AT=820.025n

.meas tran vdout0_75ck1630 FIND v(dout0_75) AT=820.025n

.meas tran vdout0_76ck1630 FIND v(dout0_76) AT=820.025n

.meas tran vdout0_77ck1630 FIND v(dout0_77) AT=820.025n

.meas tran vdout0_78ck1630 FIND v(dout0_78) AT=820.025n

.meas tran vdout0_79ck1630 FIND v(dout0_79) AT=820.025n

.meas tran vdout0_80ck1630 FIND v(dout0_80) AT=820.025n

.meas tran vdout0_81ck1630 FIND v(dout0_81) AT=820.025n

.meas tran vdout0_82ck1630 FIND v(dout0_82) AT=820.025n

.meas tran vdout0_83ck1630 FIND v(dout0_83) AT=820.025n

.meas tran vdout0_84ck1630 FIND v(dout0_84) AT=820.025n

.meas tran vdout0_85ck1630 FIND v(dout0_85) AT=820.025n

.meas tran vdout0_86ck1630 FIND v(dout0_86) AT=820.025n

.meas tran vdout0_87ck1630 FIND v(dout0_87) AT=820.025n

.meas tran vdout0_88ck1630 FIND v(dout0_88) AT=820.025n

.meas tran vdout0_89ck1630 FIND v(dout0_89) AT=820.025n

.meas tran vdout0_90ck1630 FIND v(dout0_90) AT=820.025n

.meas tran vdout0_91ck1630 FIND v(dout0_91) AT=820.025n

.meas tran vdout0_92ck1630 FIND v(dout0_92) AT=820.025n

.meas tran vdout0_93ck1630 FIND v(dout0_93) AT=820.025n

.meas tran vdout0_94ck1630 FIND v(dout0_94) AT=820.025n

.meas tran vdout0_95ck1630 FIND v(dout0_95) AT=820.025n

.meas tran vdout0_96ck1630 FIND v(dout0_96) AT=820.025n

.meas tran vdout0_97ck1630 FIND v(dout0_97) AT=820.025n

.meas tran vdout0_98ck1630 FIND v(dout0_98) AT=820.025n

.meas tran vdout0_99ck1630 FIND v(dout0_99) AT=820.025n

.meas tran vdout0_100ck1630 FIND v(dout0_100) AT=820.025n

.meas tran vdout0_101ck1630 FIND v(dout0_101) AT=820.025n

.meas tran vdout0_102ck1630 FIND v(dout0_102) AT=820.025n

.meas tran vdout0_103ck1630 FIND v(dout0_103) AT=820.025n

.meas tran vdout0_104ck1630 FIND v(dout0_104) AT=820.025n

.meas tran vdout0_105ck1630 FIND v(dout0_105) AT=820.025n

.meas tran vdout0_106ck1630 FIND v(dout0_106) AT=820.025n

.meas tran vdout0_107ck1630 FIND v(dout0_107) AT=820.025n

.meas tran vdout0_108ck1630 FIND v(dout0_108) AT=820.025n

.meas tran vdout0_109ck1630 FIND v(dout0_109) AT=820.025n

.meas tran vdout0_110ck1630 FIND v(dout0_110) AT=820.025n

.meas tran vdout0_111ck1630 FIND v(dout0_111) AT=820.025n

.meas tran vdout0_112ck1630 FIND v(dout0_112) AT=820.025n

.meas tran vdout0_113ck1630 FIND v(dout0_113) AT=820.025n

.meas tran vdout0_114ck1630 FIND v(dout0_114) AT=820.025n

.meas tran vdout0_115ck1630 FIND v(dout0_115) AT=820.025n

.meas tran vdout0_116ck1630 FIND v(dout0_116) AT=820.025n

.meas tran vdout0_117ck1630 FIND v(dout0_117) AT=820.025n

.meas tran vdout0_118ck1630 FIND v(dout0_118) AT=820.025n

.meas tran vdout0_119ck1630 FIND v(dout0_119) AT=820.025n

.meas tran vdout0_120ck1630 FIND v(dout0_120) AT=820.025n

.meas tran vdout0_121ck1630 FIND v(dout0_121) AT=820.025n

.meas tran vdout0_122ck1630 FIND v(dout0_122) AT=820.025n

.meas tran vdout0_123ck1630 FIND v(dout0_123) AT=820.025n

.meas tran vdout0_124ck1630 FIND v(dout0_124) AT=820.025n

.meas tran vdout0_125ck1630 FIND v(dout0_125) AT=820.025n

.meas tran vdout0_126ck1630 FIND v(dout0_126) AT=820.025n

.meas tran vdout0_127ck1630 FIND v(dout0_127) AT=820.025n

.meas tran vdout0_128ck1630 FIND v(dout0_128) AT=820.025n

.meas tran vdout0_129ck1630 FIND v(dout0_129) AT=820.025n

.meas tran vdout0_130ck1630 FIND v(dout0_130) AT=820.025n

.meas tran vdout0_131ck1630 FIND v(dout0_131) AT=820.025n

.meas tran vdout0_132ck1630 FIND v(dout0_132) AT=820.025n

.meas tran vdout0_133ck1630 FIND v(dout0_133) AT=820.025n

.meas tran vdout0_134ck1630 FIND v(dout0_134) AT=820.025n

.meas tran vdout0_135ck1630 FIND v(dout0_135) AT=820.025n

.meas tran vdout0_136ck1630 FIND v(dout0_136) AT=820.025n

.meas tran vdout0_137ck1630 FIND v(dout0_137) AT=820.025n

.meas tran vdout0_138ck1630 FIND v(dout0_138) AT=820.025n

.meas tran vdout0_139ck1630 FIND v(dout0_139) AT=820.025n

.meas tran vdout0_140ck1630 FIND v(dout0_140) AT=820.025n

.meas tran vdout0_141ck1630 FIND v(dout0_141) AT=820.025n

.meas tran vdout0_142ck1630 FIND v(dout0_142) AT=820.025n

.meas tran vdout0_143ck1630 FIND v(dout0_143) AT=820.025n

.meas tran vdout0_144ck1630 FIND v(dout0_144) AT=820.025n

.meas tran vdout0_145ck1630 FIND v(dout0_145) AT=820.025n

.meas tran vdout0_146ck1630 FIND v(dout0_146) AT=820.025n

.meas tran vdout0_147ck1630 FIND v(dout0_147) AT=820.025n

.meas tran vdout0_148ck1630 FIND v(dout0_148) AT=820.025n

.meas tran vdout0_149ck1630 FIND v(dout0_149) AT=820.025n

.meas tran vdout0_0ck1640 FIND v(dout0_0) AT=825.025n

.meas tran vdout0_1ck1640 FIND v(dout0_1) AT=825.025n

.meas tran vdout0_2ck1640 FIND v(dout0_2) AT=825.025n

.meas tran vdout0_3ck1640 FIND v(dout0_3) AT=825.025n

.meas tran vdout0_4ck1640 FIND v(dout0_4) AT=825.025n

.meas tran vdout0_5ck1640 FIND v(dout0_5) AT=825.025n

.meas tran vdout0_6ck1640 FIND v(dout0_6) AT=825.025n

.meas tran vdout0_7ck1640 FIND v(dout0_7) AT=825.025n

.meas tran vdout0_8ck1640 FIND v(dout0_8) AT=825.025n

.meas tran vdout0_9ck1640 FIND v(dout0_9) AT=825.025n

.meas tran vdout0_10ck1640 FIND v(dout0_10) AT=825.025n

.meas tran vdout0_11ck1640 FIND v(dout0_11) AT=825.025n

.meas tran vdout0_12ck1640 FIND v(dout0_12) AT=825.025n

.meas tran vdout0_13ck1640 FIND v(dout0_13) AT=825.025n

.meas tran vdout0_14ck1640 FIND v(dout0_14) AT=825.025n

.meas tran vdout0_15ck1640 FIND v(dout0_15) AT=825.025n

.meas tran vdout0_16ck1640 FIND v(dout0_16) AT=825.025n

.meas tran vdout0_17ck1640 FIND v(dout0_17) AT=825.025n

.meas tran vdout0_18ck1640 FIND v(dout0_18) AT=825.025n

.meas tran vdout0_19ck1640 FIND v(dout0_19) AT=825.025n

.meas tran vdout0_20ck1640 FIND v(dout0_20) AT=825.025n

.meas tran vdout0_21ck1640 FIND v(dout0_21) AT=825.025n

.meas tran vdout0_22ck1640 FIND v(dout0_22) AT=825.025n

.meas tran vdout0_23ck1640 FIND v(dout0_23) AT=825.025n

.meas tran vdout0_24ck1640 FIND v(dout0_24) AT=825.025n

.meas tran vdout0_25ck1640 FIND v(dout0_25) AT=825.025n

.meas tran vdout0_26ck1640 FIND v(dout0_26) AT=825.025n

.meas tran vdout0_27ck1640 FIND v(dout0_27) AT=825.025n

.meas tran vdout0_28ck1640 FIND v(dout0_28) AT=825.025n

.meas tran vdout0_29ck1640 FIND v(dout0_29) AT=825.025n

.meas tran vdout0_30ck1640 FIND v(dout0_30) AT=825.025n

.meas tran vdout0_31ck1640 FIND v(dout0_31) AT=825.025n

.meas tran vdout0_32ck1640 FIND v(dout0_32) AT=825.025n

.meas tran vdout0_33ck1640 FIND v(dout0_33) AT=825.025n

.meas tran vdout0_34ck1640 FIND v(dout0_34) AT=825.025n

.meas tran vdout0_35ck1640 FIND v(dout0_35) AT=825.025n

.meas tran vdout0_36ck1640 FIND v(dout0_36) AT=825.025n

.meas tran vdout0_37ck1640 FIND v(dout0_37) AT=825.025n

.meas tran vdout0_38ck1640 FIND v(dout0_38) AT=825.025n

.meas tran vdout0_39ck1640 FIND v(dout0_39) AT=825.025n

.meas tran vdout0_40ck1640 FIND v(dout0_40) AT=825.025n

.meas tran vdout0_41ck1640 FIND v(dout0_41) AT=825.025n

.meas tran vdout0_42ck1640 FIND v(dout0_42) AT=825.025n

.meas tran vdout0_43ck1640 FIND v(dout0_43) AT=825.025n

.meas tran vdout0_44ck1640 FIND v(dout0_44) AT=825.025n

.meas tran vdout0_45ck1640 FIND v(dout0_45) AT=825.025n

.meas tran vdout0_46ck1640 FIND v(dout0_46) AT=825.025n

.meas tran vdout0_47ck1640 FIND v(dout0_47) AT=825.025n

.meas tran vdout0_48ck1640 FIND v(dout0_48) AT=825.025n

.meas tran vdout0_49ck1640 FIND v(dout0_49) AT=825.025n

.meas tran vdout0_50ck1640 FIND v(dout0_50) AT=825.025n

.meas tran vdout0_51ck1640 FIND v(dout0_51) AT=825.025n

.meas tran vdout0_52ck1640 FIND v(dout0_52) AT=825.025n

.meas tran vdout0_53ck1640 FIND v(dout0_53) AT=825.025n

.meas tran vdout0_54ck1640 FIND v(dout0_54) AT=825.025n

.meas tran vdout0_55ck1640 FIND v(dout0_55) AT=825.025n

.meas tran vdout0_56ck1640 FIND v(dout0_56) AT=825.025n

.meas tran vdout0_57ck1640 FIND v(dout0_57) AT=825.025n

.meas tran vdout0_58ck1640 FIND v(dout0_58) AT=825.025n

.meas tran vdout0_59ck1640 FIND v(dout0_59) AT=825.025n

.meas tran vdout0_60ck1640 FIND v(dout0_60) AT=825.025n

.meas tran vdout0_61ck1640 FIND v(dout0_61) AT=825.025n

.meas tran vdout0_62ck1640 FIND v(dout0_62) AT=825.025n

.meas tran vdout0_63ck1640 FIND v(dout0_63) AT=825.025n

.meas tran vdout0_64ck1640 FIND v(dout0_64) AT=825.025n

.meas tran vdout0_65ck1640 FIND v(dout0_65) AT=825.025n

.meas tran vdout0_66ck1640 FIND v(dout0_66) AT=825.025n

.meas tran vdout0_67ck1640 FIND v(dout0_67) AT=825.025n

.meas tran vdout0_68ck1640 FIND v(dout0_68) AT=825.025n

.meas tran vdout0_69ck1640 FIND v(dout0_69) AT=825.025n

.meas tran vdout0_70ck1640 FIND v(dout0_70) AT=825.025n

.meas tran vdout0_71ck1640 FIND v(dout0_71) AT=825.025n

.meas tran vdout0_72ck1640 FIND v(dout0_72) AT=825.025n

.meas tran vdout0_73ck1640 FIND v(dout0_73) AT=825.025n

.meas tran vdout0_74ck1640 FIND v(dout0_74) AT=825.025n

.meas tran vdout0_75ck1640 FIND v(dout0_75) AT=825.025n

.meas tran vdout0_76ck1640 FIND v(dout0_76) AT=825.025n

.meas tran vdout0_77ck1640 FIND v(dout0_77) AT=825.025n

.meas tran vdout0_78ck1640 FIND v(dout0_78) AT=825.025n

.meas tran vdout0_79ck1640 FIND v(dout0_79) AT=825.025n

.meas tran vdout0_80ck1640 FIND v(dout0_80) AT=825.025n

.meas tran vdout0_81ck1640 FIND v(dout0_81) AT=825.025n

.meas tran vdout0_82ck1640 FIND v(dout0_82) AT=825.025n

.meas tran vdout0_83ck1640 FIND v(dout0_83) AT=825.025n

.meas tran vdout0_84ck1640 FIND v(dout0_84) AT=825.025n

.meas tran vdout0_85ck1640 FIND v(dout0_85) AT=825.025n

.meas tran vdout0_86ck1640 FIND v(dout0_86) AT=825.025n

.meas tran vdout0_87ck1640 FIND v(dout0_87) AT=825.025n

.meas tran vdout0_88ck1640 FIND v(dout0_88) AT=825.025n

.meas tran vdout0_89ck1640 FIND v(dout0_89) AT=825.025n

.meas tran vdout0_90ck1640 FIND v(dout0_90) AT=825.025n

.meas tran vdout0_91ck1640 FIND v(dout0_91) AT=825.025n

.meas tran vdout0_92ck1640 FIND v(dout0_92) AT=825.025n

.meas tran vdout0_93ck1640 FIND v(dout0_93) AT=825.025n

.meas tran vdout0_94ck1640 FIND v(dout0_94) AT=825.025n

.meas tran vdout0_95ck1640 FIND v(dout0_95) AT=825.025n

.meas tran vdout0_96ck1640 FIND v(dout0_96) AT=825.025n

.meas tran vdout0_97ck1640 FIND v(dout0_97) AT=825.025n

.meas tran vdout0_98ck1640 FIND v(dout0_98) AT=825.025n

.meas tran vdout0_99ck1640 FIND v(dout0_99) AT=825.025n

.meas tran vdout0_100ck1640 FIND v(dout0_100) AT=825.025n

.meas tran vdout0_101ck1640 FIND v(dout0_101) AT=825.025n

.meas tran vdout0_102ck1640 FIND v(dout0_102) AT=825.025n

.meas tran vdout0_103ck1640 FIND v(dout0_103) AT=825.025n

.meas tran vdout0_104ck1640 FIND v(dout0_104) AT=825.025n

.meas tran vdout0_105ck1640 FIND v(dout0_105) AT=825.025n

.meas tran vdout0_106ck1640 FIND v(dout0_106) AT=825.025n

.meas tran vdout0_107ck1640 FIND v(dout0_107) AT=825.025n

.meas tran vdout0_108ck1640 FIND v(dout0_108) AT=825.025n

.meas tran vdout0_109ck1640 FIND v(dout0_109) AT=825.025n

.meas tran vdout0_110ck1640 FIND v(dout0_110) AT=825.025n

.meas tran vdout0_111ck1640 FIND v(dout0_111) AT=825.025n

.meas tran vdout0_112ck1640 FIND v(dout0_112) AT=825.025n

.meas tran vdout0_113ck1640 FIND v(dout0_113) AT=825.025n

.meas tran vdout0_114ck1640 FIND v(dout0_114) AT=825.025n

.meas tran vdout0_115ck1640 FIND v(dout0_115) AT=825.025n

.meas tran vdout0_116ck1640 FIND v(dout0_116) AT=825.025n

.meas tran vdout0_117ck1640 FIND v(dout0_117) AT=825.025n

.meas tran vdout0_118ck1640 FIND v(dout0_118) AT=825.025n

.meas tran vdout0_119ck1640 FIND v(dout0_119) AT=825.025n

.meas tran vdout0_120ck1640 FIND v(dout0_120) AT=825.025n

.meas tran vdout0_121ck1640 FIND v(dout0_121) AT=825.025n

.meas tran vdout0_122ck1640 FIND v(dout0_122) AT=825.025n

.meas tran vdout0_123ck1640 FIND v(dout0_123) AT=825.025n

.meas tran vdout0_124ck1640 FIND v(dout0_124) AT=825.025n

.meas tran vdout0_125ck1640 FIND v(dout0_125) AT=825.025n

.meas tran vdout0_126ck1640 FIND v(dout0_126) AT=825.025n

.meas tran vdout0_127ck1640 FIND v(dout0_127) AT=825.025n

.meas tran vdout0_128ck1640 FIND v(dout0_128) AT=825.025n

.meas tran vdout0_129ck1640 FIND v(dout0_129) AT=825.025n

.meas tran vdout0_130ck1640 FIND v(dout0_130) AT=825.025n

.meas tran vdout0_131ck1640 FIND v(dout0_131) AT=825.025n

.meas tran vdout0_132ck1640 FIND v(dout0_132) AT=825.025n

.meas tran vdout0_133ck1640 FIND v(dout0_133) AT=825.025n

.meas tran vdout0_134ck1640 FIND v(dout0_134) AT=825.025n

.meas tran vdout0_135ck1640 FIND v(dout0_135) AT=825.025n

.meas tran vdout0_136ck1640 FIND v(dout0_136) AT=825.025n

.meas tran vdout0_137ck1640 FIND v(dout0_137) AT=825.025n

.meas tran vdout0_138ck1640 FIND v(dout0_138) AT=825.025n

.meas tran vdout0_139ck1640 FIND v(dout0_139) AT=825.025n

.meas tran vdout0_140ck1640 FIND v(dout0_140) AT=825.025n

.meas tran vdout0_141ck1640 FIND v(dout0_141) AT=825.025n

.meas tran vdout0_142ck1640 FIND v(dout0_142) AT=825.025n

.meas tran vdout0_143ck1640 FIND v(dout0_143) AT=825.025n

.meas tran vdout0_144ck1640 FIND v(dout0_144) AT=825.025n

.meas tran vdout0_145ck1640 FIND v(dout0_145) AT=825.025n

.meas tran vdout0_146ck1640 FIND v(dout0_146) AT=825.025n

.meas tran vdout0_147ck1640 FIND v(dout0_147) AT=825.025n

.meas tran vdout0_148ck1640 FIND v(dout0_148) AT=825.025n

.meas tran vdout0_149ck1640 FIND v(dout0_149) AT=825.025n

.meas tran vdout0_0ck1650 FIND v(dout0_0) AT=830.025n

.meas tran vdout0_1ck1650 FIND v(dout0_1) AT=830.025n

.meas tran vdout0_2ck1650 FIND v(dout0_2) AT=830.025n

.meas tran vdout0_3ck1650 FIND v(dout0_3) AT=830.025n

.meas tran vdout0_4ck1650 FIND v(dout0_4) AT=830.025n

.meas tran vdout0_5ck1650 FIND v(dout0_5) AT=830.025n

.meas tran vdout0_6ck1650 FIND v(dout0_6) AT=830.025n

.meas tran vdout0_7ck1650 FIND v(dout0_7) AT=830.025n

.meas tran vdout0_8ck1650 FIND v(dout0_8) AT=830.025n

.meas tran vdout0_9ck1650 FIND v(dout0_9) AT=830.025n

.meas tran vdout0_10ck1650 FIND v(dout0_10) AT=830.025n

.meas tran vdout0_11ck1650 FIND v(dout0_11) AT=830.025n

.meas tran vdout0_12ck1650 FIND v(dout0_12) AT=830.025n

.meas tran vdout0_13ck1650 FIND v(dout0_13) AT=830.025n

.meas tran vdout0_14ck1650 FIND v(dout0_14) AT=830.025n

.meas tran vdout0_15ck1650 FIND v(dout0_15) AT=830.025n

.meas tran vdout0_16ck1650 FIND v(dout0_16) AT=830.025n

.meas tran vdout0_17ck1650 FIND v(dout0_17) AT=830.025n

.meas tran vdout0_18ck1650 FIND v(dout0_18) AT=830.025n

.meas tran vdout0_19ck1650 FIND v(dout0_19) AT=830.025n

.meas tran vdout0_20ck1650 FIND v(dout0_20) AT=830.025n

.meas tran vdout0_21ck1650 FIND v(dout0_21) AT=830.025n

.meas tran vdout0_22ck1650 FIND v(dout0_22) AT=830.025n

.meas tran vdout0_23ck1650 FIND v(dout0_23) AT=830.025n

.meas tran vdout0_24ck1650 FIND v(dout0_24) AT=830.025n

.meas tran vdout0_25ck1650 FIND v(dout0_25) AT=830.025n

.meas tran vdout0_26ck1650 FIND v(dout0_26) AT=830.025n

.meas tran vdout0_27ck1650 FIND v(dout0_27) AT=830.025n

.meas tran vdout0_28ck1650 FIND v(dout0_28) AT=830.025n

.meas tran vdout0_29ck1650 FIND v(dout0_29) AT=830.025n

.meas tran vdout0_30ck1650 FIND v(dout0_30) AT=830.025n

.meas tran vdout0_31ck1650 FIND v(dout0_31) AT=830.025n

.meas tran vdout0_32ck1650 FIND v(dout0_32) AT=830.025n

.meas tran vdout0_33ck1650 FIND v(dout0_33) AT=830.025n

.meas tran vdout0_34ck1650 FIND v(dout0_34) AT=830.025n

.meas tran vdout0_35ck1650 FIND v(dout0_35) AT=830.025n

.meas tran vdout0_36ck1650 FIND v(dout0_36) AT=830.025n

.meas tran vdout0_37ck1650 FIND v(dout0_37) AT=830.025n

.meas tran vdout0_38ck1650 FIND v(dout0_38) AT=830.025n

.meas tran vdout0_39ck1650 FIND v(dout0_39) AT=830.025n

.meas tran vdout0_40ck1650 FIND v(dout0_40) AT=830.025n

.meas tran vdout0_41ck1650 FIND v(dout0_41) AT=830.025n

.meas tran vdout0_42ck1650 FIND v(dout0_42) AT=830.025n

.meas tran vdout0_43ck1650 FIND v(dout0_43) AT=830.025n

.meas tran vdout0_44ck1650 FIND v(dout0_44) AT=830.025n

.meas tran vdout0_45ck1650 FIND v(dout0_45) AT=830.025n

.meas tran vdout0_46ck1650 FIND v(dout0_46) AT=830.025n

.meas tran vdout0_47ck1650 FIND v(dout0_47) AT=830.025n

.meas tran vdout0_48ck1650 FIND v(dout0_48) AT=830.025n

.meas tran vdout0_49ck1650 FIND v(dout0_49) AT=830.025n

.meas tran vdout0_50ck1650 FIND v(dout0_50) AT=830.025n

.meas tran vdout0_51ck1650 FIND v(dout0_51) AT=830.025n

.meas tran vdout0_52ck1650 FIND v(dout0_52) AT=830.025n

.meas tran vdout0_53ck1650 FIND v(dout0_53) AT=830.025n

.meas tran vdout0_54ck1650 FIND v(dout0_54) AT=830.025n

.meas tran vdout0_55ck1650 FIND v(dout0_55) AT=830.025n

.meas tran vdout0_56ck1650 FIND v(dout0_56) AT=830.025n

.meas tran vdout0_57ck1650 FIND v(dout0_57) AT=830.025n

.meas tran vdout0_58ck1650 FIND v(dout0_58) AT=830.025n

.meas tran vdout0_59ck1650 FIND v(dout0_59) AT=830.025n

.meas tran vdout0_60ck1650 FIND v(dout0_60) AT=830.025n

.meas tran vdout0_61ck1650 FIND v(dout0_61) AT=830.025n

.meas tran vdout0_62ck1650 FIND v(dout0_62) AT=830.025n

.meas tran vdout0_63ck1650 FIND v(dout0_63) AT=830.025n

.meas tran vdout0_64ck1650 FIND v(dout0_64) AT=830.025n

.meas tran vdout0_65ck1650 FIND v(dout0_65) AT=830.025n

.meas tran vdout0_66ck1650 FIND v(dout0_66) AT=830.025n

.meas tran vdout0_67ck1650 FIND v(dout0_67) AT=830.025n

.meas tran vdout0_68ck1650 FIND v(dout0_68) AT=830.025n

.meas tran vdout0_69ck1650 FIND v(dout0_69) AT=830.025n

.meas tran vdout0_70ck1650 FIND v(dout0_70) AT=830.025n

.meas tran vdout0_71ck1650 FIND v(dout0_71) AT=830.025n

.meas tran vdout0_72ck1650 FIND v(dout0_72) AT=830.025n

.meas tran vdout0_73ck1650 FIND v(dout0_73) AT=830.025n

.meas tran vdout0_74ck1650 FIND v(dout0_74) AT=830.025n

.meas tran vdout0_75ck1650 FIND v(dout0_75) AT=830.025n

.meas tran vdout0_76ck1650 FIND v(dout0_76) AT=830.025n

.meas tran vdout0_77ck1650 FIND v(dout0_77) AT=830.025n

.meas tran vdout0_78ck1650 FIND v(dout0_78) AT=830.025n

.meas tran vdout0_79ck1650 FIND v(dout0_79) AT=830.025n

.meas tran vdout0_80ck1650 FIND v(dout0_80) AT=830.025n

.meas tran vdout0_81ck1650 FIND v(dout0_81) AT=830.025n

.meas tran vdout0_82ck1650 FIND v(dout0_82) AT=830.025n

.meas tran vdout0_83ck1650 FIND v(dout0_83) AT=830.025n

.meas tran vdout0_84ck1650 FIND v(dout0_84) AT=830.025n

.meas tran vdout0_85ck1650 FIND v(dout0_85) AT=830.025n

.meas tran vdout0_86ck1650 FIND v(dout0_86) AT=830.025n

.meas tran vdout0_87ck1650 FIND v(dout0_87) AT=830.025n

.meas tran vdout0_88ck1650 FIND v(dout0_88) AT=830.025n

.meas tran vdout0_89ck1650 FIND v(dout0_89) AT=830.025n

.meas tran vdout0_90ck1650 FIND v(dout0_90) AT=830.025n

.meas tran vdout0_91ck1650 FIND v(dout0_91) AT=830.025n

.meas tran vdout0_92ck1650 FIND v(dout0_92) AT=830.025n

.meas tran vdout0_93ck1650 FIND v(dout0_93) AT=830.025n

.meas tran vdout0_94ck1650 FIND v(dout0_94) AT=830.025n

.meas tran vdout0_95ck1650 FIND v(dout0_95) AT=830.025n

.meas tran vdout0_96ck1650 FIND v(dout0_96) AT=830.025n

.meas tran vdout0_97ck1650 FIND v(dout0_97) AT=830.025n

.meas tran vdout0_98ck1650 FIND v(dout0_98) AT=830.025n

.meas tran vdout0_99ck1650 FIND v(dout0_99) AT=830.025n

.meas tran vdout0_100ck1650 FIND v(dout0_100) AT=830.025n

.meas tran vdout0_101ck1650 FIND v(dout0_101) AT=830.025n

.meas tran vdout0_102ck1650 FIND v(dout0_102) AT=830.025n

.meas tran vdout0_103ck1650 FIND v(dout0_103) AT=830.025n

.meas tran vdout0_104ck1650 FIND v(dout0_104) AT=830.025n

.meas tran vdout0_105ck1650 FIND v(dout0_105) AT=830.025n

.meas tran vdout0_106ck1650 FIND v(dout0_106) AT=830.025n

.meas tran vdout0_107ck1650 FIND v(dout0_107) AT=830.025n

.meas tran vdout0_108ck1650 FIND v(dout0_108) AT=830.025n

.meas tran vdout0_109ck1650 FIND v(dout0_109) AT=830.025n

.meas tran vdout0_110ck1650 FIND v(dout0_110) AT=830.025n

.meas tran vdout0_111ck1650 FIND v(dout0_111) AT=830.025n

.meas tran vdout0_112ck1650 FIND v(dout0_112) AT=830.025n

.meas tran vdout0_113ck1650 FIND v(dout0_113) AT=830.025n

.meas tran vdout0_114ck1650 FIND v(dout0_114) AT=830.025n

.meas tran vdout0_115ck1650 FIND v(dout0_115) AT=830.025n

.meas tran vdout0_116ck1650 FIND v(dout0_116) AT=830.025n

.meas tran vdout0_117ck1650 FIND v(dout0_117) AT=830.025n

.meas tran vdout0_118ck1650 FIND v(dout0_118) AT=830.025n

.meas tran vdout0_119ck1650 FIND v(dout0_119) AT=830.025n

.meas tran vdout0_120ck1650 FIND v(dout0_120) AT=830.025n

.meas tran vdout0_121ck1650 FIND v(dout0_121) AT=830.025n

.meas tran vdout0_122ck1650 FIND v(dout0_122) AT=830.025n

.meas tran vdout0_123ck1650 FIND v(dout0_123) AT=830.025n

.meas tran vdout0_124ck1650 FIND v(dout0_124) AT=830.025n

.meas tran vdout0_125ck1650 FIND v(dout0_125) AT=830.025n

.meas tran vdout0_126ck1650 FIND v(dout0_126) AT=830.025n

.meas tran vdout0_127ck1650 FIND v(dout0_127) AT=830.025n

.meas tran vdout0_128ck1650 FIND v(dout0_128) AT=830.025n

.meas tran vdout0_129ck1650 FIND v(dout0_129) AT=830.025n

.meas tran vdout0_130ck1650 FIND v(dout0_130) AT=830.025n

.meas tran vdout0_131ck1650 FIND v(dout0_131) AT=830.025n

.meas tran vdout0_132ck1650 FIND v(dout0_132) AT=830.025n

.meas tran vdout0_133ck1650 FIND v(dout0_133) AT=830.025n

.meas tran vdout0_134ck1650 FIND v(dout0_134) AT=830.025n

.meas tran vdout0_135ck1650 FIND v(dout0_135) AT=830.025n

.meas tran vdout0_136ck1650 FIND v(dout0_136) AT=830.025n

.meas tran vdout0_137ck1650 FIND v(dout0_137) AT=830.025n

.meas tran vdout0_138ck1650 FIND v(dout0_138) AT=830.025n

.meas tran vdout0_139ck1650 FIND v(dout0_139) AT=830.025n

.meas tran vdout0_140ck1650 FIND v(dout0_140) AT=830.025n

.meas tran vdout0_141ck1650 FIND v(dout0_141) AT=830.025n

.meas tran vdout0_142ck1650 FIND v(dout0_142) AT=830.025n

.meas tran vdout0_143ck1650 FIND v(dout0_143) AT=830.025n

.meas tran vdout0_144ck1650 FIND v(dout0_144) AT=830.025n

.meas tran vdout0_145ck1650 FIND v(dout0_145) AT=830.025n

.meas tran vdout0_146ck1650 FIND v(dout0_146) AT=830.025n

.meas tran vdout0_147ck1650 FIND v(dout0_147) AT=830.025n

.meas tran vdout0_148ck1650 FIND v(dout0_148) AT=830.025n

.meas tran vdout0_149ck1650 FIND v(dout0_149) AT=830.025n

.meas tran vdout0_0ck1660 FIND v(dout0_0) AT=835.025n

.meas tran vdout0_1ck1660 FIND v(dout0_1) AT=835.025n

.meas tran vdout0_2ck1660 FIND v(dout0_2) AT=835.025n

.meas tran vdout0_3ck1660 FIND v(dout0_3) AT=835.025n

.meas tran vdout0_4ck1660 FIND v(dout0_4) AT=835.025n

.meas tran vdout0_5ck1660 FIND v(dout0_5) AT=835.025n

.meas tran vdout0_6ck1660 FIND v(dout0_6) AT=835.025n

.meas tran vdout0_7ck1660 FIND v(dout0_7) AT=835.025n

.meas tran vdout0_8ck1660 FIND v(dout0_8) AT=835.025n

.meas tran vdout0_9ck1660 FIND v(dout0_9) AT=835.025n

.meas tran vdout0_10ck1660 FIND v(dout0_10) AT=835.025n

.meas tran vdout0_11ck1660 FIND v(dout0_11) AT=835.025n

.meas tran vdout0_12ck1660 FIND v(dout0_12) AT=835.025n

.meas tran vdout0_13ck1660 FIND v(dout0_13) AT=835.025n

.meas tran vdout0_14ck1660 FIND v(dout0_14) AT=835.025n

.meas tran vdout0_15ck1660 FIND v(dout0_15) AT=835.025n

.meas tran vdout0_16ck1660 FIND v(dout0_16) AT=835.025n

.meas tran vdout0_17ck1660 FIND v(dout0_17) AT=835.025n

.meas tran vdout0_18ck1660 FIND v(dout0_18) AT=835.025n

.meas tran vdout0_19ck1660 FIND v(dout0_19) AT=835.025n

.meas tran vdout0_20ck1660 FIND v(dout0_20) AT=835.025n

.meas tran vdout0_21ck1660 FIND v(dout0_21) AT=835.025n

.meas tran vdout0_22ck1660 FIND v(dout0_22) AT=835.025n

.meas tran vdout0_23ck1660 FIND v(dout0_23) AT=835.025n

.meas tran vdout0_24ck1660 FIND v(dout0_24) AT=835.025n

.meas tran vdout0_25ck1660 FIND v(dout0_25) AT=835.025n

.meas tran vdout0_26ck1660 FIND v(dout0_26) AT=835.025n

.meas tran vdout0_27ck1660 FIND v(dout0_27) AT=835.025n

.meas tran vdout0_28ck1660 FIND v(dout0_28) AT=835.025n

.meas tran vdout0_29ck1660 FIND v(dout0_29) AT=835.025n

.meas tran vdout0_30ck1660 FIND v(dout0_30) AT=835.025n

.meas tran vdout0_31ck1660 FIND v(dout0_31) AT=835.025n

.meas tran vdout0_32ck1660 FIND v(dout0_32) AT=835.025n

.meas tran vdout0_33ck1660 FIND v(dout0_33) AT=835.025n

.meas tran vdout0_34ck1660 FIND v(dout0_34) AT=835.025n

.meas tran vdout0_35ck1660 FIND v(dout0_35) AT=835.025n

.meas tran vdout0_36ck1660 FIND v(dout0_36) AT=835.025n

.meas tran vdout0_37ck1660 FIND v(dout0_37) AT=835.025n

.meas tran vdout0_38ck1660 FIND v(dout0_38) AT=835.025n

.meas tran vdout0_39ck1660 FIND v(dout0_39) AT=835.025n

.meas tran vdout0_40ck1660 FIND v(dout0_40) AT=835.025n

.meas tran vdout0_41ck1660 FIND v(dout0_41) AT=835.025n

.meas tran vdout0_42ck1660 FIND v(dout0_42) AT=835.025n

.meas tran vdout0_43ck1660 FIND v(dout0_43) AT=835.025n

.meas tran vdout0_44ck1660 FIND v(dout0_44) AT=835.025n

.meas tran vdout0_45ck1660 FIND v(dout0_45) AT=835.025n

.meas tran vdout0_46ck1660 FIND v(dout0_46) AT=835.025n

.meas tran vdout0_47ck1660 FIND v(dout0_47) AT=835.025n

.meas tran vdout0_48ck1660 FIND v(dout0_48) AT=835.025n

.meas tran vdout0_49ck1660 FIND v(dout0_49) AT=835.025n

.meas tran vdout0_50ck1660 FIND v(dout0_50) AT=835.025n

.meas tran vdout0_51ck1660 FIND v(dout0_51) AT=835.025n

.meas tran vdout0_52ck1660 FIND v(dout0_52) AT=835.025n

.meas tran vdout0_53ck1660 FIND v(dout0_53) AT=835.025n

.meas tran vdout0_54ck1660 FIND v(dout0_54) AT=835.025n

.meas tran vdout0_55ck1660 FIND v(dout0_55) AT=835.025n

.meas tran vdout0_56ck1660 FIND v(dout0_56) AT=835.025n

.meas tran vdout0_57ck1660 FIND v(dout0_57) AT=835.025n

.meas tran vdout0_58ck1660 FIND v(dout0_58) AT=835.025n

.meas tran vdout0_59ck1660 FIND v(dout0_59) AT=835.025n

.meas tran vdout0_60ck1660 FIND v(dout0_60) AT=835.025n

.meas tran vdout0_61ck1660 FIND v(dout0_61) AT=835.025n

.meas tran vdout0_62ck1660 FIND v(dout0_62) AT=835.025n

.meas tran vdout0_63ck1660 FIND v(dout0_63) AT=835.025n

.meas tran vdout0_64ck1660 FIND v(dout0_64) AT=835.025n

.meas tran vdout0_65ck1660 FIND v(dout0_65) AT=835.025n

.meas tran vdout0_66ck1660 FIND v(dout0_66) AT=835.025n

.meas tran vdout0_67ck1660 FIND v(dout0_67) AT=835.025n

.meas tran vdout0_68ck1660 FIND v(dout0_68) AT=835.025n

.meas tran vdout0_69ck1660 FIND v(dout0_69) AT=835.025n

.meas tran vdout0_70ck1660 FIND v(dout0_70) AT=835.025n

.meas tran vdout0_71ck1660 FIND v(dout0_71) AT=835.025n

.meas tran vdout0_72ck1660 FIND v(dout0_72) AT=835.025n

.meas tran vdout0_73ck1660 FIND v(dout0_73) AT=835.025n

.meas tran vdout0_74ck1660 FIND v(dout0_74) AT=835.025n

.meas tran vdout0_75ck1660 FIND v(dout0_75) AT=835.025n

.meas tran vdout0_76ck1660 FIND v(dout0_76) AT=835.025n

.meas tran vdout0_77ck1660 FIND v(dout0_77) AT=835.025n

.meas tran vdout0_78ck1660 FIND v(dout0_78) AT=835.025n

.meas tran vdout0_79ck1660 FIND v(dout0_79) AT=835.025n

.meas tran vdout0_80ck1660 FIND v(dout0_80) AT=835.025n

.meas tran vdout0_81ck1660 FIND v(dout0_81) AT=835.025n

.meas tran vdout0_82ck1660 FIND v(dout0_82) AT=835.025n

.meas tran vdout0_83ck1660 FIND v(dout0_83) AT=835.025n

.meas tran vdout0_84ck1660 FIND v(dout0_84) AT=835.025n

.meas tran vdout0_85ck1660 FIND v(dout0_85) AT=835.025n

.meas tran vdout0_86ck1660 FIND v(dout0_86) AT=835.025n

.meas tran vdout0_87ck1660 FIND v(dout0_87) AT=835.025n

.meas tran vdout0_88ck1660 FIND v(dout0_88) AT=835.025n

.meas tran vdout0_89ck1660 FIND v(dout0_89) AT=835.025n

.meas tran vdout0_90ck1660 FIND v(dout0_90) AT=835.025n

.meas tran vdout0_91ck1660 FIND v(dout0_91) AT=835.025n

.meas tran vdout0_92ck1660 FIND v(dout0_92) AT=835.025n

.meas tran vdout0_93ck1660 FIND v(dout0_93) AT=835.025n

.meas tran vdout0_94ck1660 FIND v(dout0_94) AT=835.025n

.meas tran vdout0_95ck1660 FIND v(dout0_95) AT=835.025n

.meas tran vdout0_96ck1660 FIND v(dout0_96) AT=835.025n

.meas tran vdout0_97ck1660 FIND v(dout0_97) AT=835.025n

.meas tran vdout0_98ck1660 FIND v(dout0_98) AT=835.025n

.meas tran vdout0_99ck1660 FIND v(dout0_99) AT=835.025n

.meas tran vdout0_100ck1660 FIND v(dout0_100) AT=835.025n

.meas tran vdout0_101ck1660 FIND v(dout0_101) AT=835.025n

.meas tran vdout0_102ck1660 FIND v(dout0_102) AT=835.025n

.meas tran vdout0_103ck1660 FIND v(dout0_103) AT=835.025n

.meas tran vdout0_104ck1660 FIND v(dout0_104) AT=835.025n

.meas tran vdout0_105ck1660 FIND v(dout0_105) AT=835.025n

.meas tran vdout0_106ck1660 FIND v(dout0_106) AT=835.025n

.meas tran vdout0_107ck1660 FIND v(dout0_107) AT=835.025n

.meas tran vdout0_108ck1660 FIND v(dout0_108) AT=835.025n

.meas tran vdout0_109ck1660 FIND v(dout0_109) AT=835.025n

.meas tran vdout0_110ck1660 FIND v(dout0_110) AT=835.025n

.meas tran vdout0_111ck1660 FIND v(dout0_111) AT=835.025n

.meas tran vdout0_112ck1660 FIND v(dout0_112) AT=835.025n

.meas tran vdout0_113ck1660 FIND v(dout0_113) AT=835.025n

.meas tran vdout0_114ck1660 FIND v(dout0_114) AT=835.025n

.meas tran vdout0_115ck1660 FIND v(dout0_115) AT=835.025n

.meas tran vdout0_116ck1660 FIND v(dout0_116) AT=835.025n

.meas tran vdout0_117ck1660 FIND v(dout0_117) AT=835.025n

.meas tran vdout0_118ck1660 FIND v(dout0_118) AT=835.025n

.meas tran vdout0_119ck1660 FIND v(dout0_119) AT=835.025n

.meas tran vdout0_120ck1660 FIND v(dout0_120) AT=835.025n

.meas tran vdout0_121ck1660 FIND v(dout0_121) AT=835.025n

.meas tran vdout0_122ck1660 FIND v(dout0_122) AT=835.025n

.meas tran vdout0_123ck1660 FIND v(dout0_123) AT=835.025n

.meas tran vdout0_124ck1660 FIND v(dout0_124) AT=835.025n

.meas tran vdout0_125ck1660 FIND v(dout0_125) AT=835.025n

.meas tran vdout0_126ck1660 FIND v(dout0_126) AT=835.025n

.meas tran vdout0_127ck1660 FIND v(dout0_127) AT=835.025n

.meas tran vdout0_128ck1660 FIND v(dout0_128) AT=835.025n

.meas tran vdout0_129ck1660 FIND v(dout0_129) AT=835.025n

.meas tran vdout0_130ck1660 FIND v(dout0_130) AT=835.025n

.meas tran vdout0_131ck1660 FIND v(dout0_131) AT=835.025n

.meas tran vdout0_132ck1660 FIND v(dout0_132) AT=835.025n

.meas tran vdout0_133ck1660 FIND v(dout0_133) AT=835.025n

.meas tran vdout0_134ck1660 FIND v(dout0_134) AT=835.025n

.meas tran vdout0_135ck1660 FIND v(dout0_135) AT=835.025n

.meas tran vdout0_136ck1660 FIND v(dout0_136) AT=835.025n

.meas tran vdout0_137ck1660 FIND v(dout0_137) AT=835.025n

.meas tran vdout0_138ck1660 FIND v(dout0_138) AT=835.025n

.meas tran vdout0_139ck1660 FIND v(dout0_139) AT=835.025n

.meas tran vdout0_140ck1660 FIND v(dout0_140) AT=835.025n

.meas tran vdout0_141ck1660 FIND v(dout0_141) AT=835.025n

.meas tran vdout0_142ck1660 FIND v(dout0_142) AT=835.025n

.meas tran vdout0_143ck1660 FIND v(dout0_143) AT=835.025n

.meas tran vdout0_144ck1660 FIND v(dout0_144) AT=835.025n

.meas tran vdout0_145ck1660 FIND v(dout0_145) AT=835.025n

.meas tran vdout0_146ck1660 FIND v(dout0_146) AT=835.025n

.meas tran vdout0_147ck1660 FIND v(dout0_147) AT=835.025n

.meas tran vdout0_148ck1660 FIND v(dout0_148) AT=835.025n

.meas tran vdout0_149ck1660 FIND v(dout0_149) AT=835.025n

.meas tran vdout0_0ck1670 FIND v(dout0_0) AT=840.025n

.meas tran vdout0_1ck1670 FIND v(dout0_1) AT=840.025n

.meas tran vdout0_2ck1670 FIND v(dout0_2) AT=840.025n

.meas tran vdout0_3ck1670 FIND v(dout0_3) AT=840.025n

.meas tran vdout0_4ck1670 FIND v(dout0_4) AT=840.025n

.meas tran vdout0_5ck1670 FIND v(dout0_5) AT=840.025n

.meas tran vdout0_6ck1670 FIND v(dout0_6) AT=840.025n

.meas tran vdout0_7ck1670 FIND v(dout0_7) AT=840.025n

.meas tran vdout0_8ck1670 FIND v(dout0_8) AT=840.025n

.meas tran vdout0_9ck1670 FIND v(dout0_9) AT=840.025n

.meas tran vdout0_10ck1670 FIND v(dout0_10) AT=840.025n

.meas tran vdout0_11ck1670 FIND v(dout0_11) AT=840.025n

.meas tran vdout0_12ck1670 FIND v(dout0_12) AT=840.025n

.meas tran vdout0_13ck1670 FIND v(dout0_13) AT=840.025n

.meas tran vdout0_14ck1670 FIND v(dout0_14) AT=840.025n

.meas tran vdout0_15ck1670 FIND v(dout0_15) AT=840.025n

.meas tran vdout0_16ck1670 FIND v(dout0_16) AT=840.025n

.meas tran vdout0_17ck1670 FIND v(dout0_17) AT=840.025n

.meas tran vdout0_18ck1670 FIND v(dout0_18) AT=840.025n

.meas tran vdout0_19ck1670 FIND v(dout0_19) AT=840.025n

.meas tran vdout0_20ck1670 FIND v(dout0_20) AT=840.025n

.meas tran vdout0_21ck1670 FIND v(dout0_21) AT=840.025n

.meas tran vdout0_22ck1670 FIND v(dout0_22) AT=840.025n

.meas tran vdout0_23ck1670 FIND v(dout0_23) AT=840.025n

.meas tran vdout0_24ck1670 FIND v(dout0_24) AT=840.025n

.meas tran vdout0_25ck1670 FIND v(dout0_25) AT=840.025n

.meas tran vdout0_26ck1670 FIND v(dout0_26) AT=840.025n

.meas tran vdout0_27ck1670 FIND v(dout0_27) AT=840.025n

.meas tran vdout0_28ck1670 FIND v(dout0_28) AT=840.025n

.meas tran vdout0_29ck1670 FIND v(dout0_29) AT=840.025n

.meas tran vdout0_30ck1670 FIND v(dout0_30) AT=840.025n

.meas tran vdout0_31ck1670 FIND v(dout0_31) AT=840.025n

.meas tran vdout0_32ck1670 FIND v(dout0_32) AT=840.025n

.meas tran vdout0_33ck1670 FIND v(dout0_33) AT=840.025n

.meas tran vdout0_34ck1670 FIND v(dout0_34) AT=840.025n

.meas tran vdout0_35ck1670 FIND v(dout0_35) AT=840.025n

.meas tran vdout0_36ck1670 FIND v(dout0_36) AT=840.025n

.meas tran vdout0_37ck1670 FIND v(dout0_37) AT=840.025n

.meas tran vdout0_38ck1670 FIND v(dout0_38) AT=840.025n

.meas tran vdout0_39ck1670 FIND v(dout0_39) AT=840.025n

.meas tran vdout0_40ck1670 FIND v(dout0_40) AT=840.025n

.meas tran vdout0_41ck1670 FIND v(dout0_41) AT=840.025n

.meas tran vdout0_42ck1670 FIND v(dout0_42) AT=840.025n

.meas tran vdout0_43ck1670 FIND v(dout0_43) AT=840.025n

.meas tran vdout0_44ck1670 FIND v(dout0_44) AT=840.025n

.meas tran vdout0_45ck1670 FIND v(dout0_45) AT=840.025n

.meas tran vdout0_46ck1670 FIND v(dout0_46) AT=840.025n

.meas tran vdout0_47ck1670 FIND v(dout0_47) AT=840.025n

.meas tran vdout0_48ck1670 FIND v(dout0_48) AT=840.025n

.meas tran vdout0_49ck1670 FIND v(dout0_49) AT=840.025n

.meas tran vdout0_50ck1670 FIND v(dout0_50) AT=840.025n

.meas tran vdout0_51ck1670 FIND v(dout0_51) AT=840.025n

.meas tran vdout0_52ck1670 FIND v(dout0_52) AT=840.025n

.meas tran vdout0_53ck1670 FIND v(dout0_53) AT=840.025n

.meas tran vdout0_54ck1670 FIND v(dout0_54) AT=840.025n

.meas tran vdout0_55ck1670 FIND v(dout0_55) AT=840.025n

.meas tran vdout0_56ck1670 FIND v(dout0_56) AT=840.025n

.meas tran vdout0_57ck1670 FIND v(dout0_57) AT=840.025n

.meas tran vdout0_58ck1670 FIND v(dout0_58) AT=840.025n

.meas tran vdout0_59ck1670 FIND v(dout0_59) AT=840.025n

.meas tran vdout0_60ck1670 FIND v(dout0_60) AT=840.025n

.meas tran vdout0_61ck1670 FIND v(dout0_61) AT=840.025n

.meas tran vdout0_62ck1670 FIND v(dout0_62) AT=840.025n

.meas tran vdout0_63ck1670 FIND v(dout0_63) AT=840.025n

.meas tran vdout0_64ck1670 FIND v(dout0_64) AT=840.025n

.meas tran vdout0_65ck1670 FIND v(dout0_65) AT=840.025n

.meas tran vdout0_66ck1670 FIND v(dout0_66) AT=840.025n

.meas tran vdout0_67ck1670 FIND v(dout0_67) AT=840.025n

.meas tran vdout0_68ck1670 FIND v(dout0_68) AT=840.025n

.meas tran vdout0_69ck1670 FIND v(dout0_69) AT=840.025n

.meas tran vdout0_70ck1670 FIND v(dout0_70) AT=840.025n

.meas tran vdout0_71ck1670 FIND v(dout0_71) AT=840.025n

.meas tran vdout0_72ck1670 FIND v(dout0_72) AT=840.025n

.meas tran vdout0_73ck1670 FIND v(dout0_73) AT=840.025n

.meas tran vdout0_74ck1670 FIND v(dout0_74) AT=840.025n

.meas tran vdout0_75ck1670 FIND v(dout0_75) AT=840.025n

.meas tran vdout0_76ck1670 FIND v(dout0_76) AT=840.025n

.meas tran vdout0_77ck1670 FIND v(dout0_77) AT=840.025n

.meas tran vdout0_78ck1670 FIND v(dout0_78) AT=840.025n

.meas tran vdout0_79ck1670 FIND v(dout0_79) AT=840.025n

.meas tran vdout0_80ck1670 FIND v(dout0_80) AT=840.025n

.meas tran vdout0_81ck1670 FIND v(dout0_81) AT=840.025n

.meas tran vdout0_82ck1670 FIND v(dout0_82) AT=840.025n

.meas tran vdout0_83ck1670 FIND v(dout0_83) AT=840.025n

.meas tran vdout0_84ck1670 FIND v(dout0_84) AT=840.025n

.meas tran vdout0_85ck1670 FIND v(dout0_85) AT=840.025n

.meas tran vdout0_86ck1670 FIND v(dout0_86) AT=840.025n

.meas tran vdout0_87ck1670 FIND v(dout0_87) AT=840.025n

.meas tran vdout0_88ck1670 FIND v(dout0_88) AT=840.025n

.meas tran vdout0_89ck1670 FIND v(dout0_89) AT=840.025n

.meas tran vdout0_90ck1670 FIND v(dout0_90) AT=840.025n

.meas tran vdout0_91ck1670 FIND v(dout0_91) AT=840.025n

.meas tran vdout0_92ck1670 FIND v(dout0_92) AT=840.025n

.meas tran vdout0_93ck1670 FIND v(dout0_93) AT=840.025n

.meas tran vdout0_94ck1670 FIND v(dout0_94) AT=840.025n

.meas tran vdout0_95ck1670 FIND v(dout0_95) AT=840.025n

.meas tran vdout0_96ck1670 FIND v(dout0_96) AT=840.025n

.meas tran vdout0_97ck1670 FIND v(dout0_97) AT=840.025n

.meas tran vdout0_98ck1670 FIND v(dout0_98) AT=840.025n

.meas tran vdout0_99ck1670 FIND v(dout0_99) AT=840.025n

.meas tran vdout0_100ck1670 FIND v(dout0_100) AT=840.025n

.meas tran vdout0_101ck1670 FIND v(dout0_101) AT=840.025n

.meas tran vdout0_102ck1670 FIND v(dout0_102) AT=840.025n

.meas tran vdout0_103ck1670 FIND v(dout0_103) AT=840.025n

.meas tran vdout0_104ck1670 FIND v(dout0_104) AT=840.025n

.meas tran vdout0_105ck1670 FIND v(dout0_105) AT=840.025n

.meas tran vdout0_106ck1670 FIND v(dout0_106) AT=840.025n

.meas tran vdout0_107ck1670 FIND v(dout0_107) AT=840.025n

.meas tran vdout0_108ck1670 FIND v(dout0_108) AT=840.025n

.meas tran vdout0_109ck1670 FIND v(dout0_109) AT=840.025n

.meas tran vdout0_110ck1670 FIND v(dout0_110) AT=840.025n

.meas tran vdout0_111ck1670 FIND v(dout0_111) AT=840.025n

.meas tran vdout0_112ck1670 FIND v(dout0_112) AT=840.025n

.meas tran vdout0_113ck1670 FIND v(dout0_113) AT=840.025n

.meas tran vdout0_114ck1670 FIND v(dout0_114) AT=840.025n

.meas tran vdout0_115ck1670 FIND v(dout0_115) AT=840.025n

.meas tran vdout0_116ck1670 FIND v(dout0_116) AT=840.025n

.meas tran vdout0_117ck1670 FIND v(dout0_117) AT=840.025n

.meas tran vdout0_118ck1670 FIND v(dout0_118) AT=840.025n

.meas tran vdout0_119ck1670 FIND v(dout0_119) AT=840.025n

.meas tran vdout0_120ck1670 FIND v(dout0_120) AT=840.025n

.meas tran vdout0_121ck1670 FIND v(dout0_121) AT=840.025n

.meas tran vdout0_122ck1670 FIND v(dout0_122) AT=840.025n

.meas tran vdout0_123ck1670 FIND v(dout0_123) AT=840.025n

.meas tran vdout0_124ck1670 FIND v(dout0_124) AT=840.025n

.meas tran vdout0_125ck1670 FIND v(dout0_125) AT=840.025n

.meas tran vdout0_126ck1670 FIND v(dout0_126) AT=840.025n

.meas tran vdout0_127ck1670 FIND v(dout0_127) AT=840.025n

.meas tran vdout0_128ck1670 FIND v(dout0_128) AT=840.025n

.meas tran vdout0_129ck1670 FIND v(dout0_129) AT=840.025n

.meas tran vdout0_130ck1670 FIND v(dout0_130) AT=840.025n

.meas tran vdout0_131ck1670 FIND v(dout0_131) AT=840.025n

.meas tran vdout0_132ck1670 FIND v(dout0_132) AT=840.025n

.meas tran vdout0_133ck1670 FIND v(dout0_133) AT=840.025n

.meas tran vdout0_134ck1670 FIND v(dout0_134) AT=840.025n

.meas tran vdout0_135ck1670 FIND v(dout0_135) AT=840.025n

.meas tran vdout0_136ck1670 FIND v(dout0_136) AT=840.025n

.meas tran vdout0_137ck1670 FIND v(dout0_137) AT=840.025n

.meas tran vdout0_138ck1670 FIND v(dout0_138) AT=840.025n

.meas tran vdout0_139ck1670 FIND v(dout0_139) AT=840.025n

.meas tran vdout0_140ck1670 FIND v(dout0_140) AT=840.025n

.meas tran vdout0_141ck1670 FIND v(dout0_141) AT=840.025n

.meas tran vdout0_142ck1670 FIND v(dout0_142) AT=840.025n

.meas tran vdout0_143ck1670 FIND v(dout0_143) AT=840.025n

.meas tran vdout0_144ck1670 FIND v(dout0_144) AT=840.025n

.meas tran vdout0_145ck1670 FIND v(dout0_145) AT=840.025n

.meas tran vdout0_146ck1670 FIND v(dout0_146) AT=840.025n

.meas tran vdout0_147ck1670 FIND v(dout0_147) AT=840.025n

.meas tran vdout0_148ck1670 FIND v(dout0_148) AT=840.025n

.meas tran vdout0_149ck1670 FIND v(dout0_149) AT=840.025n

.meas tran vdout0_0ck1690 FIND v(dout0_0) AT=850.025n

.meas tran vdout0_1ck1690 FIND v(dout0_1) AT=850.025n

.meas tran vdout0_2ck1690 FIND v(dout0_2) AT=850.025n

.meas tran vdout0_3ck1690 FIND v(dout0_3) AT=850.025n

.meas tran vdout0_4ck1690 FIND v(dout0_4) AT=850.025n

.meas tran vdout0_5ck1690 FIND v(dout0_5) AT=850.025n

.meas tran vdout0_6ck1690 FIND v(dout0_6) AT=850.025n

.meas tran vdout0_7ck1690 FIND v(dout0_7) AT=850.025n

.meas tran vdout0_8ck1690 FIND v(dout0_8) AT=850.025n

.meas tran vdout0_9ck1690 FIND v(dout0_9) AT=850.025n

.meas tran vdout0_10ck1690 FIND v(dout0_10) AT=850.025n

.meas tran vdout0_11ck1690 FIND v(dout0_11) AT=850.025n

.meas tran vdout0_12ck1690 FIND v(dout0_12) AT=850.025n

.meas tran vdout0_13ck1690 FIND v(dout0_13) AT=850.025n

.meas tran vdout0_14ck1690 FIND v(dout0_14) AT=850.025n

.meas tran vdout0_15ck1690 FIND v(dout0_15) AT=850.025n

.meas tran vdout0_16ck1690 FIND v(dout0_16) AT=850.025n

.meas tran vdout0_17ck1690 FIND v(dout0_17) AT=850.025n

.meas tran vdout0_18ck1690 FIND v(dout0_18) AT=850.025n

.meas tran vdout0_19ck1690 FIND v(dout0_19) AT=850.025n

.meas tran vdout0_20ck1690 FIND v(dout0_20) AT=850.025n

.meas tran vdout0_21ck1690 FIND v(dout0_21) AT=850.025n

.meas tran vdout0_22ck1690 FIND v(dout0_22) AT=850.025n

.meas tran vdout0_23ck1690 FIND v(dout0_23) AT=850.025n

.meas tran vdout0_24ck1690 FIND v(dout0_24) AT=850.025n

.meas tran vdout0_25ck1690 FIND v(dout0_25) AT=850.025n

.meas tran vdout0_26ck1690 FIND v(dout0_26) AT=850.025n

.meas tran vdout0_27ck1690 FIND v(dout0_27) AT=850.025n

.meas tran vdout0_28ck1690 FIND v(dout0_28) AT=850.025n

.meas tran vdout0_29ck1690 FIND v(dout0_29) AT=850.025n

.meas tran vdout0_30ck1690 FIND v(dout0_30) AT=850.025n

.meas tran vdout0_31ck1690 FIND v(dout0_31) AT=850.025n

.meas tran vdout0_32ck1690 FIND v(dout0_32) AT=850.025n

.meas tran vdout0_33ck1690 FIND v(dout0_33) AT=850.025n

.meas tran vdout0_34ck1690 FIND v(dout0_34) AT=850.025n

.meas tran vdout0_35ck1690 FIND v(dout0_35) AT=850.025n

.meas tran vdout0_36ck1690 FIND v(dout0_36) AT=850.025n

.meas tran vdout0_37ck1690 FIND v(dout0_37) AT=850.025n

.meas tran vdout0_38ck1690 FIND v(dout0_38) AT=850.025n

.meas tran vdout0_39ck1690 FIND v(dout0_39) AT=850.025n

.meas tran vdout0_40ck1690 FIND v(dout0_40) AT=850.025n

.meas tran vdout0_41ck1690 FIND v(dout0_41) AT=850.025n

.meas tran vdout0_42ck1690 FIND v(dout0_42) AT=850.025n

.meas tran vdout0_43ck1690 FIND v(dout0_43) AT=850.025n

.meas tran vdout0_44ck1690 FIND v(dout0_44) AT=850.025n

.meas tran vdout0_45ck1690 FIND v(dout0_45) AT=850.025n

.meas tran vdout0_46ck1690 FIND v(dout0_46) AT=850.025n

.meas tran vdout0_47ck1690 FIND v(dout0_47) AT=850.025n

.meas tran vdout0_48ck1690 FIND v(dout0_48) AT=850.025n

.meas tran vdout0_49ck1690 FIND v(dout0_49) AT=850.025n

.meas tran vdout0_50ck1690 FIND v(dout0_50) AT=850.025n

.meas tran vdout0_51ck1690 FIND v(dout0_51) AT=850.025n

.meas tran vdout0_52ck1690 FIND v(dout0_52) AT=850.025n

.meas tran vdout0_53ck1690 FIND v(dout0_53) AT=850.025n

.meas tran vdout0_54ck1690 FIND v(dout0_54) AT=850.025n

.meas tran vdout0_55ck1690 FIND v(dout0_55) AT=850.025n

.meas tran vdout0_56ck1690 FIND v(dout0_56) AT=850.025n

.meas tran vdout0_57ck1690 FIND v(dout0_57) AT=850.025n

.meas tran vdout0_58ck1690 FIND v(dout0_58) AT=850.025n

.meas tran vdout0_59ck1690 FIND v(dout0_59) AT=850.025n

.meas tran vdout0_60ck1690 FIND v(dout0_60) AT=850.025n

.meas tran vdout0_61ck1690 FIND v(dout0_61) AT=850.025n

.meas tran vdout0_62ck1690 FIND v(dout0_62) AT=850.025n

.meas tran vdout0_63ck1690 FIND v(dout0_63) AT=850.025n

.meas tran vdout0_64ck1690 FIND v(dout0_64) AT=850.025n

.meas tran vdout0_65ck1690 FIND v(dout0_65) AT=850.025n

.meas tran vdout0_66ck1690 FIND v(dout0_66) AT=850.025n

.meas tran vdout0_67ck1690 FIND v(dout0_67) AT=850.025n

.meas tran vdout0_68ck1690 FIND v(dout0_68) AT=850.025n

.meas tran vdout0_69ck1690 FIND v(dout0_69) AT=850.025n

.meas tran vdout0_70ck1690 FIND v(dout0_70) AT=850.025n

.meas tran vdout0_71ck1690 FIND v(dout0_71) AT=850.025n

.meas tran vdout0_72ck1690 FIND v(dout0_72) AT=850.025n

.meas tran vdout0_73ck1690 FIND v(dout0_73) AT=850.025n

.meas tran vdout0_74ck1690 FIND v(dout0_74) AT=850.025n

.meas tran vdout0_75ck1690 FIND v(dout0_75) AT=850.025n

.meas tran vdout0_76ck1690 FIND v(dout0_76) AT=850.025n

.meas tran vdout0_77ck1690 FIND v(dout0_77) AT=850.025n

.meas tran vdout0_78ck1690 FIND v(dout0_78) AT=850.025n

.meas tran vdout0_79ck1690 FIND v(dout0_79) AT=850.025n

.meas tran vdout0_80ck1690 FIND v(dout0_80) AT=850.025n

.meas tran vdout0_81ck1690 FIND v(dout0_81) AT=850.025n

.meas tran vdout0_82ck1690 FIND v(dout0_82) AT=850.025n

.meas tran vdout0_83ck1690 FIND v(dout0_83) AT=850.025n

.meas tran vdout0_84ck1690 FIND v(dout0_84) AT=850.025n

.meas tran vdout0_85ck1690 FIND v(dout0_85) AT=850.025n

.meas tran vdout0_86ck1690 FIND v(dout0_86) AT=850.025n

.meas tran vdout0_87ck1690 FIND v(dout0_87) AT=850.025n

.meas tran vdout0_88ck1690 FIND v(dout0_88) AT=850.025n

.meas tran vdout0_89ck1690 FIND v(dout0_89) AT=850.025n

.meas tran vdout0_90ck1690 FIND v(dout0_90) AT=850.025n

.meas tran vdout0_91ck1690 FIND v(dout0_91) AT=850.025n

.meas tran vdout0_92ck1690 FIND v(dout0_92) AT=850.025n

.meas tran vdout0_93ck1690 FIND v(dout0_93) AT=850.025n

.meas tran vdout0_94ck1690 FIND v(dout0_94) AT=850.025n

.meas tran vdout0_95ck1690 FIND v(dout0_95) AT=850.025n

.meas tran vdout0_96ck1690 FIND v(dout0_96) AT=850.025n

.meas tran vdout0_97ck1690 FIND v(dout0_97) AT=850.025n

.meas tran vdout0_98ck1690 FIND v(dout0_98) AT=850.025n

.meas tran vdout0_99ck1690 FIND v(dout0_99) AT=850.025n

.meas tran vdout0_100ck1690 FIND v(dout0_100) AT=850.025n

.meas tran vdout0_101ck1690 FIND v(dout0_101) AT=850.025n

.meas tran vdout0_102ck1690 FIND v(dout0_102) AT=850.025n

.meas tran vdout0_103ck1690 FIND v(dout0_103) AT=850.025n

.meas tran vdout0_104ck1690 FIND v(dout0_104) AT=850.025n

.meas tran vdout0_105ck1690 FIND v(dout0_105) AT=850.025n

.meas tran vdout0_106ck1690 FIND v(dout0_106) AT=850.025n

.meas tran vdout0_107ck1690 FIND v(dout0_107) AT=850.025n

.meas tran vdout0_108ck1690 FIND v(dout0_108) AT=850.025n

.meas tran vdout0_109ck1690 FIND v(dout0_109) AT=850.025n

.meas tran vdout0_110ck1690 FIND v(dout0_110) AT=850.025n

.meas tran vdout0_111ck1690 FIND v(dout0_111) AT=850.025n

.meas tran vdout0_112ck1690 FIND v(dout0_112) AT=850.025n

.meas tran vdout0_113ck1690 FIND v(dout0_113) AT=850.025n

.meas tran vdout0_114ck1690 FIND v(dout0_114) AT=850.025n

.meas tran vdout0_115ck1690 FIND v(dout0_115) AT=850.025n

.meas tran vdout0_116ck1690 FIND v(dout0_116) AT=850.025n

.meas tran vdout0_117ck1690 FIND v(dout0_117) AT=850.025n

.meas tran vdout0_118ck1690 FIND v(dout0_118) AT=850.025n

.meas tran vdout0_119ck1690 FIND v(dout0_119) AT=850.025n

.meas tran vdout0_120ck1690 FIND v(dout0_120) AT=850.025n

.meas tran vdout0_121ck1690 FIND v(dout0_121) AT=850.025n

.meas tran vdout0_122ck1690 FIND v(dout0_122) AT=850.025n

.meas tran vdout0_123ck1690 FIND v(dout0_123) AT=850.025n

.meas tran vdout0_124ck1690 FIND v(dout0_124) AT=850.025n

.meas tran vdout0_125ck1690 FIND v(dout0_125) AT=850.025n

.meas tran vdout0_126ck1690 FIND v(dout0_126) AT=850.025n

.meas tran vdout0_127ck1690 FIND v(dout0_127) AT=850.025n

.meas tran vdout0_128ck1690 FIND v(dout0_128) AT=850.025n

.meas tran vdout0_129ck1690 FIND v(dout0_129) AT=850.025n

.meas tran vdout0_130ck1690 FIND v(dout0_130) AT=850.025n

.meas tran vdout0_131ck1690 FIND v(dout0_131) AT=850.025n

.meas tran vdout0_132ck1690 FIND v(dout0_132) AT=850.025n

.meas tran vdout0_133ck1690 FIND v(dout0_133) AT=850.025n

.meas tran vdout0_134ck1690 FIND v(dout0_134) AT=850.025n

.meas tran vdout0_135ck1690 FIND v(dout0_135) AT=850.025n

.meas tran vdout0_136ck1690 FIND v(dout0_136) AT=850.025n

.meas tran vdout0_137ck1690 FIND v(dout0_137) AT=850.025n

.meas tran vdout0_138ck1690 FIND v(dout0_138) AT=850.025n

.meas tran vdout0_139ck1690 FIND v(dout0_139) AT=850.025n

.meas tran vdout0_140ck1690 FIND v(dout0_140) AT=850.025n

.meas tran vdout0_141ck1690 FIND v(dout0_141) AT=850.025n

.meas tran vdout0_142ck1690 FIND v(dout0_142) AT=850.025n

.meas tran vdout0_143ck1690 FIND v(dout0_143) AT=850.025n

.meas tran vdout0_144ck1690 FIND v(dout0_144) AT=850.025n

.meas tran vdout0_145ck1690 FIND v(dout0_145) AT=850.025n

.meas tran vdout0_146ck1690 FIND v(dout0_146) AT=850.025n

.meas tran vdout0_147ck1690 FIND v(dout0_147) AT=850.025n

.meas tran vdout0_148ck1690 FIND v(dout0_148) AT=850.025n

.meas tran vdout0_149ck1690 FIND v(dout0_149) AT=850.025n

.meas tran vdout0_0ck1750 FIND v(dout0_0) AT=880.025n

.meas tran vdout0_1ck1750 FIND v(dout0_1) AT=880.025n

.meas tran vdout0_2ck1750 FIND v(dout0_2) AT=880.025n

.meas tran vdout0_3ck1750 FIND v(dout0_3) AT=880.025n

.meas tran vdout0_4ck1750 FIND v(dout0_4) AT=880.025n

.meas tran vdout0_5ck1750 FIND v(dout0_5) AT=880.025n

.meas tran vdout0_6ck1750 FIND v(dout0_6) AT=880.025n

.meas tran vdout0_7ck1750 FIND v(dout0_7) AT=880.025n

.meas tran vdout0_8ck1750 FIND v(dout0_8) AT=880.025n

.meas tran vdout0_9ck1750 FIND v(dout0_9) AT=880.025n

.meas tran vdout0_10ck1750 FIND v(dout0_10) AT=880.025n

.meas tran vdout0_11ck1750 FIND v(dout0_11) AT=880.025n

.meas tran vdout0_12ck1750 FIND v(dout0_12) AT=880.025n

.meas tran vdout0_13ck1750 FIND v(dout0_13) AT=880.025n

.meas tran vdout0_14ck1750 FIND v(dout0_14) AT=880.025n

.meas tran vdout0_15ck1750 FIND v(dout0_15) AT=880.025n

.meas tran vdout0_16ck1750 FIND v(dout0_16) AT=880.025n

.meas tran vdout0_17ck1750 FIND v(dout0_17) AT=880.025n

.meas tran vdout0_18ck1750 FIND v(dout0_18) AT=880.025n

.meas tran vdout0_19ck1750 FIND v(dout0_19) AT=880.025n

.meas tran vdout0_20ck1750 FIND v(dout0_20) AT=880.025n

.meas tran vdout0_21ck1750 FIND v(dout0_21) AT=880.025n

.meas tran vdout0_22ck1750 FIND v(dout0_22) AT=880.025n

.meas tran vdout0_23ck1750 FIND v(dout0_23) AT=880.025n

.meas tran vdout0_24ck1750 FIND v(dout0_24) AT=880.025n

.meas tran vdout0_25ck1750 FIND v(dout0_25) AT=880.025n

.meas tran vdout0_26ck1750 FIND v(dout0_26) AT=880.025n

.meas tran vdout0_27ck1750 FIND v(dout0_27) AT=880.025n

.meas tran vdout0_28ck1750 FIND v(dout0_28) AT=880.025n

.meas tran vdout0_29ck1750 FIND v(dout0_29) AT=880.025n

.meas tran vdout0_30ck1750 FIND v(dout0_30) AT=880.025n

.meas tran vdout0_31ck1750 FIND v(dout0_31) AT=880.025n

.meas tran vdout0_32ck1750 FIND v(dout0_32) AT=880.025n

.meas tran vdout0_33ck1750 FIND v(dout0_33) AT=880.025n

.meas tran vdout0_34ck1750 FIND v(dout0_34) AT=880.025n

.meas tran vdout0_35ck1750 FIND v(dout0_35) AT=880.025n

.meas tran vdout0_36ck1750 FIND v(dout0_36) AT=880.025n

.meas tran vdout0_37ck1750 FIND v(dout0_37) AT=880.025n

.meas tran vdout0_38ck1750 FIND v(dout0_38) AT=880.025n

.meas tran vdout0_39ck1750 FIND v(dout0_39) AT=880.025n

.meas tran vdout0_40ck1750 FIND v(dout0_40) AT=880.025n

.meas tran vdout0_41ck1750 FIND v(dout0_41) AT=880.025n

.meas tran vdout0_42ck1750 FIND v(dout0_42) AT=880.025n

.meas tran vdout0_43ck1750 FIND v(dout0_43) AT=880.025n

.meas tran vdout0_44ck1750 FIND v(dout0_44) AT=880.025n

.meas tran vdout0_45ck1750 FIND v(dout0_45) AT=880.025n

.meas tran vdout0_46ck1750 FIND v(dout0_46) AT=880.025n

.meas tran vdout0_47ck1750 FIND v(dout0_47) AT=880.025n

.meas tran vdout0_48ck1750 FIND v(dout0_48) AT=880.025n

.meas tran vdout0_49ck1750 FIND v(dout0_49) AT=880.025n

.meas tran vdout0_50ck1750 FIND v(dout0_50) AT=880.025n

.meas tran vdout0_51ck1750 FIND v(dout0_51) AT=880.025n

.meas tran vdout0_52ck1750 FIND v(dout0_52) AT=880.025n

.meas tran vdout0_53ck1750 FIND v(dout0_53) AT=880.025n

.meas tran vdout0_54ck1750 FIND v(dout0_54) AT=880.025n

.meas tran vdout0_55ck1750 FIND v(dout0_55) AT=880.025n

.meas tran vdout0_56ck1750 FIND v(dout0_56) AT=880.025n

.meas tran vdout0_57ck1750 FIND v(dout0_57) AT=880.025n

.meas tran vdout0_58ck1750 FIND v(dout0_58) AT=880.025n

.meas tran vdout0_59ck1750 FIND v(dout0_59) AT=880.025n

.meas tran vdout0_60ck1750 FIND v(dout0_60) AT=880.025n

.meas tran vdout0_61ck1750 FIND v(dout0_61) AT=880.025n

.meas tran vdout0_62ck1750 FIND v(dout0_62) AT=880.025n

.meas tran vdout0_63ck1750 FIND v(dout0_63) AT=880.025n

.meas tran vdout0_64ck1750 FIND v(dout0_64) AT=880.025n

.meas tran vdout0_65ck1750 FIND v(dout0_65) AT=880.025n

.meas tran vdout0_66ck1750 FIND v(dout0_66) AT=880.025n

.meas tran vdout0_67ck1750 FIND v(dout0_67) AT=880.025n

.meas tran vdout0_68ck1750 FIND v(dout0_68) AT=880.025n

.meas tran vdout0_69ck1750 FIND v(dout0_69) AT=880.025n

.meas tran vdout0_70ck1750 FIND v(dout0_70) AT=880.025n

.meas tran vdout0_71ck1750 FIND v(dout0_71) AT=880.025n

.meas tran vdout0_72ck1750 FIND v(dout0_72) AT=880.025n

.meas tran vdout0_73ck1750 FIND v(dout0_73) AT=880.025n

.meas tran vdout0_74ck1750 FIND v(dout0_74) AT=880.025n

.meas tran vdout0_75ck1750 FIND v(dout0_75) AT=880.025n

.meas tran vdout0_76ck1750 FIND v(dout0_76) AT=880.025n

.meas tran vdout0_77ck1750 FIND v(dout0_77) AT=880.025n

.meas tran vdout0_78ck1750 FIND v(dout0_78) AT=880.025n

.meas tran vdout0_79ck1750 FIND v(dout0_79) AT=880.025n

.meas tran vdout0_80ck1750 FIND v(dout0_80) AT=880.025n

.meas tran vdout0_81ck1750 FIND v(dout0_81) AT=880.025n

.meas tran vdout0_82ck1750 FIND v(dout0_82) AT=880.025n

.meas tran vdout0_83ck1750 FIND v(dout0_83) AT=880.025n

.meas tran vdout0_84ck1750 FIND v(dout0_84) AT=880.025n

.meas tran vdout0_85ck1750 FIND v(dout0_85) AT=880.025n

.meas tran vdout0_86ck1750 FIND v(dout0_86) AT=880.025n

.meas tran vdout0_87ck1750 FIND v(dout0_87) AT=880.025n

.meas tran vdout0_88ck1750 FIND v(dout0_88) AT=880.025n

.meas tran vdout0_89ck1750 FIND v(dout0_89) AT=880.025n

.meas tran vdout0_90ck1750 FIND v(dout0_90) AT=880.025n

.meas tran vdout0_91ck1750 FIND v(dout0_91) AT=880.025n

.meas tran vdout0_92ck1750 FIND v(dout0_92) AT=880.025n

.meas tran vdout0_93ck1750 FIND v(dout0_93) AT=880.025n

.meas tran vdout0_94ck1750 FIND v(dout0_94) AT=880.025n

.meas tran vdout0_95ck1750 FIND v(dout0_95) AT=880.025n

.meas tran vdout0_96ck1750 FIND v(dout0_96) AT=880.025n

.meas tran vdout0_97ck1750 FIND v(dout0_97) AT=880.025n

.meas tran vdout0_98ck1750 FIND v(dout0_98) AT=880.025n

.meas tran vdout0_99ck1750 FIND v(dout0_99) AT=880.025n

.meas tran vdout0_100ck1750 FIND v(dout0_100) AT=880.025n

.meas tran vdout0_101ck1750 FIND v(dout0_101) AT=880.025n

.meas tran vdout0_102ck1750 FIND v(dout0_102) AT=880.025n

.meas tran vdout0_103ck1750 FIND v(dout0_103) AT=880.025n

.meas tran vdout0_104ck1750 FIND v(dout0_104) AT=880.025n

.meas tran vdout0_105ck1750 FIND v(dout0_105) AT=880.025n

.meas tran vdout0_106ck1750 FIND v(dout0_106) AT=880.025n

.meas tran vdout0_107ck1750 FIND v(dout0_107) AT=880.025n

.meas tran vdout0_108ck1750 FIND v(dout0_108) AT=880.025n

.meas tran vdout0_109ck1750 FIND v(dout0_109) AT=880.025n

.meas tran vdout0_110ck1750 FIND v(dout0_110) AT=880.025n

.meas tran vdout0_111ck1750 FIND v(dout0_111) AT=880.025n

.meas tran vdout0_112ck1750 FIND v(dout0_112) AT=880.025n

.meas tran vdout0_113ck1750 FIND v(dout0_113) AT=880.025n

.meas tran vdout0_114ck1750 FIND v(dout0_114) AT=880.025n

.meas tran vdout0_115ck1750 FIND v(dout0_115) AT=880.025n

.meas tran vdout0_116ck1750 FIND v(dout0_116) AT=880.025n

.meas tran vdout0_117ck1750 FIND v(dout0_117) AT=880.025n

.meas tran vdout0_118ck1750 FIND v(dout0_118) AT=880.025n

.meas tran vdout0_119ck1750 FIND v(dout0_119) AT=880.025n

.meas tran vdout0_120ck1750 FIND v(dout0_120) AT=880.025n

.meas tran vdout0_121ck1750 FIND v(dout0_121) AT=880.025n

.meas tran vdout0_122ck1750 FIND v(dout0_122) AT=880.025n

.meas tran vdout0_123ck1750 FIND v(dout0_123) AT=880.025n

.meas tran vdout0_124ck1750 FIND v(dout0_124) AT=880.025n

.meas tran vdout0_125ck1750 FIND v(dout0_125) AT=880.025n

.meas tran vdout0_126ck1750 FIND v(dout0_126) AT=880.025n

.meas tran vdout0_127ck1750 FIND v(dout0_127) AT=880.025n

.meas tran vdout0_128ck1750 FIND v(dout0_128) AT=880.025n

.meas tran vdout0_129ck1750 FIND v(dout0_129) AT=880.025n

.meas tran vdout0_130ck1750 FIND v(dout0_130) AT=880.025n

.meas tran vdout0_131ck1750 FIND v(dout0_131) AT=880.025n

.meas tran vdout0_132ck1750 FIND v(dout0_132) AT=880.025n

.meas tran vdout0_133ck1750 FIND v(dout0_133) AT=880.025n

.meas tran vdout0_134ck1750 FIND v(dout0_134) AT=880.025n

.meas tran vdout0_135ck1750 FIND v(dout0_135) AT=880.025n

.meas tran vdout0_136ck1750 FIND v(dout0_136) AT=880.025n

.meas tran vdout0_137ck1750 FIND v(dout0_137) AT=880.025n

.meas tran vdout0_138ck1750 FIND v(dout0_138) AT=880.025n

.meas tran vdout0_139ck1750 FIND v(dout0_139) AT=880.025n

.meas tran vdout0_140ck1750 FIND v(dout0_140) AT=880.025n

.meas tran vdout0_141ck1750 FIND v(dout0_141) AT=880.025n

.meas tran vdout0_142ck1750 FIND v(dout0_142) AT=880.025n

.meas tran vdout0_143ck1750 FIND v(dout0_143) AT=880.025n

.meas tran vdout0_144ck1750 FIND v(dout0_144) AT=880.025n

.meas tran vdout0_145ck1750 FIND v(dout0_145) AT=880.025n

.meas tran vdout0_146ck1750 FIND v(dout0_146) AT=880.025n

.meas tran vdout0_147ck1750 FIND v(dout0_147) AT=880.025n

.meas tran vdout0_148ck1750 FIND v(dout0_148) AT=880.025n

.meas tran vdout0_149ck1750 FIND v(dout0_149) AT=880.025n

.meas tran vdout0_0ck1760 FIND v(dout0_0) AT=885.025n

.meas tran vdout0_1ck1760 FIND v(dout0_1) AT=885.025n

.meas tran vdout0_2ck1760 FIND v(dout0_2) AT=885.025n

.meas tran vdout0_3ck1760 FIND v(dout0_3) AT=885.025n

.meas tran vdout0_4ck1760 FIND v(dout0_4) AT=885.025n

.meas tran vdout0_5ck1760 FIND v(dout0_5) AT=885.025n

.meas tran vdout0_6ck1760 FIND v(dout0_6) AT=885.025n

.meas tran vdout0_7ck1760 FIND v(dout0_7) AT=885.025n

.meas tran vdout0_8ck1760 FIND v(dout0_8) AT=885.025n

.meas tran vdout0_9ck1760 FIND v(dout0_9) AT=885.025n

.meas tran vdout0_10ck1760 FIND v(dout0_10) AT=885.025n

.meas tran vdout0_11ck1760 FIND v(dout0_11) AT=885.025n

.meas tran vdout0_12ck1760 FIND v(dout0_12) AT=885.025n

.meas tran vdout0_13ck1760 FIND v(dout0_13) AT=885.025n

.meas tran vdout0_14ck1760 FIND v(dout0_14) AT=885.025n

.meas tran vdout0_15ck1760 FIND v(dout0_15) AT=885.025n

.meas tran vdout0_16ck1760 FIND v(dout0_16) AT=885.025n

.meas tran vdout0_17ck1760 FIND v(dout0_17) AT=885.025n

.meas tran vdout0_18ck1760 FIND v(dout0_18) AT=885.025n

.meas tran vdout0_19ck1760 FIND v(dout0_19) AT=885.025n

.meas tran vdout0_20ck1760 FIND v(dout0_20) AT=885.025n

.meas tran vdout0_21ck1760 FIND v(dout0_21) AT=885.025n

.meas tran vdout0_22ck1760 FIND v(dout0_22) AT=885.025n

.meas tran vdout0_23ck1760 FIND v(dout0_23) AT=885.025n

.meas tran vdout0_24ck1760 FIND v(dout0_24) AT=885.025n

.meas tran vdout0_25ck1760 FIND v(dout0_25) AT=885.025n

.meas tran vdout0_26ck1760 FIND v(dout0_26) AT=885.025n

.meas tran vdout0_27ck1760 FIND v(dout0_27) AT=885.025n

.meas tran vdout0_28ck1760 FIND v(dout0_28) AT=885.025n

.meas tran vdout0_29ck1760 FIND v(dout0_29) AT=885.025n

.meas tran vdout0_30ck1760 FIND v(dout0_30) AT=885.025n

.meas tran vdout0_31ck1760 FIND v(dout0_31) AT=885.025n

.meas tran vdout0_32ck1760 FIND v(dout0_32) AT=885.025n

.meas tran vdout0_33ck1760 FIND v(dout0_33) AT=885.025n

.meas tran vdout0_34ck1760 FIND v(dout0_34) AT=885.025n

.meas tran vdout0_35ck1760 FIND v(dout0_35) AT=885.025n

.meas tran vdout0_36ck1760 FIND v(dout0_36) AT=885.025n

.meas tran vdout0_37ck1760 FIND v(dout0_37) AT=885.025n

.meas tran vdout0_38ck1760 FIND v(dout0_38) AT=885.025n

.meas tran vdout0_39ck1760 FIND v(dout0_39) AT=885.025n

.meas tran vdout0_40ck1760 FIND v(dout0_40) AT=885.025n

.meas tran vdout0_41ck1760 FIND v(dout0_41) AT=885.025n

.meas tran vdout0_42ck1760 FIND v(dout0_42) AT=885.025n

.meas tran vdout0_43ck1760 FIND v(dout0_43) AT=885.025n

.meas tran vdout0_44ck1760 FIND v(dout0_44) AT=885.025n

.meas tran vdout0_45ck1760 FIND v(dout0_45) AT=885.025n

.meas tran vdout0_46ck1760 FIND v(dout0_46) AT=885.025n

.meas tran vdout0_47ck1760 FIND v(dout0_47) AT=885.025n

.meas tran vdout0_48ck1760 FIND v(dout0_48) AT=885.025n

.meas tran vdout0_49ck1760 FIND v(dout0_49) AT=885.025n

.meas tran vdout0_50ck1760 FIND v(dout0_50) AT=885.025n

.meas tran vdout0_51ck1760 FIND v(dout0_51) AT=885.025n

.meas tran vdout0_52ck1760 FIND v(dout0_52) AT=885.025n

.meas tran vdout0_53ck1760 FIND v(dout0_53) AT=885.025n

.meas tran vdout0_54ck1760 FIND v(dout0_54) AT=885.025n

.meas tran vdout0_55ck1760 FIND v(dout0_55) AT=885.025n

.meas tran vdout0_56ck1760 FIND v(dout0_56) AT=885.025n

.meas tran vdout0_57ck1760 FIND v(dout0_57) AT=885.025n

.meas tran vdout0_58ck1760 FIND v(dout0_58) AT=885.025n

.meas tran vdout0_59ck1760 FIND v(dout0_59) AT=885.025n

.meas tran vdout0_60ck1760 FIND v(dout0_60) AT=885.025n

.meas tran vdout0_61ck1760 FIND v(dout0_61) AT=885.025n

.meas tran vdout0_62ck1760 FIND v(dout0_62) AT=885.025n

.meas tran vdout0_63ck1760 FIND v(dout0_63) AT=885.025n

.meas tran vdout0_64ck1760 FIND v(dout0_64) AT=885.025n

.meas tran vdout0_65ck1760 FIND v(dout0_65) AT=885.025n

.meas tran vdout0_66ck1760 FIND v(dout0_66) AT=885.025n

.meas tran vdout0_67ck1760 FIND v(dout0_67) AT=885.025n

.meas tran vdout0_68ck1760 FIND v(dout0_68) AT=885.025n

.meas tran vdout0_69ck1760 FIND v(dout0_69) AT=885.025n

.meas tran vdout0_70ck1760 FIND v(dout0_70) AT=885.025n

.meas tran vdout0_71ck1760 FIND v(dout0_71) AT=885.025n

.meas tran vdout0_72ck1760 FIND v(dout0_72) AT=885.025n

.meas tran vdout0_73ck1760 FIND v(dout0_73) AT=885.025n

.meas tran vdout0_74ck1760 FIND v(dout0_74) AT=885.025n

.meas tran vdout0_75ck1760 FIND v(dout0_75) AT=885.025n

.meas tran vdout0_76ck1760 FIND v(dout0_76) AT=885.025n

.meas tran vdout0_77ck1760 FIND v(dout0_77) AT=885.025n

.meas tran vdout0_78ck1760 FIND v(dout0_78) AT=885.025n

.meas tran vdout0_79ck1760 FIND v(dout0_79) AT=885.025n

.meas tran vdout0_80ck1760 FIND v(dout0_80) AT=885.025n

.meas tran vdout0_81ck1760 FIND v(dout0_81) AT=885.025n

.meas tran vdout0_82ck1760 FIND v(dout0_82) AT=885.025n

.meas tran vdout0_83ck1760 FIND v(dout0_83) AT=885.025n

.meas tran vdout0_84ck1760 FIND v(dout0_84) AT=885.025n

.meas tran vdout0_85ck1760 FIND v(dout0_85) AT=885.025n

.meas tran vdout0_86ck1760 FIND v(dout0_86) AT=885.025n

.meas tran vdout0_87ck1760 FIND v(dout0_87) AT=885.025n

.meas tran vdout0_88ck1760 FIND v(dout0_88) AT=885.025n

.meas tran vdout0_89ck1760 FIND v(dout0_89) AT=885.025n

.meas tran vdout0_90ck1760 FIND v(dout0_90) AT=885.025n

.meas tran vdout0_91ck1760 FIND v(dout0_91) AT=885.025n

.meas tran vdout0_92ck1760 FIND v(dout0_92) AT=885.025n

.meas tran vdout0_93ck1760 FIND v(dout0_93) AT=885.025n

.meas tran vdout0_94ck1760 FIND v(dout0_94) AT=885.025n

.meas tran vdout0_95ck1760 FIND v(dout0_95) AT=885.025n

.meas tran vdout0_96ck1760 FIND v(dout0_96) AT=885.025n

.meas tran vdout0_97ck1760 FIND v(dout0_97) AT=885.025n

.meas tran vdout0_98ck1760 FIND v(dout0_98) AT=885.025n

.meas tran vdout0_99ck1760 FIND v(dout0_99) AT=885.025n

.meas tran vdout0_100ck1760 FIND v(dout0_100) AT=885.025n

.meas tran vdout0_101ck1760 FIND v(dout0_101) AT=885.025n

.meas tran vdout0_102ck1760 FIND v(dout0_102) AT=885.025n

.meas tran vdout0_103ck1760 FIND v(dout0_103) AT=885.025n

.meas tran vdout0_104ck1760 FIND v(dout0_104) AT=885.025n

.meas tran vdout0_105ck1760 FIND v(dout0_105) AT=885.025n

.meas tran vdout0_106ck1760 FIND v(dout0_106) AT=885.025n

.meas tran vdout0_107ck1760 FIND v(dout0_107) AT=885.025n

.meas tran vdout0_108ck1760 FIND v(dout0_108) AT=885.025n

.meas tran vdout0_109ck1760 FIND v(dout0_109) AT=885.025n

.meas tran vdout0_110ck1760 FIND v(dout0_110) AT=885.025n

.meas tran vdout0_111ck1760 FIND v(dout0_111) AT=885.025n

.meas tran vdout0_112ck1760 FIND v(dout0_112) AT=885.025n

.meas tran vdout0_113ck1760 FIND v(dout0_113) AT=885.025n

.meas tran vdout0_114ck1760 FIND v(dout0_114) AT=885.025n

.meas tran vdout0_115ck1760 FIND v(dout0_115) AT=885.025n

.meas tran vdout0_116ck1760 FIND v(dout0_116) AT=885.025n

.meas tran vdout0_117ck1760 FIND v(dout0_117) AT=885.025n

.meas tran vdout0_118ck1760 FIND v(dout0_118) AT=885.025n

.meas tran vdout0_119ck1760 FIND v(dout0_119) AT=885.025n

.meas tran vdout0_120ck1760 FIND v(dout0_120) AT=885.025n

.meas tran vdout0_121ck1760 FIND v(dout0_121) AT=885.025n

.meas tran vdout0_122ck1760 FIND v(dout0_122) AT=885.025n

.meas tran vdout0_123ck1760 FIND v(dout0_123) AT=885.025n

.meas tran vdout0_124ck1760 FIND v(dout0_124) AT=885.025n

.meas tran vdout0_125ck1760 FIND v(dout0_125) AT=885.025n

.meas tran vdout0_126ck1760 FIND v(dout0_126) AT=885.025n

.meas tran vdout0_127ck1760 FIND v(dout0_127) AT=885.025n

.meas tran vdout0_128ck1760 FIND v(dout0_128) AT=885.025n

.meas tran vdout0_129ck1760 FIND v(dout0_129) AT=885.025n

.meas tran vdout0_130ck1760 FIND v(dout0_130) AT=885.025n

.meas tran vdout0_131ck1760 FIND v(dout0_131) AT=885.025n

.meas tran vdout0_132ck1760 FIND v(dout0_132) AT=885.025n

.meas tran vdout0_133ck1760 FIND v(dout0_133) AT=885.025n

.meas tran vdout0_134ck1760 FIND v(dout0_134) AT=885.025n

.meas tran vdout0_135ck1760 FIND v(dout0_135) AT=885.025n

.meas tran vdout0_136ck1760 FIND v(dout0_136) AT=885.025n

.meas tran vdout0_137ck1760 FIND v(dout0_137) AT=885.025n

.meas tran vdout0_138ck1760 FIND v(dout0_138) AT=885.025n

.meas tran vdout0_139ck1760 FIND v(dout0_139) AT=885.025n

.meas tran vdout0_140ck1760 FIND v(dout0_140) AT=885.025n

.meas tran vdout0_141ck1760 FIND v(dout0_141) AT=885.025n

.meas tran vdout0_142ck1760 FIND v(dout0_142) AT=885.025n

.meas tran vdout0_143ck1760 FIND v(dout0_143) AT=885.025n

.meas tran vdout0_144ck1760 FIND v(dout0_144) AT=885.025n

.meas tran vdout0_145ck1760 FIND v(dout0_145) AT=885.025n

.meas tran vdout0_146ck1760 FIND v(dout0_146) AT=885.025n

.meas tran vdout0_147ck1760 FIND v(dout0_147) AT=885.025n

.meas tran vdout0_148ck1760 FIND v(dout0_148) AT=885.025n

.meas tran vdout0_149ck1760 FIND v(dout0_149) AT=885.025n

.meas tran vdout0_0ck1770 FIND v(dout0_0) AT=890.025n

.meas tran vdout0_1ck1770 FIND v(dout0_1) AT=890.025n

.meas tran vdout0_2ck1770 FIND v(dout0_2) AT=890.025n

.meas tran vdout0_3ck1770 FIND v(dout0_3) AT=890.025n

.meas tran vdout0_4ck1770 FIND v(dout0_4) AT=890.025n

.meas tran vdout0_5ck1770 FIND v(dout0_5) AT=890.025n

.meas tran vdout0_6ck1770 FIND v(dout0_6) AT=890.025n

.meas tran vdout0_7ck1770 FIND v(dout0_7) AT=890.025n

.meas tran vdout0_8ck1770 FIND v(dout0_8) AT=890.025n

.meas tran vdout0_9ck1770 FIND v(dout0_9) AT=890.025n

.meas tran vdout0_10ck1770 FIND v(dout0_10) AT=890.025n

.meas tran vdout0_11ck1770 FIND v(dout0_11) AT=890.025n

.meas tran vdout0_12ck1770 FIND v(dout0_12) AT=890.025n

.meas tran vdout0_13ck1770 FIND v(dout0_13) AT=890.025n

.meas tran vdout0_14ck1770 FIND v(dout0_14) AT=890.025n

.meas tran vdout0_15ck1770 FIND v(dout0_15) AT=890.025n

.meas tran vdout0_16ck1770 FIND v(dout0_16) AT=890.025n

.meas tran vdout0_17ck1770 FIND v(dout0_17) AT=890.025n

.meas tran vdout0_18ck1770 FIND v(dout0_18) AT=890.025n

.meas tran vdout0_19ck1770 FIND v(dout0_19) AT=890.025n

.meas tran vdout0_20ck1770 FIND v(dout0_20) AT=890.025n

.meas tran vdout0_21ck1770 FIND v(dout0_21) AT=890.025n

.meas tran vdout0_22ck1770 FIND v(dout0_22) AT=890.025n

.meas tran vdout0_23ck1770 FIND v(dout0_23) AT=890.025n

.meas tran vdout0_24ck1770 FIND v(dout0_24) AT=890.025n

.meas tran vdout0_25ck1770 FIND v(dout0_25) AT=890.025n

.meas tran vdout0_26ck1770 FIND v(dout0_26) AT=890.025n

.meas tran vdout0_27ck1770 FIND v(dout0_27) AT=890.025n

.meas tran vdout0_28ck1770 FIND v(dout0_28) AT=890.025n

.meas tran vdout0_29ck1770 FIND v(dout0_29) AT=890.025n

.meas tran vdout0_30ck1770 FIND v(dout0_30) AT=890.025n

.meas tran vdout0_31ck1770 FIND v(dout0_31) AT=890.025n

.meas tran vdout0_32ck1770 FIND v(dout0_32) AT=890.025n

.meas tran vdout0_33ck1770 FIND v(dout0_33) AT=890.025n

.meas tran vdout0_34ck1770 FIND v(dout0_34) AT=890.025n

.meas tran vdout0_35ck1770 FIND v(dout0_35) AT=890.025n

.meas tran vdout0_36ck1770 FIND v(dout0_36) AT=890.025n

.meas tran vdout0_37ck1770 FIND v(dout0_37) AT=890.025n

.meas tran vdout0_38ck1770 FIND v(dout0_38) AT=890.025n

.meas tran vdout0_39ck1770 FIND v(dout0_39) AT=890.025n

.meas tran vdout0_40ck1770 FIND v(dout0_40) AT=890.025n

.meas tran vdout0_41ck1770 FIND v(dout0_41) AT=890.025n

.meas tran vdout0_42ck1770 FIND v(dout0_42) AT=890.025n

.meas tran vdout0_43ck1770 FIND v(dout0_43) AT=890.025n

.meas tran vdout0_44ck1770 FIND v(dout0_44) AT=890.025n

.meas tran vdout0_45ck1770 FIND v(dout0_45) AT=890.025n

.meas tran vdout0_46ck1770 FIND v(dout0_46) AT=890.025n

.meas tran vdout0_47ck1770 FIND v(dout0_47) AT=890.025n

.meas tran vdout0_48ck1770 FIND v(dout0_48) AT=890.025n

.meas tran vdout0_49ck1770 FIND v(dout0_49) AT=890.025n

.meas tran vdout0_50ck1770 FIND v(dout0_50) AT=890.025n

.meas tran vdout0_51ck1770 FIND v(dout0_51) AT=890.025n

.meas tran vdout0_52ck1770 FIND v(dout0_52) AT=890.025n

.meas tran vdout0_53ck1770 FIND v(dout0_53) AT=890.025n

.meas tran vdout0_54ck1770 FIND v(dout0_54) AT=890.025n

.meas tran vdout0_55ck1770 FIND v(dout0_55) AT=890.025n

.meas tran vdout0_56ck1770 FIND v(dout0_56) AT=890.025n

.meas tran vdout0_57ck1770 FIND v(dout0_57) AT=890.025n

.meas tran vdout0_58ck1770 FIND v(dout0_58) AT=890.025n

.meas tran vdout0_59ck1770 FIND v(dout0_59) AT=890.025n

.meas tran vdout0_60ck1770 FIND v(dout0_60) AT=890.025n

.meas tran vdout0_61ck1770 FIND v(dout0_61) AT=890.025n

.meas tran vdout0_62ck1770 FIND v(dout0_62) AT=890.025n

.meas tran vdout0_63ck1770 FIND v(dout0_63) AT=890.025n

.meas tran vdout0_64ck1770 FIND v(dout0_64) AT=890.025n

.meas tran vdout0_65ck1770 FIND v(dout0_65) AT=890.025n

.meas tran vdout0_66ck1770 FIND v(dout0_66) AT=890.025n

.meas tran vdout0_67ck1770 FIND v(dout0_67) AT=890.025n

.meas tran vdout0_68ck1770 FIND v(dout0_68) AT=890.025n

.meas tran vdout0_69ck1770 FIND v(dout0_69) AT=890.025n

.meas tran vdout0_70ck1770 FIND v(dout0_70) AT=890.025n

.meas tran vdout0_71ck1770 FIND v(dout0_71) AT=890.025n

.meas tran vdout0_72ck1770 FIND v(dout0_72) AT=890.025n

.meas tran vdout0_73ck1770 FIND v(dout0_73) AT=890.025n

.meas tran vdout0_74ck1770 FIND v(dout0_74) AT=890.025n

.meas tran vdout0_75ck1770 FIND v(dout0_75) AT=890.025n

.meas tran vdout0_76ck1770 FIND v(dout0_76) AT=890.025n

.meas tran vdout0_77ck1770 FIND v(dout0_77) AT=890.025n

.meas tran vdout0_78ck1770 FIND v(dout0_78) AT=890.025n

.meas tran vdout0_79ck1770 FIND v(dout0_79) AT=890.025n

.meas tran vdout0_80ck1770 FIND v(dout0_80) AT=890.025n

.meas tran vdout0_81ck1770 FIND v(dout0_81) AT=890.025n

.meas tran vdout0_82ck1770 FIND v(dout0_82) AT=890.025n

.meas tran vdout0_83ck1770 FIND v(dout0_83) AT=890.025n

.meas tran vdout0_84ck1770 FIND v(dout0_84) AT=890.025n

.meas tran vdout0_85ck1770 FIND v(dout0_85) AT=890.025n

.meas tran vdout0_86ck1770 FIND v(dout0_86) AT=890.025n

.meas tran vdout0_87ck1770 FIND v(dout0_87) AT=890.025n

.meas tran vdout0_88ck1770 FIND v(dout0_88) AT=890.025n

.meas tran vdout0_89ck1770 FIND v(dout0_89) AT=890.025n

.meas tran vdout0_90ck1770 FIND v(dout0_90) AT=890.025n

.meas tran vdout0_91ck1770 FIND v(dout0_91) AT=890.025n

.meas tran vdout0_92ck1770 FIND v(dout0_92) AT=890.025n

.meas tran vdout0_93ck1770 FIND v(dout0_93) AT=890.025n

.meas tran vdout0_94ck1770 FIND v(dout0_94) AT=890.025n

.meas tran vdout0_95ck1770 FIND v(dout0_95) AT=890.025n

.meas tran vdout0_96ck1770 FIND v(dout0_96) AT=890.025n

.meas tran vdout0_97ck1770 FIND v(dout0_97) AT=890.025n

.meas tran vdout0_98ck1770 FIND v(dout0_98) AT=890.025n

.meas tran vdout0_99ck1770 FIND v(dout0_99) AT=890.025n

.meas tran vdout0_100ck1770 FIND v(dout0_100) AT=890.025n

.meas tran vdout0_101ck1770 FIND v(dout0_101) AT=890.025n

.meas tran vdout0_102ck1770 FIND v(dout0_102) AT=890.025n

.meas tran vdout0_103ck1770 FIND v(dout0_103) AT=890.025n

.meas tran vdout0_104ck1770 FIND v(dout0_104) AT=890.025n

.meas tran vdout0_105ck1770 FIND v(dout0_105) AT=890.025n

.meas tran vdout0_106ck1770 FIND v(dout0_106) AT=890.025n

.meas tran vdout0_107ck1770 FIND v(dout0_107) AT=890.025n

.meas tran vdout0_108ck1770 FIND v(dout0_108) AT=890.025n

.meas tran vdout0_109ck1770 FIND v(dout0_109) AT=890.025n

.meas tran vdout0_110ck1770 FIND v(dout0_110) AT=890.025n

.meas tran vdout0_111ck1770 FIND v(dout0_111) AT=890.025n

.meas tran vdout0_112ck1770 FIND v(dout0_112) AT=890.025n

.meas tran vdout0_113ck1770 FIND v(dout0_113) AT=890.025n

.meas tran vdout0_114ck1770 FIND v(dout0_114) AT=890.025n

.meas tran vdout0_115ck1770 FIND v(dout0_115) AT=890.025n

.meas tran vdout0_116ck1770 FIND v(dout0_116) AT=890.025n

.meas tran vdout0_117ck1770 FIND v(dout0_117) AT=890.025n

.meas tran vdout0_118ck1770 FIND v(dout0_118) AT=890.025n

.meas tran vdout0_119ck1770 FIND v(dout0_119) AT=890.025n

.meas tran vdout0_120ck1770 FIND v(dout0_120) AT=890.025n

.meas tran vdout0_121ck1770 FIND v(dout0_121) AT=890.025n

.meas tran vdout0_122ck1770 FIND v(dout0_122) AT=890.025n

.meas tran vdout0_123ck1770 FIND v(dout0_123) AT=890.025n

.meas tran vdout0_124ck1770 FIND v(dout0_124) AT=890.025n

.meas tran vdout0_125ck1770 FIND v(dout0_125) AT=890.025n

.meas tran vdout0_126ck1770 FIND v(dout0_126) AT=890.025n

.meas tran vdout0_127ck1770 FIND v(dout0_127) AT=890.025n

.meas tran vdout0_128ck1770 FIND v(dout0_128) AT=890.025n

.meas tran vdout0_129ck1770 FIND v(dout0_129) AT=890.025n

.meas tran vdout0_130ck1770 FIND v(dout0_130) AT=890.025n

.meas tran vdout0_131ck1770 FIND v(dout0_131) AT=890.025n

.meas tran vdout0_132ck1770 FIND v(dout0_132) AT=890.025n

.meas tran vdout0_133ck1770 FIND v(dout0_133) AT=890.025n

.meas tran vdout0_134ck1770 FIND v(dout0_134) AT=890.025n

.meas tran vdout0_135ck1770 FIND v(dout0_135) AT=890.025n

.meas tran vdout0_136ck1770 FIND v(dout0_136) AT=890.025n

.meas tran vdout0_137ck1770 FIND v(dout0_137) AT=890.025n

.meas tran vdout0_138ck1770 FIND v(dout0_138) AT=890.025n

.meas tran vdout0_139ck1770 FIND v(dout0_139) AT=890.025n

.meas tran vdout0_140ck1770 FIND v(dout0_140) AT=890.025n

.meas tran vdout0_141ck1770 FIND v(dout0_141) AT=890.025n

.meas tran vdout0_142ck1770 FIND v(dout0_142) AT=890.025n

.meas tran vdout0_143ck1770 FIND v(dout0_143) AT=890.025n

.meas tran vdout0_144ck1770 FIND v(dout0_144) AT=890.025n

.meas tran vdout0_145ck1770 FIND v(dout0_145) AT=890.025n

.meas tran vdout0_146ck1770 FIND v(dout0_146) AT=890.025n

.meas tran vdout0_147ck1770 FIND v(dout0_147) AT=890.025n

.meas tran vdout0_148ck1770 FIND v(dout0_148) AT=890.025n

.meas tran vdout0_149ck1770 FIND v(dout0_149) AT=890.025n

.meas tran vdout0_0ck1780 FIND v(dout0_0) AT=895.025n

.meas tran vdout0_1ck1780 FIND v(dout0_1) AT=895.025n

.meas tran vdout0_2ck1780 FIND v(dout0_2) AT=895.025n

.meas tran vdout0_3ck1780 FIND v(dout0_3) AT=895.025n

.meas tran vdout0_4ck1780 FIND v(dout0_4) AT=895.025n

.meas tran vdout0_5ck1780 FIND v(dout0_5) AT=895.025n

.meas tran vdout0_6ck1780 FIND v(dout0_6) AT=895.025n

.meas tran vdout0_7ck1780 FIND v(dout0_7) AT=895.025n

.meas tran vdout0_8ck1780 FIND v(dout0_8) AT=895.025n

.meas tran vdout0_9ck1780 FIND v(dout0_9) AT=895.025n

.meas tran vdout0_10ck1780 FIND v(dout0_10) AT=895.025n

.meas tran vdout0_11ck1780 FIND v(dout0_11) AT=895.025n

.meas tran vdout0_12ck1780 FIND v(dout0_12) AT=895.025n

.meas tran vdout0_13ck1780 FIND v(dout0_13) AT=895.025n

.meas tran vdout0_14ck1780 FIND v(dout0_14) AT=895.025n

.meas tran vdout0_15ck1780 FIND v(dout0_15) AT=895.025n

.meas tran vdout0_16ck1780 FIND v(dout0_16) AT=895.025n

.meas tran vdout0_17ck1780 FIND v(dout0_17) AT=895.025n

.meas tran vdout0_18ck1780 FIND v(dout0_18) AT=895.025n

.meas tran vdout0_19ck1780 FIND v(dout0_19) AT=895.025n

.meas tran vdout0_20ck1780 FIND v(dout0_20) AT=895.025n

.meas tran vdout0_21ck1780 FIND v(dout0_21) AT=895.025n

.meas tran vdout0_22ck1780 FIND v(dout0_22) AT=895.025n

.meas tran vdout0_23ck1780 FIND v(dout0_23) AT=895.025n

.meas tran vdout0_24ck1780 FIND v(dout0_24) AT=895.025n

.meas tran vdout0_25ck1780 FIND v(dout0_25) AT=895.025n

.meas tran vdout0_26ck1780 FIND v(dout0_26) AT=895.025n

.meas tran vdout0_27ck1780 FIND v(dout0_27) AT=895.025n

.meas tran vdout0_28ck1780 FIND v(dout0_28) AT=895.025n

.meas tran vdout0_29ck1780 FIND v(dout0_29) AT=895.025n

.meas tran vdout0_30ck1780 FIND v(dout0_30) AT=895.025n

.meas tran vdout0_31ck1780 FIND v(dout0_31) AT=895.025n

.meas tran vdout0_32ck1780 FIND v(dout0_32) AT=895.025n

.meas tran vdout0_33ck1780 FIND v(dout0_33) AT=895.025n

.meas tran vdout0_34ck1780 FIND v(dout0_34) AT=895.025n

.meas tran vdout0_35ck1780 FIND v(dout0_35) AT=895.025n

.meas tran vdout0_36ck1780 FIND v(dout0_36) AT=895.025n

.meas tran vdout0_37ck1780 FIND v(dout0_37) AT=895.025n

.meas tran vdout0_38ck1780 FIND v(dout0_38) AT=895.025n

.meas tran vdout0_39ck1780 FIND v(dout0_39) AT=895.025n

.meas tran vdout0_40ck1780 FIND v(dout0_40) AT=895.025n

.meas tran vdout0_41ck1780 FIND v(dout0_41) AT=895.025n

.meas tran vdout0_42ck1780 FIND v(dout0_42) AT=895.025n

.meas tran vdout0_43ck1780 FIND v(dout0_43) AT=895.025n

.meas tran vdout0_44ck1780 FIND v(dout0_44) AT=895.025n

.meas tran vdout0_45ck1780 FIND v(dout0_45) AT=895.025n

.meas tran vdout0_46ck1780 FIND v(dout0_46) AT=895.025n

.meas tran vdout0_47ck1780 FIND v(dout0_47) AT=895.025n

.meas tran vdout0_48ck1780 FIND v(dout0_48) AT=895.025n

.meas tran vdout0_49ck1780 FIND v(dout0_49) AT=895.025n

.meas tran vdout0_50ck1780 FIND v(dout0_50) AT=895.025n

.meas tran vdout0_51ck1780 FIND v(dout0_51) AT=895.025n

.meas tran vdout0_52ck1780 FIND v(dout0_52) AT=895.025n

.meas tran vdout0_53ck1780 FIND v(dout0_53) AT=895.025n

.meas tran vdout0_54ck1780 FIND v(dout0_54) AT=895.025n

.meas tran vdout0_55ck1780 FIND v(dout0_55) AT=895.025n

.meas tran vdout0_56ck1780 FIND v(dout0_56) AT=895.025n

.meas tran vdout0_57ck1780 FIND v(dout0_57) AT=895.025n

.meas tran vdout0_58ck1780 FIND v(dout0_58) AT=895.025n

.meas tran vdout0_59ck1780 FIND v(dout0_59) AT=895.025n

.meas tran vdout0_60ck1780 FIND v(dout0_60) AT=895.025n

.meas tran vdout0_61ck1780 FIND v(dout0_61) AT=895.025n

.meas tran vdout0_62ck1780 FIND v(dout0_62) AT=895.025n

.meas tran vdout0_63ck1780 FIND v(dout0_63) AT=895.025n

.meas tran vdout0_64ck1780 FIND v(dout0_64) AT=895.025n

.meas tran vdout0_65ck1780 FIND v(dout0_65) AT=895.025n

.meas tran vdout0_66ck1780 FIND v(dout0_66) AT=895.025n

.meas tran vdout0_67ck1780 FIND v(dout0_67) AT=895.025n

.meas tran vdout0_68ck1780 FIND v(dout0_68) AT=895.025n

.meas tran vdout0_69ck1780 FIND v(dout0_69) AT=895.025n

.meas tran vdout0_70ck1780 FIND v(dout0_70) AT=895.025n

.meas tran vdout0_71ck1780 FIND v(dout0_71) AT=895.025n

.meas tran vdout0_72ck1780 FIND v(dout0_72) AT=895.025n

.meas tran vdout0_73ck1780 FIND v(dout0_73) AT=895.025n

.meas tran vdout0_74ck1780 FIND v(dout0_74) AT=895.025n

.meas tran vdout0_75ck1780 FIND v(dout0_75) AT=895.025n

.meas tran vdout0_76ck1780 FIND v(dout0_76) AT=895.025n

.meas tran vdout0_77ck1780 FIND v(dout0_77) AT=895.025n

.meas tran vdout0_78ck1780 FIND v(dout0_78) AT=895.025n

.meas tran vdout0_79ck1780 FIND v(dout0_79) AT=895.025n

.meas tran vdout0_80ck1780 FIND v(dout0_80) AT=895.025n

.meas tran vdout0_81ck1780 FIND v(dout0_81) AT=895.025n

.meas tran vdout0_82ck1780 FIND v(dout0_82) AT=895.025n

.meas tran vdout0_83ck1780 FIND v(dout0_83) AT=895.025n

.meas tran vdout0_84ck1780 FIND v(dout0_84) AT=895.025n

.meas tran vdout0_85ck1780 FIND v(dout0_85) AT=895.025n

.meas tran vdout0_86ck1780 FIND v(dout0_86) AT=895.025n

.meas tran vdout0_87ck1780 FIND v(dout0_87) AT=895.025n

.meas tran vdout0_88ck1780 FIND v(dout0_88) AT=895.025n

.meas tran vdout0_89ck1780 FIND v(dout0_89) AT=895.025n

.meas tran vdout0_90ck1780 FIND v(dout0_90) AT=895.025n

.meas tran vdout0_91ck1780 FIND v(dout0_91) AT=895.025n

.meas tran vdout0_92ck1780 FIND v(dout0_92) AT=895.025n

.meas tran vdout0_93ck1780 FIND v(dout0_93) AT=895.025n

.meas tran vdout0_94ck1780 FIND v(dout0_94) AT=895.025n

.meas tran vdout0_95ck1780 FIND v(dout0_95) AT=895.025n

.meas tran vdout0_96ck1780 FIND v(dout0_96) AT=895.025n

.meas tran vdout0_97ck1780 FIND v(dout0_97) AT=895.025n

.meas tran vdout0_98ck1780 FIND v(dout0_98) AT=895.025n

.meas tran vdout0_99ck1780 FIND v(dout0_99) AT=895.025n

.meas tran vdout0_100ck1780 FIND v(dout0_100) AT=895.025n

.meas tran vdout0_101ck1780 FIND v(dout0_101) AT=895.025n

.meas tran vdout0_102ck1780 FIND v(dout0_102) AT=895.025n

.meas tran vdout0_103ck1780 FIND v(dout0_103) AT=895.025n

.meas tran vdout0_104ck1780 FIND v(dout0_104) AT=895.025n

.meas tran vdout0_105ck1780 FIND v(dout0_105) AT=895.025n

.meas tran vdout0_106ck1780 FIND v(dout0_106) AT=895.025n

.meas tran vdout0_107ck1780 FIND v(dout0_107) AT=895.025n

.meas tran vdout0_108ck1780 FIND v(dout0_108) AT=895.025n

.meas tran vdout0_109ck1780 FIND v(dout0_109) AT=895.025n

.meas tran vdout0_110ck1780 FIND v(dout0_110) AT=895.025n

.meas tran vdout0_111ck1780 FIND v(dout0_111) AT=895.025n

.meas tran vdout0_112ck1780 FIND v(dout0_112) AT=895.025n

.meas tran vdout0_113ck1780 FIND v(dout0_113) AT=895.025n

.meas tran vdout0_114ck1780 FIND v(dout0_114) AT=895.025n

.meas tran vdout0_115ck1780 FIND v(dout0_115) AT=895.025n

.meas tran vdout0_116ck1780 FIND v(dout0_116) AT=895.025n

.meas tran vdout0_117ck1780 FIND v(dout0_117) AT=895.025n

.meas tran vdout0_118ck1780 FIND v(dout0_118) AT=895.025n

.meas tran vdout0_119ck1780 FIND v(dout0_119) AT=895.025n

.meas tran vdout0_120ck1780 FIND v(dout0_120) AT=895.025n

.meas tran vdout0_121ck1780 FIND v(dout0_121) AT=895.025n

.meas tran vdout0_122ck1780 FIND v(dout0_122) AT=895.025n

.meas tran vdout0_123ck1780 FIND v(dout0_123) AT=895.025n

.meas tran vdout0_124ck1780 FIND v(dout0_124) AT=895.025n

.meas tran vdout0_125ck1780 FIND v(dout0_125) AT=895.025n

.meas tran vdout0_126ck1780 FIND v(dout0_126) AT=895.025n

.meas tran vdout0_127ck1780 FIND v(dout0_127) AT=895.025n

.meas tran vdout0_128ck1780 FIND v(dout0_128) AT=895.025n

.meas tran vdout0_129ck1780 FIND v(dout0_129) AT=895.025n

.meas tran vdout0_130ck1780 FIND v(dout0_130) AT=895.025n

.meas tran vdout0_131ck1780 FIND v(dout0_131) AT=895.025n

.meas tran vdout0_132ck1780 FIND v(dout0_132) AT=895.025n

.meas tran vdout0_133ck1780 FIND v(dout0_133) AT=895.025n

.meas tran vdout0_134ck1780 FIND v(dout0_134) AT=895.025n

.meas tran vdout0_135ck1780 FIND v(dout0_135) AT=895.025n

.meas tran vdout0_136ck1780 FIND v(dout0_136) AT=895.025n

.meas tran vdout0_137ck1780 FIND v(dout0_137) AT=895.025n

.meas tran vdout0_138ck1780 FIND v(dout0_138) AT=895.025n

.meas tran vdout0_139ck1780 FIND v(dout0_139) AT=895.025n

.meas tran vdout0_140ck1780 FIND v(dout0_140) AT=895.025n

.meas tran vdout0_141ck1780 FIND v(dout0_141) AT=895.025n

.meas tran vdout0_142ck1780 FIND v(dout0_142) AT=895.025n

.meas tran vdout0_143ck1780 FIND v(dout0_143) AT=895.025n

.meas tran vdout0_144ck1780 FIND v(dout0_144) AT=895.025n

.meas tran vdout0_145ck1780 FIND v(dout0_145) AT=895.025n

.meas tran vdout0_146ck1780 FIND v(dout0_146) AT=895.025n

.meas tran vdout0_147ck1780 FIND v(dout0_147) AT=895.025n

.meas tran vdout0_148ck1780 FIND v(dout0_148) AT=895.025n

.meas tran vdout0_149ck1780 FIND v(dout0_149) AT=895.025n

.meas tran vdout0_0ck1790 FIND v(dout0_0) AT=900.025n

.meas tran vdout0_1ck1790 FIND v(dout0_1) AT=900.025n

.meas tran vdout0_2ck1790 FIND v(dout0_2) AT=900.025n

.meas tran vdout0_3ck1790 FIND v(dout0_3) AT=900.025n

.meas tran vdout0_4ck1790 FIND v(dout0_4) AT=900.025n

.meas tran vdout0_5ck1790 FIND v(dout0_5) AT=900.025n

.meas tran vdout0_6ck1790 FIND v(dout0_6) AT=900.025n

.meas tran vdout0_7ck1790 FIND v(dout0_7) AT=900.025n

.meas tran vdout0_8ck1790 FIND v(dout0_8) AT=900.025n

.meas tran vdout0_9ck1790 FIND v(dout0_9) AT=900.025n

.meas tran vdout0_10ck1790 FIND v(dout0_10) AT=900.025n

.meas tran vdout0_11ck1790 FIND v(dout0_11) AT=900.025n

.meas tran vdout0_12ck1790 FIND v(dout0_12) AT=900.025n

.meas tran vdout0_13ck1790 FIND v(dout0_13) AT=900.025n

.meas tran vdout0_14ck1790 FIND v(dout0_14) AT=900.025n

.meas tran vdout0_15ck1790 FIND v(dout0_15) AT=900.025n

.meas tran vdout0_16ck1790 FIND v(dout0_16) AT=900.025n

.meas tran vdout0_17ck1790 FIND v(dout0_17) AT=900.025n

.meas tran vdout0_18ck1790 FIND v(dout0_18) AT=900.025n

.meas tran vdout0_19ck1790 FIND v(dout0_19) AT=900.025n

.meas tran vdout0_20ck1790 FIND v(dout0_20) AT=900.025n

.meas tran vdout0_21ck1790 FIND v(dout0_21) AT=900.025n

.meas tran vdout0_22ck1790 FIND v(dout0_22) AT=900.025n

.meas tran vdout0_23ck1790 FIND v(dout0_23) AT=900.025n

.meas tran vdout0_24ck1790 FIND v(dout0_24) AT=900.025n

.meas tran vdout0_25ck1790 FIND v(dout0_25) AT=900.025n

.meas tran vdout0_26ck1790 FIND v(dout0_26) AT=900.025n

.meas tran vdout0_27ck1790 FIND v(dout0_27) AT=900.025n

.meas tran vdout0_28ck1790 FIND v(dout0_28) AT=900.025n

.meas tran vdout0_29ck1790 FIND v(dout0_29) AT=900.025n

.meas tran vdout0_30ck1790 FIND v(dout0_30) AT=900.025n

.meas tran vdout0_31ck1790 FIND v(dout0_31) AT=900.025n

.meas tran vdout0_32ck1790 FIND v(dout0_32) AT=900.025n

.meas tran vdout0_33ck1790 FIND v(dout0_33) AT=900.025n

.meas tran vdout0_34ck1790 FIND v(dout0_34) AT=900.025n

.meas tran vdout0_35ck1790 FIND v(dout0_35) AT=900.025n

.meas tran vdout0_36ck1790 FIND v(dout0_36) AT=900.025n

.meas tran vdout0_37ck1790 FIND v(dout0_37) AT=900.025n

.meas tran vdout0_38ck1790 FIND v(dout0_38) AT=900.025n

.meas tran vdout0_39ck1790 FIND v(dout0_39) AT=900.025n

.meas tran vdout0_40ck1790 FIND v(dout0_40) AT=900.025n

.meas tran vdout0_41ck1790 FIND v(dout0_41) AT=900.025n

.meas tran vdout0_42ck1790 FIND v(dout0_42) AT=900.025n

.meas tran vdout0_43ck1790 FIND v(dout0_43) AT=900.025n

.meas tran vdout0_44ck1790 FIND v(dout0_44) AT=900.025n

.meas tran vdout0_45ck1790 FIND v(dout0_45) AT=900.025n

.meas tran vdout0_46ck1790 FIND v(dout0_46) AT=900.025n

.meas tran vdout0_47ck1790 FIND v(dout0_47) AT=900.025n

.meas tran vdout0_48ck1790 FIND v(dout0_48) AT=900.025n

.meas tran vdout0_49ck1790 FIND v(dout0_49) AT=900.025n

.meas tran vdout0_50ck1790 FIND v(dout0_50) AT=900.025n

.meas tran vdout0_51ck1790 FIND v(dout0_51) AT=900.025n

.meas tran vdout0_52ck1790 FIND v(dout0_52) AT=900.025n

.meas tran vdout0_53ck1790 FIND v(dout0_53) AT=900.025n

.meas tran vdout0_54ck1790 FIND v(dout0_54) AT=900.025n

.meas tran vdout0_55ck1790 FIND v(dout0_55) AT=900.025n

.meas tran vdout0_56ck1790 FIND v(dout0_56) AT=900.025n

.meas tran vdout0_57ck1790 FIND v(dout0_57) AT=900.025n

.meas tran vdout0_58ck1790 FIND v(dout0_58) AT=900.025n

.meas tran vdout0_59ck1790 FIND v(dout0_59) AT=900.025n

.meas tran vdout0_60ck1790 FIND v(dout0_60) AT=900.025n

.meas tran vdout0_61ck1790 FIND v(dout0_61) AT=900.025n

.meas tran vdout0_62ck1790 FIND v(dout0_62) AT=900.025n

.meas tran vdout0_63ck1790 FIND v(dout0_63) AT=900.025n

.meas tran vdout0_64ck1790 FIND v(dout0_64) AT=900.025n

.meas tran vdout0_65ck1790 FIND v(dout0_65) AT=900.025n

.meas tran vdout0_66ck1790 FIND v(dout0_66) AT=900.025n

.meas tran vdout0_67ck1790 FIND v(dout0_67) AT=900.025n

.meas tran vdout0_68ck1790 FIND v(dout0_68) AT=900.025n

.meas tran vdout0_69ck1790 FIND v(dout0_69) AT=900.025n

.meas tran vdout0_70ck1790 FIND v(dout0_70) AT=900.025n

.meas tran vdout0_71ck1790 FIND v(dout0_71) AT=900.025n

.meas tran vdout0_72ck1790 FIND v(dout0_72) AT=900.025n

.meas tran vdout0_73ck1790 FIND v(dout0_73) AT=900.025n

.meas tran vdout0_74ck1790 FIND v(dout0_74) AT=900.025n

.meas tran vdout0_75ck1790 FIND v(dout0_75) AT=900.025n

.meas tran vdout0_76ck1790 FIND v(dout0_76) AT=900.025n

.meas tran vdout0_77ck1790 FIND v(dout0_77) AT=900.025n

.meas tran vdout0_78ck1790 FIND v(dout0_78) AT=900.025n

.meas tran vdout0_79ck1790 FIND v(dout0_79) AT=900.025n

.meas tran vdout0_80ck1790 FIND v(dout0_80) AT=900.025n

.meas tran vdout0_81ck1790 FIND v(dout0_81) AT=900.025n

.meas tran vdout0_82ck1790 FIND v(dout0_82) AT=900.025n

.meas tran vdout0_83ck1790 FIND v(dout0_83) AT=900.025n

.meas tran vdout0_84ck1790 FIND v(dout0_84) AT=900.025n

.meas tran vdout0_85ck1790 FIND v(dout0_85) AT=900.025n

.meas tran vdout0_86ck1790 FIND v(dout0_86) AT=900.025n

.meas tran vdout0_87ck1790 FIND v(dout0_87) AT=900.025n

.meas tran vdout0_88ck1790 FIND v(dout0_88) AT=900.025n

.meas tran vdout0_89ck1790 FIND v(dout0_89) AT=900.025n

.meas tran vdout0_90ck1790 FIND v(dout0_90) AT=900.025n

.meas tran vdout0_91ck1790 FIND v(dout0_91) AT=900.025n

.meas tran vdout0_92ck1790 FIND v(dout0_92) AT=900.025n

.meas tran vdout0_93ck1790 FIND v(dout0_93) AT=900.025n

.meas tran vdout0_94ck1790 FIND v(dout0_94) AT=900.025n

.meas tran vdout0_95ck1790 FIND v(dout0_95) AT=900.025n

.meas tran vdout0_96ck1790 FIND v(dout0_96) AT=900.025n

.meas tran vdout0_97ck1790 FIND v(dout0_97) AT=900.025n

.meas tran vdout0_98ck1790 FIND v(dout0_98) AT=900.025n

.meas tran vdout0_99ck1790 FIND v(dout0_99) AT=900.025n

.meas tran vdout0_100ck1790 FIND v(dout0_100) AT=900.025n

.meas tran vdout0_101ck1790 FIND v(dout0_101) AT=900.025n

.meas tran vdout0_102ck1790 FIND v(dout0_102) AT=900.025n

.meas tran vdout0_103ck1790 FIND v(dout0_103) AT=900.025n

.meas tran vdout0_104ck1790 FIND v(dout0_104) AT=900.025n

.meas tran vdout0_105ck1790 FIND v(dout0_105) AT=900.025n

.meas tran vdout0_106ck1790 FIND v(dout0_106) AT=900.025n

.meas tran vdout0_107ck1790 FIND v(dout0_107) AT=900.025n

.meas tran vdout0_108ck1790 FIND v(dout0_108) AT=900.025n

.meas tran vdout0_109ck1790 FIND v(dout0_109) AT=900.025n

.meas tran vdout0_110ck1790 FIND v(dout0_110) AT=900.025n

.meas tran vdout0_111ck1790 FIND v(dout0_111) AT=900.025n

.meas tran vdout0_112ck1790 FIND v(dout0_112) AT=900.025n

.meas tran vdout0_113ck1790 FIND v(dout0_113) AT=900.025n

.meas tran vdout0_114ck1790 FIND v(dout0_114) AT=900.025n

.meas tran vdout0_115ck1790 FIND v(dout0_115) AT=900.025n

.meas tran vdout0_116ck1790 FIND v(dout0_116) AT=900.025n

.meas tran vdout0_117ck1790 FIND v(dout0_117) AT=900.025n

.meas tran vdout0_118ck1790 FIND v(dout0_118) AT=900.025n

.meas tran vdout0_119ck1790 FIND v(dout0_119) AT=900.025n

.meas tran vdout0_120ck1790 FIND v(dout0_120) AT=900.025n

.meas tran vdout0_121ck1790 FIND v(dout0_121) AT=900.025n

.meas tran vdout0_122ck1790 FIND v(dout0_122) AT=900.025n

.meas tran vdout0_123ck1790 FIND v(dout0_123) AT=900.025n

.meas tran vdout0_124ck1790 FIND v(dout0_124) AT=900.025n

.meas tran vdout0_125ck1790 FIND v(dout0_125) AT=900.025n

.meas tran vdout0_126ck1790 FIND v(dout0_126) AT=900.025n

.meas tran vdout0_127ck1790 FIND v(dout0_127) AT=900.025n

.meas tran vdout0_128ck1790 FIND v(dout0_128) AT=900.025n

.meas tran vdout0_129ck1790 FIND v(dout0_129) AT=900.025n

.meas tran vdout0_130ck1790 FIND v(dout0_130) AT=900.025n

.meas tran vdout0_131ck1790 FIND v(dout0_131) AT=900.025n

.meas tran vdout0_132ck1790 FIND v(dout0_132) AT=900.025n

.meas tran vdout0_133ck1790 FIND v(dout0_133) AT=900.025n

.meas tran vdout0_134ck1790 FIND v(dout0_134) AT=900.025n

.meas tran vdout0_135ck1790 FIND v(dout0_135) AT=900.025n

.meas tran vdout0_136ck1790 FIND v(dout0_136) AT=900.025n

.meas tran vdout0_137ck1790 FIND v(dout0_137) AT=900.025n

.meas tran vdout0_138ck1790 FIND v(dout0_138) AT=900.025n

.meas tran vdout0_139ck1790 FIND v(dout0_139) AT=900.025n

.meas tran vdout0_140ck1790 FIND v(dout0_140) AT=900.025n

.meas tran vdout0_141ck1790 FIND v(dout0_141) AT=900.025n

.meas tran vdout0_142ck1790 FIND v(dout0_142) AT=900.025n

.meas tran vdout0_143ck1790 FIND v(dout0_143) AT=900.025n

.meas tran vdout0_144ck1790 FIND v(dout0_144) AT=900.025n

.meas tran vdout0_145ck1790 FIND v(dout0_145) AT=900.025n

.meas tran vdout0_146ck1790 FIND v(dout0_146) AT=900.025n

.meas tran vdout0_147ck1790 FIND v(dout0_147) AT=900.025n

.meas tran vdout0_148ck1790 FIND v(dout0_148) AT=900.025n

.meas tran vdout0_149ck1790 FIND v(dout0_149) AT=900.025n

.meas tran vdout0_0ck1800 FIND v(dout0_0) AT=905.025n

.meas tran vdout0_1ck1800 FIND v(dout0_1) AT=905.025n

.meas tran vdout0_2ck1800 FIND v(dout0_2) AT=905.025n

.meas tran vdout0_3ck1800 FIND v(dout0_3) AT=905.025n

.meas tran vdout0_4ck1800 FIND v(dout0_4) AT=905.025n

.meas tran vdout0_5ck1800 FIND v(dout0_5) AT=905.025n

.meas tran vdout0_6ck1800 FIND v(dout0_6) AT=905.025n

.meas tran vdout0_7ck1800 FIND v(dout0_7) AT=905.025n

.meas tran vdout0_8ck1800 FIND v(dout0_8) AT=905.025n

.meas tran vdout0_9ck1800 FIND v(dout0_9) AT=905.025n

.meas tran vdout0_10ck1800 FIND v(dout0_10) AT=905.025n

.meas tran vdout0_11ck1800 FIND v(dout0_11) AT=905.025n

.meas tran vdout0_12ck1800 FIND v(dout0_12) AT=905.025n

.meas tran vdout0_13ck1800 FIND v(dout0_13) AT=905.025n

.meas tran vdout0_14ck1800 FIND v(dout0_14) AT=905.025n

.meas tran vdout0_15ck1800 FIND v(dout0_15) AT=905.025n

.meas tran vdout0_16ck1800 FIND v(dout0_16) AT=905.025n

.meas tran vdout0_17ck1800 FIND v(dout0_17) AT=905.025n

.meas tran vdout0_18ck1800 FIND v(dout0_18) AT=905.025n

.meas tran vdout0_19ck1800 FIND v(dout0_19) AT=905.025n

.meas tran vdout0_20ck1800 FIND v(dout0_20) AT=905.025n

.meas tran vdout0_21ck1800 FIND v(dout0_21) AT=905.025n

.meas tran vdout0_22ck1800 FIND v(dout0_22) AT=905.025n

.meas tran vdout0_23ck1800 FIND v(dout0_23) AT=905.025n

.meas tran vdout0_24ck1800 FIND v(dout0_24) AT=905.025n

.meas tran vdout0_25ck1800 FIND v(dout0_25) AT=905.025n

.meas tran vdout0_26ck1800 FIND v(dout0_26) AT=905.025n

.meas tran vdout0_27ck1800 FIND v(dout0_27) AT=905.025n

.meas tran vdout0_28ck1800 FIND v(dout0_28) AT=905.025n

.meas tran vdout0_29ck1800 FIND v(dout0_29) AT=905.025n

.meas tran vdout0_30ck1800 FIND v(dout0_30) AT=905.025n

.meas tran vdout0_31ck1800 FIND v(dout0_31) AT=905.025n

.meas tran vdout0_32ck1800 FIND v(dout0_32) AT=905.025n

.meas tran vdout0_33ck1800 FIND v(dout0_33) AT=905.025n

.meas tran vdout0_34ck1800 FIND v(dout0_34) AT=905.025n

.meas tran vdout0_35ck1800 FIND v(dout0_35) AT=905.025n

.meas tran vdout0_36ck1800 FIND v(dout0_36) AT=905.025n

.meas tran vdout0_37ck1800 FIND v(dout0_37) AT=905.025n

.meas tran vdout0_38ck1800 FIND v(dout0_38) AT=905.025n

.meas tran vdout0_39ck1800 FIND v(dout0_39) AT=905.025n

.meas tran vdout0_40ck1800 FIND v(dout0_40) AT=905.025n

.meas tran vdout0_41ck1800 FIND v(dout0_41) AT=905.025n

.meas tran vdout0_42ck1800 FIND v(dout0_42) AT=905.025n

.meas tran vdout0_43ck1800 FIND v(dout0_43) AT=905.025n

.meas tran vdout0_44ck1800 FIND v(dout0_44) AT=905.025n

.meas tran vdout0_45ck1800 FIND v(dout0_45) AT=905.025n

.meas tran vdout0_46ck1800 FIND v(dout0_46) AT=905.025n

.meas tran vdout0_47ck1800 FIND v(dout0_47) AT=905.025n

.meas tran vdout0_48ck1800 FIND v(dout0_48) AT=905.025n

.meas tran vdout0_49ck1800 FIND v(dout0_49) AT=905.025n

.meas tran vdout0_50ck1800 FIND v(dout0_50) AT=905.025n

.meas tran vdout0_51ck1800 FIND v(dout0_51) AT=905.025n

.meas tran vdout0_52ck1800 FIND v(dout0_52) AT=905.025n

.meas tran vdout0_53ck1800 FIND v(dout0_53) AT=905.025n

.meas tran vdout0_54ck1800 FIND v(dout0_54) AT=905.025n

.meas tran vdout0_55ck1800 FIND v(dout0_55) AT=905.025n

.meas tran vdout0_56ck1800 FIND v(dout0_56) AT=905.025n

.meas tran vdout0_57ck1800 FIND v(dout0_57) AT=905.025n

.meas tran vdout0_58ck1800 FIND v(dout0_58) AT=905.025n

.meas tran vdout0_59ck1800 FIND v(dout0_59) AT=905.025n

.meas tran vdout0_60ck1800 FIND v(dout0_60) AT=905.025n

.meas tran vdout0_61ck1800 FIND v(dout0_61) AT=905.025n

.meas tran vdout0_62ck1800 FIND v(dout0_62) AT=905.025n

.meas tran vdout0_63ck1800 FIND v(dout0_63) AT=905.025n

.meas tran vdout0_64ck1800 FIND v(dout0_64) AT=905.025n

.meas tran vdout0_65ck1800 FIND v(dout0_65) AT=905.025n

.meas tran vdout0_66ck1800 FIND v(dout0_66) AT=905.025n

.meas tran vdout0_67ck1800 FIND v(dout0_67) AT=905.025n

.meas tran vdout0_68ck1800 FIND v(dout0_68) AT=905.025n

.meas tran vdout0_69ck1800 FIND v(dout0_69) AT=905.025n

.meas tran vdout0_70ck1800 FIND v(dout0_70) AT=905.025n

.meas tran vdout0_71ck1800 FIND v(dout0_71) AT=905.025n

.meas tran vdout0_72ck1800 FIND v(dout0_72) AT=905.025n

.meas tran vdout0_73ck1800 FIND v(dout0_73) AT=905.025n

.meas tran vdout0_74ck1800 FIND v(dout0_74) AT=905.025n

.meas tran vdout0_75ck1800 FIND v(dout0_75) AT=905.025n

.meas tran vdout0_76ck1800 FIND v(dout0_76) AT=905.025n

.meas tran vdout0_77ck1800 FIND v(dout0_77) AT=905.025n

.meas tran vdout0_78ck1800 FIND v(dout0_78) AT=905.025n

.meas tran vdout0_79ck1800 FIND v(dout0_79) AT=905.025n

.meas tran vdout0_80ck1800 FIND v(dout0_80) AT=905.025n

.meas tran vdout0_81ck1800 FIND v(dout0_81) AT=905.025n

.meas tran vdout0_82ck1800 FIND v(dout0_82) AT=905.025n

.meas tran vdout0_83ck1800 FIND v(dout0_83) AT=905.025n

.meas tran vdout0_84ck1800 FIND v(dout0_84) AT=905.025n

.meas tran vdout0_85ck1800 FIND v(dout0_85) AT=905.025n

.meas tran vdout0_86ck1800 FIND v(dout0_86) AT=905.025n

.meas tran vdout0_87ck1800 FIND v(dout0_87) AT=905.025n

.meas tran vdout0_88ck1800 FIND v(dout0_88) AT=905.025n

.meas tran vdout0_89ck1800 FIND v(dout0_89) AT=905.025n

.meas tran vdout0_90ck1800 FIND v(dout0_90) AT=905.025n

.meas tran vdout0_91ck1800 FIND v(dout0_91) AT=905.025n

.meas tran vdout0_92ck1800 FIND v(dout0_92) AT=905.025n

.meas tran vdout0_93ck1800 FIND v(dout0_93) AT=905.025n

.meas tran vdout0_94ck1800 FIND v(dout0_94) AT=905.025n

.meas tran vdout0_95ck1800 FIND v(dout0_95) AT=905.025n

.meas tran vdout0_96ck1800 FIND v(dout0_96) AT=905.025n

.meas tran vdout0_97ck1800 FIND v(dout0_97) AT=905.025n

.meas tran vdout0_98ck1800 FIND v(dout0_98) AT=905.025n

.meas tran vdout0_99ck1800 FIND v(dout0_99) AT=905.025n

.meas tran vdout0_100ck1800 FIND v(dout0_100) AT=905.025n

.meas tran vdout0_101ck1800 FIND v(dout0_101) AT=905.025n

.meas tran vdout0_102ck1800 FIND v(dout0_102) AT=905.025n

.meas tran vdout0_103ck1800 FIND v(dout0_103) AT=905.025n

.meas tran vdout0_104ck1800 FIND v(dout0_104) AT=905.025n

.meas tran vdout0_105ck1800 FIND v(dout0_105) AT=905.025n

.meas tran vdout0_106ck1800 FIND v(dout0_106) AT=905.025n

.meas tran vdout0_107ck1800 FIND v(dout0_107) AT=905.025n

.meas tran vdout0_108ck1800 FIND v(dout0_108) AT=905.025n

.meas tran vdout0_109ck1800 FIND v(dout0_109) AT=905.025n

.meas tran vdout0_110ck1800 FIND v(dout0_110) AT=905.025n

.meas tran vdout0_111ck1800 FIND v(dout0_111) AT=905.025n

.meas tran vdout0_112ck1800 FIND v(dout0_112) AT=905.025n

.meas tran vdout0_113ck1800 FIND v(dout0_113) AT=905.025n

.meas tran vdout0_114ck1800 FIND v(dout0_114) AT=905.025n

.meas tran vdout0_115ck1800 FIND v(dout0_115) AT=905.025n

.meas tran vdout0_116ck1800 FIND v(dout0_116) AT=905.025n

.meas tran vdout0_117ck1800 FIND v(dout0_117) AT=905.025n

.meas tran vdout0_118ck1800 FIND v(dout0_118) AT=905.025n

.meas tran vdout0_119ck1800 FIND v(dout0_119) AT=905.025n

.meas tran vdout0_120ck1800 FIND v(dout0_120) AT=905.025n

.meas tran vdout0_121ck1800 FIND v(dout0_121) AT=905.025n

.meas tran vdout0_122ck1800 FIND v(dout0_122) AT=905.025n

.meas tran vdout0_123ck1800 FIND v(dout0_123) AT=905.025n

.meas tran vdout0_124ck1800 FIND v(dout0_124) AT=905.025n

.meas tran vdout0_125ck1800 FIND v(dout0_125) AT=905.025n

.meas tran vdout0_126ck1800 FIND v(dout0_126) AT=905.025n

.meas tran vdout0_127ck1800 FIND v(dout0_127) AT=905.025n

.meas tran vdout0_128ck1800 FIND v(dout0_128) AT=905.025n

.meas tran vdout0_129ck1800 FIND v(dout0_129) AT=905.025n

.meas tran vdout0_130ck1800 FIND v(dout0_130) AT=905.025n

.meas tran vdout0_131ck1800 FIND v(dout0_131) AT=905.025n

.meas tran vdout0_132ck1800 FIND v(dout0_132) AT=905.025n

.meas tran vdout0_133ck1800 FIND v(dout0_133) AT=905.025n

.meas tran vdout0_134ck1800 FIND v(dout0_134) AT=905.025n

.meas tran vdout0_135ck1800 FIND v(dout0_135) AT=905.025n

.meas tran vdout0_136ck1800 FIND v(dout0_136) AT=905.025n

.meas tran vdout0_137ck1800 FIND v(dout0_137) AT=905.025n

.meas tran vdout0_138ck1800 FIND v(dout0_138) AT=905.025n

.meas tran vdout0_139ck1800 FIND v(dout0_139) AT=905.025n

.meas tran vdout0_140ck1800 FIND v(dout0_140) AT=905.025n

.meas tran vdout0_141ck1800 FIND v(dout0_141) AT=905.025n

.meas tran vdout0_142ck1800 FIND v(dout0_142) AT=905.025n

.meas tran vdout0_143ck1800 FIND v(dout0_143) AT=905.025n

.meas tran vdout0_144ck1800 FIND v(dout0_144) AT=905.025n

.meas tran vdout0_145ck1800 FIND v(dout0_145) AT=905.025n

.meas tran vdout0_146ck1800 FIND v(dout0_146) AT=905.025n

.meas tran vdout0_147ck1800 FIND v(dout0_147) AT=905.025n

.meas tran vdout0_148ck1800 FIND v(dout0_148) AT=905.025n

.meas tran vdout0_149ck1800 FIND v(dout0_149) AT=905.025n

.meas tran vdout0_0ck1830 FIND v(dout0_0) AT=920.025n

.meas tran vdout0_1ck1830 FIND v(dout0_1) AT=920.025n

.meas tran vdout0_2ck1830 FIND v(dout0_2) AT=920.025n

.meas tran vdout0_3ck1830 FIND v(dout0_3) AT=920.025n

.meas tran vdout0_4ck1830 FIND v(dout0_4) AT=920.025n

.meas tran vdout0_5ck1830 FIND v(dout0_5) AT=920.025n

.meas tran vdout0_6ck1830 FIND v(dout0_6) AT=920.025n

.meas tran vdout0_7ck1830 FIND v(dout0_7) AT=920.025n

.meas tran vdout0_8ck1830 FIND v(dout0_8) AT=920.025n

.meas tran vdout0_9ck1830 FIND v(dout0_9) AT=920.025n

.meas tran vdout0_10ck1830 FIND v(dout0_10) AT=920.025n

.meas tran vdout0_11ck1830 FIND v(dout0_11) AT=920.025n

.meas tran vdout0_12ck1830 FIND v(dout0_12) AT=920.025n

.meas tran vdout0_13ck1830 FIND v(dout0_13) AT=920.025n

.meas tran vdout0_14ck1830 FIND v(dout0_14) AT=920.025n

.meas tran vdout0_15ck1830 FIND v(dout0_15) AT=920.025n

.meas tran vdout0_16ck1830 FIND v(dout0_16) AT=920.025n

.meas tran vdout0_17ck1830 FIND v(dout0_17) AT=920.025n

.meas tran vdout0_18ck1830 FIND v(dout0_18) AT=920.025n

.meas tran vdout0_19ck1830 FIND v(dout0_19) AT=920.025n

.meas tran vdout0_20ck1830 FIND v(dout0_20) AT=920.025n

.meas tran vdout0_21ck1830 FIND v(dout0_21) AT=920.025n

.meas tran vdout0_22ck1830 FIND v(dout0_22) AT=920.025n

.meas tran vdout0_23ck1830 FIND v(dout0_23) AT=920.025n

.meas tran vdout0_24ck1830 FIND v(dout0_24) AT=920.025n

.meas tran vdout0_25ck1830 FIND v(dout0_25) AT=920.025n

.meas tran vdout0_26ck1830 FIND v(dout0_26) AT=920.025n

.meas tran vdout0_27ck1830 FIND v(dout0_27) AT=920.025n

.meas tran vdout0_28ck1830 FIND v(dout0_28) AT=920.025n

.meas tran vdout0_29ck1830 FIND v(dout0_29) AT=920.025n

.meas tran vdout0_30ck1830 FIND v(dout0_30) AT=920.025n

.meas tran vdout0_31ck1830 FIND v(dout0_31) AT=920.025n

.meas tran vdout0_32ck1830 FIND v(dout0_32) AT=920.025n

.meas tran vdout0_33ck1830 FIND v(dout0_33) AT=920.025n

.meas tran vdout0_34ck1830 FIND v(dout0_34) AT=920.025n

.meas tran vdout0_35ck1830 FIND v(dout0_35) AT=920.025n

.meas tran vdout0_36ck1830 FIND v(dout0_36) AT=920.025n

.meas tran vdout0_37ck1830 FIND v(dout0_37) AT=920.025n

.meas tran vdout0_38ck1830 FIND v(dout0_38) AT=920.025n

.meas tran vdout0_39ck1830 FIND v(dout0_39) AT=920.025n

.meas tran vdout0_40ck1830 FIND v(dout0_40) AT=920.025n

.meas tran vdout0_41ck1830 FIND v(dout0_41) AT=920.025n

.meas tran vdout0_42ck1830 FIND v(dout0_42) AT=920.025n

.meas tran vdout0_43ck1830 FIND v(dout0_43) AT=920.025n

.meas tran vdout0_44ck1830 FIND v(dout0_44) AT=920.025n

.meas tran vdout0_45ck1830 FIND v(dout0_45) AT=920.025n

.meas tran vdout0_46ck1830 FIND v(dout0_46) AT=920.025n

.meas tran vdout0_47ck1830 FIND v(dout0_47) AT=920.025n

.meas tran vdout0_48ck1830 FIND v(dout0_48) AT=920.025n

.meas tran vdout0_49ck1830 FIND v(dout0_49) AT=920.025n

.meas tran vdout0_50ck1830 FIND v(dout0_50) AT=920.025n

.meas tran vdout0_51ck1830 FIND v(dout0_51) AT=920.025n

.meas tran vdout0_52ck1830 FIND v(dout0_52) AT=920.025n

.meas tran vdout0_53ck1830 FIND v(dout0_53) AT=920.025n

.meas tran vdout0_54ck1830 FIND v(dout0_54) AT=920.025n

.meas tran vdout0_55ck1830 FIND v(dout0_55) AT=920.025n

.meas tran vdout0_56ck1830 FIND v(dout0_56) AT=920.025n

.meas tran vdout0_57ck1830 FIND v(dout0_57) AT=920.025n

.meas tran vdout0_58ck1830 FIND v(dout0_58) AT=920.025n

.meas tran vdout0_59ck1830 FIND v(dout0_59) AT=920.025n

.meas tran vdout0_60ck1830 FIND v(dout0_60) AT=920.025n

.meas tran vdout0_61ck1830 FIND v(dout0_61) AT=920.025n

.meas tran vdout0_62ck1830 FIND v(dout0_62) AT=920.025n

.meas tran vdout0_63ck1830 FIND v(dout0_63) AT=920.025n

.meas tran vdout0_64ck1830 FIND v(dout0_64) AT=920.025n

.meas tran vdout0_65ck1830 FIND v(dout0_65) AT=920.025n

.meas tran vdout0_66ck1830 FIND v(dout0_66) AT=920.025n

.meas tran vdout0_67ck1830 FIND v(dout0_67) AT=920.025n

.meas tran vdout0_68ck1830 FIND v(dout0_68) AT=920.025n

.meas tran vdout0_69ck1830 FIND v(dout0_69) AT=920.025n

.meas tran vdout0_70ck1830 FIND v(dout0_70) AT=920.025n

.meas tran vdout0_71ck1830 FIND v(dout0_71) AT=920.025n

.meas tran vdout0_72ck1830 FIND v(dout0_72) AT=920.025n

.meas tran vdout0_73ck1830 FIND v(dout0_73) AT=920.025n

.meas tran vdout0_74ck1830 FIND v(dout0_74) AT=920.025n

.meas tran vdout0_75ck1830 FIND v(dout0_75) AT=920.025n

.meas tran vdout0_76ck1830 FIND v(dout0_76) AT=920.025n

.meas tran vdout0_77ck1830 FIND v(dout0_77) AT=920.025n

.meas tran vdout0_78ck1830 FIND v(dout0_78) AT=920.025n

.meas tran vdout0_79ck1830 FIND v(dout0_79) AT=920.025n

.meas tran vdout0_80ck1830 FIND v(dout0_80) AT=920.025n

.meas tran vdout0_81ck1830 FIND v(dout0_81) AT=920.025n

.meas tran vdout0_82ck1830 FIND v(dout0_82) AT=920.025n

.meas tran vdout0_83ck1830 FIND v(dout0_83) AT=920.025n

.meas tran vdout0_84ck1830 FIND v(dout0_84) AT=920.025n

.meas tran vdout0_85ck1830 FIND v(dout0_85) AT=920.025n

.meas tran vdout0_86ck1830 FIND v(dout0_86) AT=920.025n

.meas tran vdout0_87ck1830 FIND v(dout0_87) AT=920.025n

.meas tran vdout0_88ck1830 FIND v(dout0_88) AT=920.025n

.meas tran vdout0_89ck1830 FIND v(dout0_89) AT=920.025n

.meas tran vdout0_90ck1830 FIND v(dout0_90) AT=920.025n

.meas tran vdout0_91ck1830 FIND v(dout0_91) AT=920.025n

.meas tran vdout0_92ck1830 FIND v(dout0_92) AT=920.025n

.meas tran vdout0_93ck1830 FIND v(dout0_93) AT=920.025n

.meas tran vdout0_94ck1830 FIND v(dout0_94) AT=920.025n

.meas tran vdout0_95ck1830 FIND v(dout0_95) AT=920.025n

.meas tran vdout0_96ck1830 FIND v(dout0_96) AT=920.025n

.meas tran vdout0_97ck1830 FIND v(dout0_97) AT=920.025n

.meas tran vdout0_98ck1830 FIND v(dout0_98) AT=920.025n

.meas tran vdout0_99ck1830 FIND v(dout0_99) AT=920.025n

.meas tran vdout0_100ck1830 FIND v(dout0_100) AT=920.025n

.meas tran vdout0_101ck1830 FIND v(dout0_101) AT=920.025n

.meas tran vdout0_102ck1830 FIND v(dout0_102) AT=920.025n

.meas tran vdout0_103ck1830 FIND v(dout0_103) AT=920.025n

.meas tran vdout0_104ck1830 FIND v(dout0_104) AT=920.025n

.meas tran vdout0_105ck1830 FIND v(dout0_105) AT=920.025n

.meas tran vdout0_106ck1830 FIND v(dout0_106) AT=920.025n

.meas tran vdout0_107ck1830 FIND v(dout0_107) AT=920.025n

.meas tran vdout0_108ck1830 FIND v(dout0_108) AT=920.025n

.meas tran vdout0_109ck1830 FIND v(dout0_109) AT=920.025n

.meas tran vdout0_110ck1830 FIND v(dout0_110) AT=920.025n

.meas tran vdout0_111ck1830 FIND v(dout0_111) AT=920.025n

.meas tran vdout0_112ck1830 FIND v(dout0_112) AT=920.025n

.meas tran vdout0_113ck1830 FIND v(dout0_113) AT=920.025n

.meas tran vdout0_114ck1830 FIND v(dout0_114) AT=920.025n

.meas tran vdout0_115ck1830 FIND v(dout0_115) AT=920.025n

.meas tran vdout0_116ck1830 FIND v(dout0_116) AT=920.025n

.meas tran vdout0_117ck1830 FIND v(dout0_117) AT=920.025n

.meas tran vdout0_118ck1830 FIND v(dout0_118) AT=920.025n

.meas tran vdout0_119ck1830 FIND v(dout0_119) AT=920.025n

.meas tran vdout0_120ck1830 FIND v(dout0_120) AT=920.025n

.meas tran vdout0_121ck1830 FIND v(dout0_121) AT=920.025n

.meas tran vdout0_122ck1830 FIND v(dout0_122) AT=920.025n

.meas tran vdout0_123ck1830 FIND v(dout0_123) AT=920.025n

.meas tran vdout0_124ck1830 FIND v(dout0_124) AT=920.025n

.meas tran vdout0_125ck1830 FIND v(dout0_125) AT=920.025n

.meas tran vdout0_126ck1830 FIND v(dout0_126) AT=920.025n

.meas tran vdout0_127ck1830 FIND v(dout0_127) AT=920.025n

.meas tran vdout0_128ck1830 FIND v(dout0_128) AT=920.025n

.meas tran vdout0_129ck1830 FIND v(dout0_129) AT=920.025n

.meas tran vdout0_130ck1830 FIND v(dout0_130) AT=920.025n

.meas tran vdout0_131ck1830 FIND v(dout0_131) AT=920.025n

.meas tran vdout0_132ck1830 FIND v(dout0_132) AT=920.025n

.meas tran vdout0_133ck1830 FIND v(dout0_133) AT=920.025n

.meas tran vdout0_134ck1830 FIND v(dout0_134) AT=920.025n

.meas tran vdout0_135ck1830 FIND v(dout0_135) AT=920.025n

.meas tran vdout0_136ck1830 FIND v(dout0_136) AT=920.025n

.meas tran vdout0_137ck1830 FIND v(dout0_137) AT=920.025n

.meas tran vdout0_138ck1830 FIND v(dout0_138) AT=920.025n

.meas tran vdout0_139ck1830 FIND v(dout0_139) AT=920.025n

.meas tran vdout0_140ck1830 FIND v(dout0_140) AT=920.025n

.meas tran vdout0_141ck1830 FIND v(dout0_141) AT=920.025n

.meas tran vdout0_142ck1830 FIND v(dout0_142) AT=920.025n

.meas tran vdout0_143ck1830 FIND v(dout0_143) AT=920.025n

.meas tran vdout0_144ck1830 FIND v(dout0_144) AT=920.025n

.meas tran vdout0_145ck1830 FIND v(dout0_145) AT=920.025n

.meas tran vdout0_146ck1830 FIND v(dout0_146) AT=920.025n

.meas tran vdout0_147ck1830 FIND v(dout0_147) AT=920.025n

.meas tran vdout0_148ck1830 FIND v(dout0_148) AT=920.025n

.meas tran vdout0_149ck1830 FIND v(dout0_149) AT=920.025n

.meas tran vdout0_0ck1850 FIND v(dout0_0) AT=930.025n

.meas tran vdout0_1ck1850 FIND v(dout0_1) AT=930.025n

.meas tran vdout0_2ck1850 FIND v(dout0_2) AT=930.025n

.meas tran vdout0_3ck1850 FIND v(dout0_3) AT=930.025n

.meas tran vdout0_4ck1850 FIND v(dout0_4) AT=930.025n

.meas tran vdout0_5ck1850 FIND v(dout0_5) AT=930.025n

.meas tran vdout0_6ck1850 FIND v(dout0_6) AT=930.025n

.meas tran vdout0_7ck1850 FIND v(dout0_7) AT=930.025n

.meas tran vdout0_8ck1850 FIND v(dout0_8) AT=930.025n

.meas tran vdout0_9ck1850 FIND v(dout0_9) AT=930.025n

.meas tran vdout0_10ck1850 FIND v(dout0_10) AT=930.025n

.meas tran vdout0_11ck1850 FIND v(dout0_11) AT=930.025n

.meas tran vdout0_12ck1850 FIND v(dout0_12) AT=930.025n

.meas tran vdout0_13ck1850 FIND v(dout0_13) AT=930.025n

.meas tran vdout0_14ck1850 FIND v(dout0_14) AT=930.025n

.meas tran vdout0_15ck1850 FIND v(dout0_15) AT=930.025n

.meas tran vdout0_16ck1850 FIND v(dout0_16) AT=930.025n

.meas tran vdout0_17ck1850 FIND v(dout0_17) AT=930.025n

.meas tran vdout0_18ck1850 FIND v(dout0_18) AT=930.025n

.meas tran vdout0_19ck1850 FIND v(dout0_19) AT=930.025n

.meas tran vdout0_20ck1850 FIND v(dout0_20) AT=930.025n

.meas tran vdout0_21ck1850 FIND v(dout0_21) AT=930.025n

.meas tran vdout0_22ck1850 FIND v(dout0_22) AT=930.025n

.meas tran vdout0_23ck1850 FIND v(dout0_23) AT=930.025n

.meas tran vdout0_24ck1850 FIND v(dout0_24) AT=930.025n

.meas tran vdout0_25ck1850 FIND v(dout0_25) AT=930.025n

.meas tran vdout0_26ck1850 FIND v(dout0_26) AT=930.025n

.meas tran vdout0_27ck1850 FIND v(dout0_27) AT=930.025n

.meas tran vdout0_28ck1850 FIND v(dout0_28) AT=930.025n

.meas tran vdout0_29ck1850 FIND v(dout0_29) AT=930.025n

.meas tran vdout0_30ck1850 FIND v(dout0_30) AT=930.025n

.meas tran vdout0_31ck1850 FIND v(dout0_31) AT=930.025n

.meas tran vdout0_32ck1850 FIND v(dout0_32) AT=930.025n

.meas tran vdout0_33ck1850 FIND v(dout0_33) AT=930.025n

.meas tran vdout0_34ck1850 FIND v(dout0_34) AT=930.025n

.meas tran vdout0_35ck1850 FIND v(dout0_35) AT=930.025n

.meas tran vdout0_36ck1850 FIND v(dout0_36) AT=930.025n

.meas tran vdout0_37ck1850 FIND v(dout0_37) AT=930.025n

.meas tran vdout0_38ck1850 FIND v(dout0_38) AT=930.025n

.meas tran vdout0_39ck1850 FIND v(dout0_39) AT=930.025n

.meas tran vdout0_40ck1850 FIND v(dout0_40) AT=930.025n

.meas tran vdout0_41ck1850 FIND v(dout0_41) AT=930.025n

.meas tran vdout0_42ck1850 FIND v(dout0_42) AT=930.025n

.meas tran vdout0_43ck1850 FIND v(dout0_43) AT=930.025n

.meas tran vdout0_44ck1850 FIND v(dout0_44) AT=930.025n

.meas tran vdout0_45ck1850 FIND v(dout0_45) AT=930.025n

.meas tran vdout0_46ck1850 FIND v(dout0_46) AT=930.025n

.meas tran vdout0_47ck1850 FIND v(dout0_47) AT=930.025n

.meas tran vdout0_48ck1850 FIND v(dout0_48) AT=930.025n

.meas tran vdout0_49ck1850 FIND v(dout0_49) AT=930.025n

.meas tran vdout0_50ck1850 FIND v(dout0_50) AT=930.025n

.meas tran vdout0_51ck1850 FIND v(dout0_51) AT=930.025n

.meas tran vdout0_52ck1850 FIND v(dout0_52) AT=930.025n

.meas tran vdout0_53ck1850 FIND v(dout0_53) AT=930.025n

.meas tran vdout0_54ck1850 FIND v(dout0_54) AT=930.025n

.meas tran vdout0_55ck1850 FIND v(dout0_55) AT=930.025n

.meas tran vdout0_56ck1850 FIND v(dout0_56) AT=930.025n

.meas tran vdout0_57ck1850 FIND v(dout0_57) AT=930.025n

.meas tran vdout0_58ck1850 FIND v(dout0_58) AT=930.025n

.meas tran vdout0_59ck1850 FIND v(dout0_59) AT=930.025n

.meas tran vdout0_60ck1850 FIND v(dout0_60) AT=930.025n

.meas tran vdout0_61ck1850 FIND v(dout0_61) AT=930.025n

.meas tran vdout0_62ck1850 FIND v(dout0_62) AT=930.025n

.meas tran vdout0_63ck1850 FIND v(dout0_63) AT=930.025n

.meas tran vdout0_64ck1850 FIND v(dout0_64) AT=930.025n

.meas tran vdout0_65ck1850 FIND v(dout0_65) AT=930.025n

.meas tran vdout0_66ck1850 FIND v(dout0_66) AT=930.025n

.meas tran vdout0_67ck1850 FIND v(dout0_67) AT=930.025n

.meas tran vdout0_68ck1850 FIND v(dout0_68) AT=930.025n

.meas tran vdout0_69ck1850 FIND v(dout0_69) AT=930.025n

.meas tran vdout0_70ck1850 FIND v(dout0_70) AT=930.025n

.meas tran vdout0_71ck1850 FIND v(dout0_71) AT=930.025n

.meas tran vdout0_72ck1850 FIND v(dout0_72) AT=930.025n

.meas tran vdout0_73ck1850 FIND v(dout0_73) AT=930.025n

.meas tran vdout0_74ck1850 FIND v(dout0_74) AT=930.025n

.meas tran vdout0_75ck1850 FIND v(dout0_75) AT=930.025n

.meas tran vdout0_76ck1850 FIND v(dout0_76) AT=930.025n

.meas tran vdout0_77ck1850 FIND v(dout0_77) AT=930.025n

.meas tran vdout0_78ck1850 FIND v(dout0_78) AT=930.025n

.meas tran vdout0_79ck1850 FIND v(dout0_79) AT=930.025n

.meas tran vdout0_80ck1850 FIND v(dout0_80) AT=930.025n

.meas tran vdout0_81ck1850 FIND v(dout0_81) AT=930.025n

.meas tran vdout0_82ck1850 FIND v(dout0_82) AT=930.025n

.meas tran vdout0_83ck1850 FIND v(dout0_83) AT=930.025n

.meas tran vdout0_84ck1850 FIND v(dout0_84) AT=930.025n

.meas tran vdout0_85ck1850 FIND v(dout0_85) AT=930.025n

.meas tran vdout0_86ck1850 FIND v(dout0_86) AT=930.025n

.meas tran vdout0_87ck1850 FIND v(dout0_87) AT=930.025n

.meas tran vdout0_88ck1850 FIND v(dout0_88) AT=930.025n

.meas tran vdout0_89ck1850 FIND v(dout0_89) AT=930.025n

.meas tran vdout0_90ck1850 FIND v(dout0_90) AT=930.025n

.meas tran vdout0_91ck1850 FIND v(dout0_91) AT=930.025n

.meas tran vdout0_92ck1850 FIND v(dout0_92) AT=930.025n

.meas tran vdout0_93ck1850 FIND v(dout0_93) AT=930.025n

.meas tran vdout0_94ck1850 FIND v(dout0_94) AT=930.025n

.meas tran vdout0_95ck1850 FIND v(dout0_95) AT=930.025n

.meas tran vdout0_96ck1850 FIND v(dout0_96) AT=930.025n

.meas tran vdout0_97ck1850 FIND v(dout0_97) AT=930.025n

.meas tran vdout0_98ck1850 FIND v(dout0_98) AT=930.025n

.meas tran vdout0_99ck1850 FIND v(dout0_99) AT=930.025n

.meas tran vdout0_100ck1850 FIND v(dout0_100) AT=930.025n

.meas tran vdout0_101ck1850 FIND v(dout0_101) AT=930.025n

.meas tran vdout0_102ck1850 FIND v(dout0_102) AT=930.025n

.meas tran vdout0_103ck1850 FIND v(dout0_103) AT=930.025n

.meas tran vdout0_104ck1850 FIND v(dout0_104) AT=930.025n

.meas tran vdout0_105ck1850 FIND v(dout0_105) AT=930.025n

.meas tran vdout0_106ck1850 FIND v(dout0_106) AT=930.025n

.meas tran vdout0_107ck1850 FIND v(dout0_107) AT=930.025n

.meas tran vdout0_108ck1850 FIND v(dout0_108) AT=930.025n

.meas tran vdout0_109ck1850 FIND v(dout0_109) AT=930.025n

.meas tran vdout0_110ck1850 FIND v(dout0_110) AT=930.025n

.meas tran vdout0_111ck1850 FIND v(dout0_111) AT=930.025n

.meas tran vdout0_112ck1850 FIND v(dout0_112) AT=930.025n

.meas tran vdout0_113ck1850 FIND v(dout0_113) AT=930.025n

.meas tran vdout0_114ck1850 FIND v(dout0_114) AT=930.025n

.meas tran vdout0_115ck1850 FIND v(dout0_115) AT=930.025n

.meas tran vdout0_116ck1850 FIND v(dout0_116) AT=930.025n

.meas tran vdout0_117ck1850 FIND v(dout0_117) AT=930.025n

.meas tran vdout0_118ck1850 FIND v(dout0_118) AT=930.025n

.meas tran vdout0_119ck1850 FIND v(dout0_119) AT=930.025n

.meas tran vdout0_120ck1850 FIND v(dout0_120) AT=930.025n

.meas tran vdout0_121ck1850 FIND v(dout0_121) AT=930.025n

.meas tran vdout0_122ck1850 FIND v(dout0_122) AT=930.025n

.meas tran vdout0_123ck1850 FIND v(dout0_123) AT=930.025n

.meas tran vdout0_124ck1850 FIND v(dout0_124) AT=930.025n

.meas tran vdout0_125ck1850 FIND v(dout0_125) AT=930.025n

.meas tran vdout0_126ck1850 FIND v(dout0_126) AT=930.025n

.meas tran vdout0_127ck1850 FIND v(dout0_127) AT=930.025n

.meas tran vdout0_128ck1850 FIND v(dout0_128) AT=930.025n

.meas tran vdout0_129ck1850 FIND v(dout0_129) AT=930.025n

.meas tran vdout0_130ck1850 FIND v(dout0_130) AT=930.025n

.meas tran vdout0_131ck1850 FIND v(dout0_131) AT=930.025n

.meas tran vdout0_132ck1850 FIND v(dout0_132) AT=930.025n

.meas tran vdout0_133ck1850 FIND v(dout0_133) AT=930.025n

.meas tran vdout0_134ck1850 FIND v(dout0_134) AT=930.025n

.meas tran vdout0_135ck1850 FIND v(dout0_135) AT=930.025n

.meas tran vdout0_136ck1850 FIND v(dout0_136) AT=930.025n

.meas tran vdout0_137ck1850 FIND v(dout0_137) AT=930.025n

.meas tran vdout0_138ck1850 FIND v(dout0_138) AT=930.025n

.meas tran vdout0_139ck1850 FIND v(dout0_139) AT=930.025n

.meas tran vdout0_140ck1850 FIND v(dout0_140) AT=930.025n

.meas tran vdout0_141ck1850 FIND v(dout0_141) AT=930.025n

.meas tran vdout0_142ck1850 FIND v(dout0_142) AT=930.025n

.meas tran vdout0_143ck1850 FIND v(dout0_143) AT=930.025n

.meas tran vdout0_144ck1850 FIND v(dout0_144) AT=930.025n

.meas tran vdout0_145ck1850 FIND v(dout0_145) AT=930.025n

.meas tran vdout0_146ck1850 FIND v(dout0_146) AT=930.025n

.meas tran vdout0_147ck1850 FIND v(dout0_147) AT=930.025n

.meas tran vdout0_148ck1850 FIND v(dout0_148) AT=930.025n

.meas tran vdout0_149ck1850 FIND v(dout0_149) AT=930.025n

.meas tran vdout0_0ck1860 FIND v(dout0_0) AT=935.025n

.meas tran vdout0_1ck1860 FIND v(dout0_1) AT=935.025n

.meas tran vdout0_2ck1860 FIND v(dout0_2) AT=935.025n

.meas tran vdout0_3ck1860 FIND v(dout0_3) AT=935.025n

.meas tran vdout0_4ck1860 FIND v(dout0_4) AT=935.025n

.meas tran vdout0_5ck1860 FIND v(dout0_5) AT=935.025n

.meas tran vdout0_6ck1860 FIND v(dout0_6) AT=935.025n

.meas tran vdout0_7ck1860 FIND v(dout0_7) AT=935.025n

.meas tran vdout0_8ck1860 FIND v(dout0_8) AT=935.025n

.meas tran vdout0_9ck1860 FIND v(dout0_9) AT=935.025n

.meas tran vdout0_10ck1860 FIND v(dout0_10) AT=935.025n

.meas tran vdout0_11ck1860 FIND v(dout0_11) AT=935.025n

.meas tran vdout0_12ck1860 FIND v(dout0_12) AT=935.025n

.meas tran vdout0_13ck1860 FIND v(dout0_13) AT=935.025n

.meas tran vdout0_14ck1860 FIND v(dout0_14) AT=935.025n

.meas tran vdout0_15ck1860 FIND v(dout0_15) AT=935.025n

.meas tran vdout0_16ck1860 FIND v(dout0_16) AT=935.025n

.meas tran vdout0_17ck1860 FIND v(dout0_17) AT=935.025n

.meas tran vdout0_18ck1860 FIND v(dout0_18) AT=935.025n

.meas tran vdout0_19ck1860 FIND v(dout0_19) AT=935.025n

.meas tran vdout0_20ck1860 FIND v(dout0_20) AT=935.025n

.meas tran vdout0_21ck1860 FIND v(dout0_21) AT=935.025n

.meas tran vdout0_22ck1860 FIND v(dout0_22) AT=935.025n

.meas tran vdout0_23ck1860 FIND v(dout0_23) AT=935.025n

.meas tran vdout0_24ck1860 FIND v(dout0_24) AT=935.025n

.meas tran vdout0_25ck1860 FIND v(dout0_25) AT=935.025n

.meas tran vdout0_26ck1860 FIND v(dout0_26) AT=935.025n

.meas tran vdout0_27ck1860 FIND v(dout0_27) AT=935.025n

.meas tran vdout0_28ck1860 FIND v(dout0_28) AT=935.025n

.meas tran vdout0_29ck1860 FIND v(dout0_29) AT=935.025n

.meas tran vdout0_30ck1860 FIND v(dout0_30) AT=935.025n

.meas tran vdout0_31ck1860 FIND v(dout0_31) AT=935.025n

.meas tran vdout0_32ck1860 FIND v(dout0_32) AT=935.025n

.meas tran vdout0_33ck1860 FIND v(dout0_33) AT=935.025n

.meas tran vdout0_34ck1860 FIND v(dout0_34) AT=935.025n

.meas tran vdout0_35ck1860 FIND v(dout0_35) AT=935.025n

.meas tran vdout0_36ck1860 FIND v(dout0_36) AT=935.025n

.meas tran vdout0_37ck1860 FIND v(dout0_37) AT=935.025n

.meas tran vdout0_38ck1860 FIND v(dout0_38) AT=935.025n

.meas tran vdout0_39ck1860 FIND v(dout0_39) AT=935.025n

.meas tran vdout0_40ck1860 FIND v(dout0_40) AT=935.025n

.meas tran vdout0_41ck1860 FIND v(dout0_41) AT=935.025n

.meas tran vdout0_42ck1860 FIND v(dout0_42) AT=935.025n

.meas tran vdout0_43ck1860 FIND v(dout0_43) AT=935.025n

.meas tran vdout0_44ck1860 FIND v(dout0_44) AT=935.025n

.meas tran vdout0_45ck1860 FIND v(dout0_45) AT=935.025n

.meas tran vdout0_46ck1860 FIND v(dout0_46) AT=935.025n

.meas tran vdout0_47ck1860 FIND v(dout0_47) AT=935.025n

.meas tran vdout0_48ck1860 FIND v(dout0_48) AT=935.025n

.meas tran vdout0_49ck1860 FIND v(dout0_49) AT=935.025n

.meas tran vdout0_50ck1860 FIND v(dout0_50) AT=935.025n

.meas tran vdout0_51ck1860 FIND v(dout0_51) AT=935.025n

.meas tran vdout0_52ck1860 FIND v(dout0_52) AT=935.025n

.meas tran vdout0_53ck1860 FIND v(dout0_53) AT=935.025n

.meas tran vdout0_54ck1860 FIND v(dout0_54) AT=935.025n

.meas tran vdout0_55ck1860 FIND v(dout0_55) AT=935.025n

.meas tran vdout0_56ck1860 FIND v(dout0_56) AT=935.025n

.meas tran vdout0_57ck1860 FIND v(dout0_57) AT=935.025n

.meas tran vdout0_58ck1860 FIND v(dout0_58) AT=935.025n

.meas tran vdout0_59ck1860 FIND v(dout0_59) AT=935.025n

.meas tran vdout0_60ck1860 FIND v(dout0_60) AT=935.025n

.meas tran vdout0_61ck1860 FIND v(dout0_61) AT=935.025n

.meas tran vdout0_62ck1860 FIND v(dout0_62) AT=935.025n

.meas tran vdout0_63ck1860 FIND v(dout0_63) AT=935.025n

.meas tran vdout0_64ck1860 FIND v(dout0_64) AT=935.025n

.meas tran vdout0_65ck1860 FIND v(dout0_65) AT=935.025n

.meas tran vdout0_66ck1860 FIND v(dout0_66) AT=935.025n

.meas tran vdout0_67ck1860 FIND v(dout0_67) AT=935.025n

.meas tran vdout0_68ck1860 FIND v(dout0_68) AT=935.025n

.meas tran vdout0_69ck1860 FIND v(dout0_69) AT=935.025n

.meas tran vdout0_70ck1860 FIND v(dout0_70) AT=935.025n

.meas tran vdout0_71ck1860 FIND v(dout0_71) AT=935.025n

.meas tran vdout0_72ck1860 FIND v(dout0_72) AT=935.025n

.meas tran vdout0_73ck1860 FIND v(dout0_73) AT=935.025n

.meas tran vdout0_74ck1860 FIND v(dout0_74) AT=935.025n

.meas tran vdout0_75ck1860 FIND v(dout0_75) AT=935.025n

.meas tran vdout0_76ck1860 FIND v(dout0_76) AT=935.025n

.meas tran vdout0_77ck1860 FIND v(dout0_77) AT=935.025n

.meas tran vdout0_78ck1860 FIND v(dout0_78) AT=935.025n

.meas tran vdout0_79ck1860 FIND v(dout0_79) AT=935.025n

.meas tran vdout0_80ck1860 FIND v(dout0_80) AT=935.025n

.meas tran vdout0_81ck1860 FIND v(dout0_81) AT=935.025n

.meas tran vdout0_82ck1860 FIND v(dout0_82) AT=935.025n

.meas tran vdout0_83ck1860 FIND v(dout0_83) AT=935.025n

.meas tran vdout0_84ck1860 FIND v(dout0_84) AT=935.025n

.meas tran vdout0_85ck1860 FIND v(dout0_85) AT=935.025n

.meas tran vdout0_86ck1860 FIND v(dout0_86) AT=935.025n

.meas tran vdout0_87ck1860 FIND v(dout0_87) AT=935.025n

.meas tran vdout0_88ck1860 FIND v(dout0_88) AT=935.025n

.meas tran vdout0_89ck1860 FIND v(dout0_89) AT=935.025n

.meas tran vdout0_90ck1860 FIND v(dout0_90) AT=935.025n

.meas tran vdout0_91ck1860 FIND v(dout0_91) AT=935.025n

.meas tran vdout0_92ck1860 FIND v(dout0_92) AT=935.025n

.meas tran vdout0_93ck1860 FIND v(dout0_93) AT=935.025n

.meas tran vdout0_94ck1860 FIND v(dout0_94) AT=935.025n

.meas tran vdout0_95ck1860 FIND v(dout0_95) AT=935.025n

.meas tran vdout0_96ck1860 FIND v(dout0_96) AT=935.025n

.meas tran vdout0_97ck1860 FIND v(dout0_97) AT=935.025n

.meas tran vdout0_98ck1860 FIND v(dout0_98) AT=935.025n

.meas tran vdout0_99ck1860 FIND v(dout0_99) AT=935.025n

.meas tran vdout0_100ck1860 FIND v(dout0_100) AT=935.025n

.meas tran vdout0_101ck1860 FIND v(dout0_101) AT=935.025n

.meas tran vdout0_102ck1860 FIND v(dout0_102) AT=935.025n

.meas tran vdout0_103ck1860 FIND v(dout0_103) AT=935.025n

.meas tran vdout0_104ck1860 FIND v(dout0_104) AT=935.025n

.meas tran vdout0_105ck1860 FIND v(dout0_105) AT=935.025n

.meas tran vdout0_106ck1860 FIND v(dout0_106) AT=935.025n

.meas tran vdout0_107ck1860 FIND v(dout0_107) AT=935.025n

.meas tran vdout0_108ck1860 FIND v(dout0_108) AT=935.025n

.meas tran vdout0_109ck1860 FIND v(dout0_109) AT=935.025n

.meas tran vdout0_110ck1860 FIND v(dout0_110) AT=935.025n

.meas tran vdout0_111ck1860 FIND v(dout0_111) AT=935.025n

.meas tran vdout0_112ck1860 FIND v(dout0_112) AT=935.025n

.meas tran vdout0_113ck1860 FIND v(dout0_113) AT=935.025n

.meas tran vdout0_114ck1860 FIND v(dout0_114) AT=935.025n

.meas tran vdout0_115ck1860 FIND v(dout0_115) AT=935.025n

.meas tran vdout0_116ck1860 FIND v(dout0_116) AT=935.025n

.meas tran vdout0_117ck1860 FIND v(dout0_117) AT=935.025n

.meas tran vdout0_118ck1860 FIND v(dout0_118) AT=935.025n

.meas tran vdout0_119ck1860 FIND v(dout0_119) AT=935.025n

.meas tran vdout0_120ck1860 FIND v(dout0_120) AT=935.025n

.meas tran vdout0_121ck1860 FIND v(dout0_121) AT=935.025n

.meas tran vdout0_122ck1860 FIND v(dout0_122) AT=935.025n

.meas tran vdout0_123ck1860 FIND v(dout0_123) AT=935.025n

.meas tran vdout0_124ck1860 FIND v(dout0_124) AT=935.025n

.meas tran vdout0_125ck1860 FIND v(dout0_125) AT=935.025n

.meas tran vdout0_126ck1860 FIND v(dout0_126) AT=935.025n

.meas tran vdout0_127ck1860 FIND v(dout0_127) AT=935.025n

.meas tran vdout0_128ck1860 FIND v(dout0_128) AT=935.025n

.meas tran vdout0_129ck1860 FIND v(dout0_129) AT=935.025n

.meas tran vdout0_130ck1860 FIND v(dout0_130) AT=935.025n

.meas tran vdout0_131ck1860 FIND v(dout0_131) AT=935.025n

.meas tran vdout0_132ck1860 FIND v(dout0_132) AT=935.025n

.meas tran vdout0_133ck1860 FIND v(dout0_133) AT=935.025n

.meas tran vdout0_134ck1860 FIND v(dout0_134) AT=935.025n

.meas tran vdout0_135ck1860 FIND v(dout0_135) AT=935.025n

.meas tran vdout0_136ck1860 FIND v(dout0_136) AT=935.025n

.meas tran vdout0_137ck1860 FIND v(dout0_137) AT=935.025n

.meas tran vdout0_138ck1860 FIND v(dout0_138) AT=935.025n

.meas tran vdout0_139ck1860 FIND v(dout0_139) AT=935.025n

.meas tran vdout0_140ck1860 FIND v(dout0_140) AT=935.025n

.meas tran vdout0_141ck1860 FIND v(dout0_141) AT=935.025n

.meas tran vdout0_142ck1860 FIND v(dout0_142) AT=935.025n

.meas tran vdout0_143ck1860 FIND v(dout0_143) AT=935.025n

.meas tran vdout0_144ck1860 FIND v(dout0_144) AT=935.025n

.meas tran vdout0_145ck1860 FIND v(dout0_145) AT=935.025n

.meas tran vdout0_146ck1860 FIND v(dout0_146) AT=935.025n

.meas tran vdout0_147ck1860 FIND v(dout0_147) AT=935.025n

.meas tran vdout0_148ck1860 FIND v(dout0_148) AT=935.025n

.meas tran vdout0_149ck1860 FIND v(dout0_149) AT=935.025n

.meas tran vdout0_0ck1870 FIND v(dout0_0) AT=940.025n

.meas tran vdout0_1ck1870 FIND v(dout0_1) AT=940.025n

.meas tran vdout0_2ck1870 FIND v(dout0_2) AT=940.025n

.meas tran vdout0_3ck1870 FIND v(dout0_3) AT=940.025n

.meas tran vdout0_4ck1870 FIND v(dout0_4) AT=940.025n

.meas tran vdout0_5ck1870 FIND v(dout0_5) AT=940.025n

.meas tran vdout0_6ck1870 FIND v(dout0_6) AT=940.025n

.meas tran vdout0_7ck1870 FIND v(dout0_7) AT=940.025n

.meas tran vdout0_8ck1870 FIND v(dout0_8) AT=940.025n

.meas tran vdout0_9ck1870 FIND v(dout0_9) AT=940.025n

.meas tran vdout0_10ck1870 FIND v(dout0_10) AT=940.025n

.meas tran vdout0_11ck1870 FIND v(dout0_11) AT=940.025n

.meas tran vdout0_12ck1870 FIND v(dout0_12) AT=940.025n

.meas tran vdout0_13ck1870 FIND v(dout0_13) AT=940.025n

.meas tran vdout0_14ck1870 FIND v(dout0_14) AT=940.025n

.meas tran vdout0_15ck1870 FIND v(dout0_15) AT=940.025n

.meas tran vdout0_16ck1870 FIND v(dout0_16) AT=940.025n

.meas tran vdout0_17ck1870 FIND v(dout0_17) AT=940.025n

.meas tran vdout0_18ck1870 FIND v(dout0_18) AT=940.025n

.meas tran vdout0_19ck1870 FIND v(dout0_19) AT=940.025n

.meas tran vdout0_20ck1870 FIND v(dout0_20) AT=940.025n

.meas tran vdout0_21ck1870 FIND v(dout0_21) AT=940.025n

.meas tran vdout0_22ck1870 FIND v(dout0_22) AT=940.025n

.meas tran vdout0_23ck1870 FIND v(dout0_23) AT=940.025n

.meas tran vdout0_24ck1870 FIND v(dout0_24) AT=940.025n

.meas tran vdout0_25ck1870 FIND v(dout0_25) AT=940.025n

.meas tran vdout0_26ck1870 FIND v(dout0_26) AT=940.025n

.meas tran vdout0_27ck1870 FIND v(dout0_27) AT=940.025n

.meas tran vdout0_28ck1870 FIND v(dout0_28) AT=940.025n

.meas tran vdout0_29ck1870 FIND v(dout0_29) AT=940.025n

.meas tran vdout0_30ck1870 FIND v(dout0_30) AT=940.025n

.meas tran vdout0_31ck1870 FIND v(dout0_31) AT=940.025n

.meas tran vdout0_32ck1870 FIND v(dout0_32) AT=940.025n

.meas tran vdout0_33ck1870 FIND v(dout0_33) AT=940.025n

.meas tran vdout0_34ck1870 FIND v(dout0_34) AT=940.025n

.meas tran vdout0_35ck1870 FIND v(dout0_35) AT=940.025n

.meas tran vdout0_36ck1870 FIND v(dout0_36) AT=940.025n

.meas tran vdout0_37ck1870 FIND v(dout0_37) AT=940.025n

.meas tran vdout0_38ck1870 FIND v(dout0_38) AT=940.025n

.meas tran vdout0_39ck1870 FIND v(dout0_39) AT=940.025n

.meas tran vdout0_40ck1870 FIND v(dout0_40) AT=940.025n

.meas tran vdout0_41ck1870 FIND v(dout0_41) AT=940.025n

.meas tran vdout0_42ck1870 FIND v(dout0_42) AT=940.025n

.meas tran vdout0_43ck1870 FIND v(dout0_43) AT=940.025n

.meas tran vdout0_44ck1870 FIND v(dout0_44) AT=940.025n

.meas tran vdout0_45ck1870 FIND v(dout0_45) AT=940.025n

.meas tran vdout0_46ck1870 FIND v(dout0_46) AT=940.025n

.meas tran vdout0_47ck1870 FIND v(dout0_47) AT=940.025n

.meas tran vdout0_48ck1870 FIND v(dout0_48) AT=940.025n

.meas tran vdout0_49ck1870 FIND v(dout0_49) AT=940.025n

.meas tran vdout0_50ck1870 FIND v(dout0_50) AT=940.025n

.meas tran vdout0_51ck1870 FIND v(dout0_51) AT=940.025n

.meas tran vdout0_52ck1870 FIND v(dout0_52) AT=940.025n

.meas tran vdout0_53ck1870 FIND v(dout0_53) AT=940.025n

.meas tran vdout0_54ck1870 FIND v(dout0_54) AT=940.025n

.meas tran vdout0_55ck1870 FIND v(dout0_55) AT=940.025n

.meas tran vdout0_56ck1870 FIND v(dout0_56) AT=940.025n

.meas tran vdout0_57ck1870 FIND v(dout0_57) AT=940.025n

.meas tran vdout0_58ck1870 FIND v(dout0_58) AT=940.025n

.meas tran vdout0_59ck1870 FIND v(dout0_59) AT=940.025n

.meas tran vdout0_60ck1870 FIND v(dout0_60) AT=940.025n

.meas tran vdout0_61ck1870 FIND v(dout0_61) AT=940.025n

.meas tran vdout0_62ck1870 FIND v(dout0_62) AT=940.025n

.meas tran vdout0_63ck1870 FIND v(dout0_63) AT=940.025n

.meas tran vdout0_64ck1870 FIND v(dout0_64) AT=940.025n

.meas tran vdout0_65ck1870 FIND v(dout0_65) AT=940.025n

.meas tran vdout0_66ck1870 FIND v(dout0_66) AT=940.025n

.meas tran vdout0_67ck1870 FIND v(dout0_67) AT=940.025n

.meas tran vdout0_68ck1870 FIND v(dout0_68) AT=940.025n

.meas tran vdout0_69ck1870 FIND v(dout0_69) AT=940.025n

.meas tran vdout0_70ck1870 FIND v(dout0_70) AT=940.025n

.meas tran vdout0_71ck1870 FIND v(dout0_71) AT=940.025n

.meas tran vdout0_72ck1870 FIND v(dout0_72) AT=940.025n

.meas tran vdout0_73ck1870 FIND v(dout0_73) AT=940.025n

.meas tran vdout0_74ck1870 FIND v(dout0_74) AT=940.025n

.meas tran vdout0_75ck1870 FIND v(dout0_75) AT=940.025n

.meas tran vdout0_76ck1870 FIND v(dout0_76) AT=940.025n

.meas tran vdout0_77ck1870 FIND v(dout0_77) AT=940.025n

.meas tran vdout0_78ck1870 FIND v(dout0_78) AT=940.025n

.meas tran vdout0_79ck1870 FIND v(dout0_79) AT=940.025n

.meas tran vdout0_80ck1870 FIND v(dout0_80) AT=940.025n

.meas tran vdout0_81ck1870 FIND v(dout0_81) AT=940.025n

.meas tran vdout0_82ck1870 FIND v(dout0_82) AT=940.025n

.meas tran vdout0_83ck1870 FIND v(dout0_83) AT=940.025n

.meas tran vdout0_84ck1870 FIND v(dout0_84) AT=940.025n

.meas tran vdout0_85ck1870 FIND v(dout0_85) AT=940.025n

.meas tran vdout0_86ck1870 FIND v(dout0_86) AT=940.025n

.meas tran vdout0_87ck1870 FIND v(dout0_87) AT=940.025n

.meas tran vdout0_88ck1870 FIND v(dout0_88) AT=940.025n

.meas tran vdout0_89ck1870 FIND v(dout0_89) AT=940.025n

.meas tran vdout0_90ck1870 FIND v(dout0_90) AT=940.025n

.meas tran vdout0_91ck1870 FIND v(dout0_91) AT=940.025n

.meas tran vdout0_92ck1870 FIND v(dout0_92) AT=940.025n

.meas tran vdout0_93ck1870 FIND v(dout0_93) AT=940.025n

.meas tran vdout0_94ck1870 FIND v(dout0_94) AT=940.025n

.meas tran vdout0_95ck1870 FIND v(dout0_95) AT=940.025n

.meas tran vdout0_96ck1870 FIND v(dout0_96) AT=940.025n

.meas tran vdout0_97ck1870 FIND v(dout0_97) AT=940.025n

.meas tran vdout0_98ck1870 FIND v(dout0_98) AT=940.025n

.meas tran vdout0_99ck1870 FIND v(dout0_99) AT=940.025n

.meas tran vdout0_100ck1870 FIND v(dout0_100) AT=940.025n

.meas tran vdout0_101ck1870 FIND v(dout0_101) AT=940.025n

.meas tran vdout0_102ck1870 FIND v(dout0_102) AT=940.025n

.meas tran vdout0_103ck1870 FIND v(dout0_103) AT=940.025n

.meas tran vdout0_104ck1870 FIND v(dout0_104) AT=940.025n

.meas tran vdout0_105ck1870 FIND v(dout0_105) AT=940.025n

.meas tran vdout0_106ck1870 FIND v(dout0_106) AT=940.025n

.meas tran vdout0_107ck1870 FIND v(dout0_107) AT=940.025n

.meas tran vdout0_108ck1870 FIND v(dout0_108) AT=940.025n

.meas tran vdout0_109ck1870 FIND v(dout0_109) AT=940.025n

.meas tran vdout0_110ck1870 FIND v(dout0_110) AT=940.025n

.meas tran vdout0_111ck1870 FIND v(dout0_111) AT=940.025n

.meas tran vdout0_112ck1870 FIND v(dout0_112) AT=940.025n

.meas tran vdout0_113ck1870 FIND v(dout0_113) AT=940.025n

.meas tran vdout0_114ck1870 FIND v(dout0_114) AT=940.025n

.meas tran vdout0_115ck1870 FIND v(dout0_115) AT=940.025n

.meas tran vdout0_116ck1870 FIND v(dout0_116) AT=940.025n

.meas tran vdout0_117ck1870 FIND v(dout0_117) AT=940.025n

.meas tran vdout0_118ck1870 FIND v(dout0_118) AT=940.025n

.meas tran vdout0_119ck1870 FIND v(dout0_119) AT=940.025n

.meas tran vdout0_120ck1870 FIND v(dout0_120) AT=940.025n

.meas tran vdout0_121ck1870 FIND v(dout0_121) AT=940.025n

.meas tran vdout0_122ck1870 FIND v(dout0_122) AT=940.025n

.meas tran vdout0_123ck1870 FIND v(dout0_123) AT=940.025n

.meas tran vdout0_124ck1870 FIND v(dout0_124) AT=940.025n

.meas tran vdout0_125ck1870 FIND v(dout0_125) AT=940.025n

.meas tran vdout0_126ck1870 FIND v(dout0_126) AT=940.025n

.meas tran vdout0_127ck1870 FIND v(dout0_127) AT=940.025n

.meas tran vdout0_128ck1870 FIND v(dout0_128) AT=940.025n

.meas tran vdout0_129ck1870 FIND v(dout0_129) AT=940.025n

.meas tran vdout0_130ck1870 FIND v(dout0_130) AT=940.025n

.meas tran vdout0_131ck1870 FIND v(dout0_131) AT=940.025n

.meas tran vdout0_132ck1870 FIND v(dout0_132) AT=940.025n

.meas tran vdout0_133ck1870 FIND v(dout0_133) AT=940.025n

.meas tran vdout0_134ck1870 FIND v(dout0_134) AT=940.025n

.meas tran vdout0_135ck1870 FIND v(dout0_135) AT=940.025n

.meas tran vdout0_136ck1870 FIND v(dout0_136) AT=940.025n

.meas tran vdout0_137ck1870 FIND v(dout0_137) AT=940.025n

.meas tran vdout0_138ck1870 FIND v(dout0_138) AT=940.025n

.meas tran vdout0_139ck1870 FIND v(dout0_139) AT=940.025n

.meas tran vdout0_140ck1870 FIND v(dout0_140) AT=940.025n

.meas tran vdout0_141ck1870 FIND v(dout0_141) AT=940.025n

.meas tran vdout0_142ck1870 FIND v(dout0_142) AT=940.025n

.meas tran vdout0_143ck1870 FIND v(dout0_143) AT=940.025n

.meas tran vdout0_144ck1870 FIND v(dout0_144) AT=940.025n

.meas tran vdout0_145ck1870 FIND v(dout0_145) AT=940.025n

.meas tran vdout0_146ck1870 FIND v(dout0_146) AT=940.025n

.meas tran vdout0_147ck1870 FIND v(dout0_147) AT=940.025n

.meas tran vdout0_148ck1870 FIND v(dout0_148) AT=940.025n

.meas tran vdout0_149ck1870 FIND v(dout0_149) AT=940.025n

.meas tran vdout0_0ck1880 FIND v(dout0_0) AT=945.025n

.meas tran vdout0_1ck1880 FIND v(dout0_1) AT=945.025n

.meas tran vdout0_2ck1880 FIND v(dout0_2) AT=945.025n

.meas tran vdout0_3ck1880 FIND v(dout0_3) AT=945.025n

.meas tran vdout0_4ck1880 FIND v(dout0_4) AT=945.025n

.meas tran vdout0_5ck1880 FIND v(dout0_5) AT=945.025n

.meas tran vdout0_6ck1880 FIND v(dout0_6) AT=945.025n

.meas tran vdout0_7ck1880 FIND v(dout0_7) AT=945.025n

.meas tran vdout0_8ck1880 FIND v(dout0_8) AT=945.025n

.meas tran vdout0_9ck1880 FIND v(dout0_9) AT=945.025n

.meas tran vdout0_10ck1880 FIND v(dout0_10) AT=945.025n

.meas tran vdout0_11ck1880 FIND v(dout0_11) AT=945.025n

.meas tran vdout0_12ck1880 FIND v(dout0_12) AT=945.025n

.meas tran vdout0_13ck1880 FIND v(dout0_13) AT=945.025n

.meas tran vdout0_14ck1880 FIND v(dout0_14) AT=945.025n

.meas tran vdout0_15ck1880 FIND v(dout0_15) AT=945.025n

.meas tran vdout0_16ck1880 FIND v(dout0_16) AT=945.025n

.meas tran vdout0_17ck1880 FIND v(dout0_17) AT=945.025n

.meas tran vdout0_18ck1880 FIND v(dout0_18) AT=945.025n

.meas tran vdout0_19ck1880 FIND v(dout0_19) AT=945.025n

.meas tran vdout0_20ck1880 FIND v(dout0_20) AT=945.025n

.meas tran vdout0_21ck1880 FIND v(dout0_21) AT=945.025n

.meas tran vdout0_22ck1880 FIND v(dout0_22) AT=945.025n

.meas tran vdout0_23ck1880 FIND v(dout0_23) AT=945.025n

.meas tran vdout0_24ck1880 FIND v(dout0_24) AT=945.025n

.meas tran vdout0_25ck1880 FIND v(dout0_25) AT=945.025n

.meas tran vdout0_26ck1880 FIND v(dout0_26) AT=945.025n

.meas tran vdout0_27ck1880 FIND v(dout0_27) AT=945.025n

.meas tran vdout0_28ck1880 FIND v(dout0_28) AT=945.025n

.meas tran vdout0_29ck1880 FIND v(dout0_29) AT=945.025n

.meas tran vdout0_30ck1880 FIND v(dout0_30) AT=945.025n

.meas tran vdout0_31ck1880 FIND v(dout0_31) AT=945.025n

.meas tran vdout0_32ck1880 FIND v(dout0_32) AT=945.025n

.meas tran vdout0_33ck1880 FIND v(dout0_33) AT=945.025n

.meas tran vdout0_34ck1880 FIND v(dout0_34) AT=945.025n

.meas tran vdout0_35ck1880 FIND v(dout0_35) AT=945.025n

.meas tran vdout0_36ck1880 FIND v(dout0_36) AT=945.025n

.meas tran vdout0_37ck1880 FIND v(dout0_37) AT=945.025n

.meas tran vdout0_38ck1880 FIND v(dout0_38) AT=945.025n

.meas tran vdout0_39ck1880 FIND v(dout0_39) AT=945.025n

.meas tran vdout0_40ck1880 FIND v(dout0_40) AT=945.025n

.meas tran vdout0_41ck1880 FIND v(dout0_41) AT=945.025n

.meas tran vdout0_42ck1880 FIND v(dout0_42) AT=945.025n

.meas tran vdout0_43ck1880 FIND v(dout0_43) AT=945.025n

.meas tran vdout0_44ck1880 FIND v(dout0_44) AT=945.025n

.meas tran vdout0_45ck1880 FIND v(dout0_45) AT=945.025n

.meas tran vdout0_46ck1880 FIND v(dout0_46) AT=945.025n

.meas tran vdout0_47ck1880 FIND v(dout0_47) AT=945.025n

.meas tran vdout0_48ck1880 FIND v(dout0_48) AT=945.025n

.meas tran vdout0_49ck1880 FIND v(dout0_49) AT=945.025n

.meas tran vdout0_50ck1880 FIND v(dout0_50) AT=945.025n

.meas tran vdout0_51ck1880 FIND v(dout0_51) AT=945.025n

.meas tran vdout0_52ck1880 FIND v(dout0_52) AT=945.025n

.meas tran vdout0_53ck1880 FIND v(dout0_53) AT=945.025n

.meas tran vdout0_54ck1880 FIND v(dout0_54) AT=945.025n

.meas tran vdout0_55ck1880 FIND v(dout0_55) AT=945.025n

.meas tran vdout0_56ck1880 FIND v(dout0_56) AT=945.025n

.meas tran vdout0_57ck1880 FIND v(dout0_57) AT=945.025n

.meas tran vdout0_58ck1880 FIND v(dout0_58) AT=945.025n

.meas tran vdout0_59ck1880 FIND v(dout0_59) AT=945.025n

.meas tran vdout0_60ck1880 FIND v(dout0_60) AT=945.025n

.meas tran vdout0_61ck1880 FIND v(dout0_61) AT=945.025n

.meas tran vdout0_62ck1880 FIND v(dout0_62) AT=945.025n

.meas tran vdout0_63ck1880 FIND v(dout0_63) AT=945.025n

.meas tran vdout0_64ck1880 FIND v(dout0_64) AT=945.025n

.meas tran vdout0_65ck1880 FIND v(dout0_65) AT=945.025n

.meas tran vdout0_66ck1880 FIND v(dout0_66) AT=945.025n

.meas tran vdout0_67ck1880 FIND v(dout0_67) AT=945.025n

.meas tran vdout0_68ck1880 FIND v(dout0_68) AT=945.025n

.meas tran vdout0_69ck1880 FIND v(dout0_69) AT=945.025n

.meas tran vdout0_70ck1880 FIND v(dout0_70) AT=945.025n

.meas tran vdout0_71ck1880 FIND v(dout0_71) AT=945.025n

.meas tran vdout0_72ck1880 FIND v(dout0_72) AT=945.025n

.meas tran vdout0_73ck1880 FIND v(dout0_73) AT=945.025n

.meas tran vdout0_74ck1880 FIND v(dout0_74) AT=945.025n

.meas tran vdout0_75ck1880 FIND v(dout0_75) AT=945.025n

.meas tran vdout0_76ck1880 FIND v(dout0_76) AT=945.025n

.meas tran vdout0_77ck1880 FIND v(dout0_77) AT=945.025n

.meas tran vdout0_78ck1880 FIND v(dout0_78) AT=945.025n

.meas tran vdout0_79ck1880 FIND v(dout0_79) AT=945.025n

.meas tran vdout0_80ck1880 FIND v(dout0_80) AT=945.025n

.meas tran vdout0_81ck1880 FIND v(dout0_81) AT=945.025n

.meas tran vdout0_82ck1880 FIND v(dout0_82) AT=945.025n

.meas tran vdout0_83ck1880 FIND v(dout0_83) AT=945.025n

.meas tran vdout0_84ck1880 FIND v(dout0_84) AT=945.025n

.meas tran vdout0_85ck1880 FIND v(dout0_85) AT=945.025n

.meas tran vdout0_86ck1880 FIND v(dout0_86) AT=945.025n

.meas tran vdout0_87ck1880 FIND v(dout0_87) AT=945.025n

.meas tran vdout0_88ck1880 FIND v(dout0_88) AT=945.025n

.meas tran vdout0_89ck1880 FIND v(dout0_89) AT=945.025n

.meas tran vdout0_90ck1880 FIND v(dout0_90) AT=945.025n

.meas tran vdout0_91ck1880 FIND v(dout0_91) AT=945.025n

.meas tran vdout0_92ck1880 FIND v(dout0_92) AT=945.025n

.meas tran vdout0_93ck1880 FIND v(dout0_93) AT=945.025n

.meas tran vdout0_94ck1880 FIND v(dout0_94) AT=945.025n

.meas tran vdout0_95ck1880 FIND v(dout0_95) AT=945.025n

.meas tran vdout0_96ck1880 FIND v(dout0_96) AT=945.025n

.meas tran vdout0_97ck1880 FIND v(dout0_97) AT=945.025n

.meas tran vdout0_98ck1880 FIND v(dout0_98) AT=945.025n

.meas tran vdout0_99ck1880 FIND v(dout0_99) AT=945.025n

.meas tran vdout0_100ck1880 FIND v(dout0_100) AT=945.025n

.meas tran vdout0_101ck1880 FIND v(dout0_101) AT=945.025n

.meas tran vdout0_102ck1880 FIND v(dout0_102) AT=945.025n

.meas tran vdout0_103ck1880 FIND v(dout0_103) AT=945.025n

.meas tran vdout0_104ck1880 FIND v(dout0_104) AT=945.025n

.meas tran vdout0_105ck1880 FIND v(dout0_105) AT=945.025n

.meas tran vdout0_106ck1880 FIND v(dout0_106) AT=945.025n

.meas tran vdout0_107ck1880 FIND v(dout0_107) AT=945.025n

.meas tran vdout0_108ck1880 FIND v(dout0_108) AT=945.025n

.meas tran vdout0_109ck1880 FIND v(dout0_109) AT=945.025n

.meas tran vdout0_110ck1880 FIND v(dout0_110) AT=945.025n

.meas tran vdout0_111ck1880 FIND v(dout0_111) AT=945.025n

.meas tran vdout0_112ck1880 FIND v(dout0_112) AT=945.025n

.meas tran vdout0_113ck1880 FIND v(dout0_113) AT=945.025n

.meas tran vdout0_114ck1880 FIND v(dout0_114) AT=945.025n

.meas tran vdout0_115ck1880 FIND v(dout0_115) AT=945.025n

.meas tran vdout0_116ck1880 FIND v(dout0_116) AT=945.025n

.meas tran vdout0_117ck1880 FIND v(dout0_117) AT=945.025n

.meas tran vdout0_118ck1880 FIND v(dout0_118) AT=945.025n

.meas tran vdout0_119ck1880 FIND v(dout0_119) AT=945.025n

.meas tran vdout0_120ck1880 FIND v(dout0_120) AT=945.025n

.meas tran vdout0_121ck1880 FIND v(dout0_121) AT=945.025n

.meas tran vdout0_122ck1880 FIND v(dout0_122) AT=945.025n

.meas tran vdout0_123ck1880 FIND v(dout0_123) AT=945.025n

.meas tran vdout0_124ck1880 FIND v(dout0_124) AT=945.025n

.meas tran vdout0_125ck1880 FIND v(dout0_125) AT=945.025n

.meas tran vdout0_126ck1880 FIND v(dout0_126) AT=945.025n

.meas tran vdout0_127ck1880 FIND v(dout0_127) AT=945.025n

.meas tran vdout0_128ck1880 FIND v(dout0_128) AT=945.025n

.meas tran vdout0_129ck1880 FIND v(dout0_129) AT=945.025n

.meas tran vdout0_130ck1880 FIND v(dout0_130) AT=945.025n

.meas tran vdout0_131ck1880 FIND v(dout0_131) AT=945.025n

.meas tran vdout0_132ck1880 FIND v(dout0_132) AT=945.025n

.meas tran vdout0_133ck1880 FIND v(dout0_133) AT=945.025n

.meas tran vdout0_134ck1880 FIND v(dout0_134) AT=945.025n

.meas tran vdout0_135ck1880 FIND v(dout0_135) AT=945.025n

.meas tran vdout0_136ck1880 FIND v(dout0_136) AT=945.025n

.meas tran vdout0_137ck1880 FIND v(dout0_137) AT=945.025n

.meas tran vdout0_138ck1880 FIND v(dout0_138) AT=945.025n

.meas tran vdout0_139ck1880 FIND v(dout0_139) AT=945.025n

.meas tran vdout0_140ck1880 FIND v(dout0_140) AT=945.025n

.meas tran vdout0_141ck1880 FIND v(dout0_141) AT=945.025n

.meas tran vdout0_142ck1880 FIND v(dout0_142) AT=945.025n

.meas tran vdout0_143ck1880 FIND v(dout0_143) AT=945.025n

.meas tran vdout0_144ck1880 FIND v(dout0_144) AT=945.025n

.meas tran vdout0_145ck1880 FIND v(dout0_145) AT=945.025n

.meas tran vdout0_146ck1880 FIND v(dout0_146) AT=945.025n

.meas tran vdout0_147ck1880 FIND v(dout0_147) AT=945.025n

.meas tran vdout0_148ck1880 FIND v(dout0_148) AT=945.025n

.meas tran vdout0_149ck1880 FIND v(dout0_149) AT=945.025n

.meas tran vdout0_0ck1890 FIND v(dout0_0) AT=950.025n

.meas tran vdout0_1ck1890 FIND v(dout0_1) AT=950.025n

.meas tran vdout0_2ck1890 FIND v(dout0_2) AT=950.025n

.meas tran vdout0_3ck1890 FIND v(dout0_3) AT=950.025n

.meas tran vdout0_4ck1890 FIND v(dout0_4) AT=950.025n

.meas tran vdout0_5ck1890 FIND v(dout0_5) AT=950.025n

.meas tran vdout0_6ck1890 FIND v(dout0_6) AT=950.025n

.meas tran vdout0_7ck1890 FIND v(dout0_7) AT=950.025n

.meas tran vdout0_8ck1890 FIND v(dout0_8) AT=950.025n

.meas tran vdout0_9ck1890 FIND v(dout0_9) AT=950.025n

.meas tran vdout0_10ck1890 FIND v(dout0_10) AT=950.025n

.meas tran vdout0_11ck1890 FIND v(dout0_11) AT=950.025n

.meas tran vdout0_12ck1890 FIND v(dout0_12) AT=950.025n

.meas tran vdout0_13ck1890 FIND v(dout0_13) AT=950.025n

.meas tran vdout0_14ck1890 FIND v(dout0_14) AT=950.025n

.meas tran vdout0_15ck1890 FIND v(dout0_15) AT=950.025n

.meas tran vdout0_16ck1890 FIND v(dout0_16) AT=950.025n

.meas tran vdout0_17ck1890 FIND v(dout0_17) AT=950.025n

.meas tran vdout0_18ck1890 FIND v(dout0_18) AT=950.025n

.meas tran vdout0_19ck1890 FIND v(dout0_19) AT=950.025n

.meas tran vdout0_20ck1890 FIND v(dout0_20) AT=950.025n

.meas tran vdout0_21ck1890 FIND v(dout0_21) AT=950.025n

.meas tran vdout0_22ck1890 FIND v(dout0_22) AT=950.025n

.meas tran vdout0_23ck1890 FIND v(dout0_23) AT=950.025n

.meas tran vdout0_24ck1890 FIND v(dout0_24) AT=950.025n

.meas tran vdout0_25ck1890 FIND v(dout0_25) AT=950.025n

.meas tran vdout0_26ck1890 FIND v(dout0_26) AT=950.025n

.meas tran vdout0_27ck1890 FIND v(dout0_27) AT=950.025n

.meas tran vdout0_28ck1890 FIND v(dout0_28) AT=950.025n

.meas tran vdout0_29ck1890 FIND v(dout0_29) AT=950.025n

.meas tran vdout0_30ck1890 FIND v(dout0_30) AT=950.025n

.meas tran vdout0_31ck1890 FIND v(dout0_31) AT=950.025n

.meas tran vdout0_32ck1890 FIND v(dout0_32) AT=950.025n

.meas tran vdout0_33ck1890 FIND v(dout0_33) AT=950.025n

.meas tran vdout0_34ck1890 FIND v(dout0_34) AT=950.025n

.meas tran vdout0_35ck1890 FIND v(dout0_35) AT=950.025n

.meas tran vdout0_36ck1890 FIND v(dout0_36) AT=950.025n

.meas tran vdout0_37ck1890 FIND v(dout0_37) AT=950.025n

.meas tran vdout0_38ck1890 FIND v(dout0_38) AT=950.025n

.meas tran vdout0_39ck1890 FIND v(dout0_39) AT=950.025n

.meas tran vdout0_40ck1890 FIND v(dout0_40) AT=950.025n

.meas tran vdout0_41ck1890 FIND v(dout0_41) AT=950.025n

.meas tran vdout0_42ck1890 FIND v(dout0_42) AT=950.025n

.meas tran vdout0_43ck1890 FIND v(dout0_43) AT=950.025n

.meas tran vdout0_44ck1890 FIND v(dout0_44) AT=950.025n

.meas tran vdout0_45ck1890 FIND v(dout0_45) AT=950.025n

.meas tran vdout0_46ck1890 FIND v(dout0_46) AT=950.025n

.meas tran vdout0_47ck1890 FIND v(dout0_47) AT=950.025n

.meas tran vdout0_48ck1890 FIND v(dout0_48) AT=950.025n

.meas tran vdout0_49ck1890 FIND v(dout0_49) AT=950.025n

.meas tran vdout0_50ck1890 FIND v(dout0_50) AT=950.025n

.meas tran vdout0_51ck1890 FIND v(dout0_51) AT=950.025n

.meas tran vdout0_52ck1890 FIND v(dout0_52) AT=950.025n

.meas tran vdout0_53ck1890 FIND v(dout0_53) AT=950.025n

.meas tran vdout0_54ck1890 FIND v(dout0_54) AT=950.025n

.meas tran vdout0_55ck1890 FIND v(dout0_55) AT=950.025n

.meas tran vdout0_56ck1890 FIND v(dout0_56) AT=950.025n

.meas tran vdout0_57ck1890 FIND v(dout0_57) AT=950.025n

.meas tran vdout0_58ck1890 FIND v(dout0_58) AT=950.025n

.meas tran vdout0_59ck1890 FIND v(dout0_59) AT=950.025n

.meas tran vdout0_60ck1890 FIND v(dout0_60) AT=950.025n

.meas tran vdout0_61ck1890 FIND v(dout0_61) AT=950.025n

.meas tran vdout0_62ck1890 FIND v(dout0_62) AT=950.025n

.meas tran vdout0_63ck1890 FIND v(dout0_63) AT=950.025n

.meas tran vdout0_64ck1890 FIND v(dout0_64) AT=950.025n

.meas tran vdout0_65ck1890 FIND v(dout0_65) AT=950.025n

.meas tran vdout0_66ck1890 FIND v(dout0_66) AT=950.025n

.meas tran vdout0_67ck1890 FIND v(dout0_67) AT=950.025n

.meas tran vdout0_68ck1890 FIND v(dout0_68) AT=950.025n

.meas tran vdout0_69ck1890 FIND v(dout0_69) AT=950.025n

.meas tran vdout0_70ck1890 FIND v(dout0_70) AT=950.025n

.meas tran vdout0_71ck1890 FIND v(dout0_71) AT=950.025n

.meas tran vdout0_72ck1890 FIND v(dout0_72) AT=950.025n

.meas tran vdout0_73ck1890 FIND v(dout0_73) AT=950.025n

.meas tran vdout0_74ck1890 FIND v(dout0_74) AT=950.025n

.meas tran vdout0_75ck1890 FIND v(dout0_75) AT=950.025n

.meas tran vdout0_76ck1890 FIND v(dout0_76) AT=950.025n

.meas tran vdout0_77ck1890 FIND v(dout0_77) AT=950.025n

.meas tran vdout0_78ck1890 FIND v(dout0_78) AT=950.025n

.meas tran vdout0_79ck1890 FIND v(dout0_79) AT=950.025n

.meas tran vdout0_80ck1890 FIND v(dout0_80) AT=950.025n

.meas tran vdout0_81ck1890 FIND v(dout0_81) AT=950.025n

.meas tran vdout0_82ck1890 FIND v(dout0_82) AT=950.025n

.meas tran vdout0_83ck1890 FIND v(dout0_83) AT=950.025n

.meas tran vdout0_84ck1890 FIND v(dout0_84) AT=950.025n

.meas tran vdout0_85ck1890 FIND v(dout0_85) AT=950.025n

.meas tran vdout0_86ck1890 FIND v(dout0_86) AT=950.025n

.meas tran vdout0_87ck1890 FIND v(dout0_87) AT=950.025n

.meas tran vdout0_88ck1890 FIND v(dout0_88) AT=950.025n

.meas tran vdout0_89ck1890 FIND v(dout0_89) AT=950.025n

.meas tran vdout0_90ck1890 FIND v(dout0_90) AT=950.025n

.meas tran vdout0_91ck1890 FIND v(dout0_91) AT=950.025n

.meas tran vdout0_92ck1890 FIND v(dout0_92) AT=950.025n

.meas tran vdout0_93ck1890 FIND v(dout0_93) AT=950.025n

.meas tran vdout0_94ck1890 FIND v(dout0_94) AT=950.025n

.meas tran vdout0_95ck1890 FIND v(dout0_95) AT=950.025n

.meas tran vdout0_96ck1890 FIND v(dout0_96) AT=950.025n

.meas tran vdout0_97ck1890 FIND v(dout0_97) AT=950.025n

.meas tran vdout0_98ck1890 FIND v(dout0_98) AT=950.025n

.meas tran vdout0_99ck1890 FIND v(dout0_99) AT=950.025n

.meas tran vdout0_100ck1890 FIND v(dout0_100) AT=950.025n

.meas tran vdout0_101ck1890 FIND v(dout0_101) AT=950.025n

.meas tran vdout0_102ck1890 FIND v(dout0_102) AT=950.025n

.meas tran vdout0_103ck1890 FIND v(dout0_103) AT=950.025n

.meas tran vdout0_104ck1890 FIND v(dout0_104) AT=950.025n

.meas tran vdout0_105ck1890 FIND v(dout0_105) AT=950.025n

.meas tran vdout0_106ck1890 FIND v(dout0_106) AT=950.025n

.meas tran vdout0_107ck1890 FIND v(dout0_107) AT=950.025n

.meas tran vdout0_108ck1890 FIND v(dout0_108) AT=950.025n

.meas tran vdout0_109ck1890 FIND v(dout0_109) AT=950.025n

.meas tran vdout0_110ck1890 FIND v(dout0_110) AT=950.025n

.meas tran vdout0_111ck1890 FIND v(dout0_111) AT=950.025n

.meas tran vdout0_112ck1890 FIND v(dout0_112) AT=950.025n

.meas tran vdout0_113ck1890 FIND v(dout0_113) AT=950.025n

.meas tran vdout0_114ck1890 FIND v(dout0_114) AT=950.025n

.meas tran vdout0_115ck1890 FIND v(dout0_115) AT=950.025n

.meas tran vdout0_116ck1890 FIND v(dout0_116) AT=950.025n

.meas tran vdout0_117ck1890 FIND v(dout0_117) AT=950.025n

.meas tran vdout0_118ck1890 FIND v(dout0_118) AT=950.025n

.meas tran vdout0_119ck1890 FIND v(dout0_119) AT=950.025n

.meas tran vdout0_120ck1890 FIND v(dout0_120) AT=950.025n

.meas tran vdout0_121ck1890 FIND v(dout0_121) AT=950.025n

.meas tran vdout0_122ck1890 FIND v(dout0_122) AT=950.025n

.meas tran vdout0_123ck1890 FIND v(dout0_123) AT=950.025n

.meas tran vdout0_124ck1890 FIND v(dout0_124) AT=950.025n

.meas tran vdout0_125ck1890 FIND v(dout0_125) AT=950.025n

.meas tran vdout0_126ck1890 FIND v(dout0_126) AT=950.025n

.meas tran vdout0_127ck1890 FIND v(dout0_127) AT=950.025n

.meas tran vdout0_128ck1890 FIND v(dout0_128) AT=950.025n

.meas tran vdout0_129ck1890 FIND v(dout0_129) AT=950.025n

.meas tran vdout0_130ck1890 FIND v(dout0_130) AT=950.025n

.meas tran vdout0_131ck1890 FIND v(dout0_131) AT=950.025n

.meas tran vdout0_132ck1890 FIND v(dout0_132) AT=950.025n

.meas tran vdout0_133ck1890 FIND v(dout0_133) AT=950.025n

.meas tran vdout0_134ck1890 FIND v(dout0_134) AT=950.025n

.meas tran vdout0_135ck1890 FIND v(dout0_135) AT=950.025n

.meas tran vdout0_136ck1890 FIND v(dout0_136) AT=950.025n

.meas tran vdout0_137ck1890 FIND v(dout0_137) AT=950.025n

.meas tran vdout0_138ck1890 FIND v(dout0_138) AT=950.025n

.meas tran vdout0_139ck1890 FIND v(dout0_139) AT=950.025n

.meas tran vdout0_140ck1890 FIND v(dout0_140) AT=950.025n

.meas tran vdout0_141ck1890 FIND v(dout0_141) AT=950.025n

.meas tran vdout0_142ck1890 FIND v(dout0_142) AT=950.025n

.meas tran vdout0_143ck1890 FIND v(dout0_143) AT=950.025n

.meas tran vdout0_144ck1890 FIND v(dout0_144) AT=950.025n

.meas tran vdout0_145ck1890 FIND v(dout0_145) AT=950.025n

.meas tran vdout0_146ck1890 FIND v(dout0_146) AT=950.025n

.meas tran vdout0_147ck1890 FIND v(dout0_147) AT=950.025n

.meas tran vdout0_148ck1890 FIND v(dout0_148) AT=950.025n

.meas tran vdout0_149ck1890 FIND v(dout0_149) AT=950.025n

.meas tran vdout0_0ck1900 FIND v(dout0_0) AT=955.025n

.meas tran vdout0_1ck1900 FIND v(dout0_1) AT=955.025n

.meas tran vdout0_2ck1900 FIND v(dout0_2) AT=955.025n

.meas tran vdout0_3ck1900 FIND v(dout0_3) AT=955.025n

.meas tran vdout0_4ck1900 FIND v(dout0_4) AT=955.025n

.meas tran vdout0_5ck1900 FIND v(dout0_5) AT=955.025n

.meas tran vdout0_6ck1900 FIND v(dout0_6) AT=955.025n

.meas tran vdout0_7ck1900 FIND v(dout0_7) AT=955.025n

.meas tran vdout0_8ck1900 FIND v(dout0_8) AT=955.025n

.meas tran vdout0_9ck1900 FIND v(dout0_9) AT=955.025n

.meas tran vdout0_10ck1900 FIND v(dout0_10) AT=955.025n

.meas tran vdout0_11ck1900 FIND v(dout0_11) AT=955.025n

.meas tran vdout0_12ck1900 FIND v(dout0_12) AT=955.025n

.meas tran vdout0_13ck1900 FIND v(dout0_13) AT=955.025n

.meas tran vdout0_14ck1900 FIND v(dout0_14) AT=955.025n

.meas tran vdout0_15ck1900 FIND v(dout0_15) AT=955.025n

.meas tran vdout0_16ck1900 FIND v(dout0_16) AT=955.025n

.meas tran vdout0_17ck1900 FIND v(dout0_17) AT=955.025n

.meas tran vdout0_18ck1900 FIND v(dout0_18) AT=955.025n

.meas tran vdout0_19ck1900 FIND v(dout0_19) AT=955.025n

.meas tran vdout0_20ck1900 FIND v(dout0_20) AT=955.025n

.meas tran vdout0_21ck1900 FIND v(dout0_21) AT=955.025n

.meas tran vdout0_22ck1900 FIND v(dout0_22) AT=955.025n

.meas tran vdout0_23ck1900 FIND v(dout0_23) AT=955.025n

.meas tran vdout0_24ck1900 FIND v(dout0_24) AT=955.025n

.meas tran vdout0_25ck1900 FIND v(dout0_25) AT=955.025n

.meas tran vdout0_26ck1900 FIND v(dout0_26) AT=955.025n

.meas tran vdout0_27ck1900 FIND v(dout0_27) AT=955.025n

.meas tran vdout0_28ck1900 FIND v(dout0_28) AT=955.025n

.meas tran vdout0_29ck1900 FIND v(dout0_29) AT=955.025n

.meas tran vdout0_30ck1900 FIND v(dout0_30) AT=955.025n

.meas tran vdout0_31ck1900 FIND v(dout0_31) AT=955.025n

.meas tran vdout0_32ck1900 FIND v(dout0_32) AT=955.025n

.meas tran vdout0_33ck1900 FIND v(dout0_33) AT=955.025n

.meas tran vdout0_34ck1900 FIND v(dout0_34) AT=955.025n

.meas tran vdout0_35ck1900 FIND v(dout0_35) AT=955.025n

.meas tran vdout0_36ck1900 FIND v(dout0_36) AT=955.025n

.meas tran vdout0_37ck1900 FIND v(dout0_37) AT=955.025n

.meas tran vdout0_38ck1900 FIND v(dout0_38) AT=955.025n

.meas tran vdout0_39ck1900 FIND v(dout0_39) AT=955.025n

.meas tran vdout0_40ck1900 FIND v(dout0_40) AT=955.025n

.meas tran vdout0_41ck1900 FIND v(dout0_41) AT=955.025n

.meas tran vdout0_42ck1900 FIND v(dout0_42) AT=955.025n

.meas tran vdout0_43ck1900 FIND v(dout0_43) AT=955.025n

.meas tran vdout0_44ck1900 FIND v(dout0_44) AT=955.025n

.meas tran vdout0_45ck1900 FIND v(dout0_45) AT=955.025n

.meas tran vdout0_46ck1900 FIND v(dout0_46) AT=955.025n

.meas tran vdout0_47ck1900 FIND v(dout0_47) AT=955.025n

.meas tran vdout0_48ck1900 FIND v(dout0_48) AT=955.025n

.meas tran vdout0_49ck1900 FIND v(dout0_49) AT=955.025n

.meas tran vdout0_50ck1900 FIND v(dout0_50) AT=955.025n

.meas tran vdout0_51ck1900 FIND v(dout0_51) AT=955.025n

.meas tran vdout0_52ck1900 FIND v(dout0_52) AT=955.025n

.meas tran vdout0_53ck1900 FIND v(dout0_53) AT=955.025n

.meas tran vdout0_54ck1900 FIND v(dout0_54) AT=955.025n

.meas tran vdout0_55ck1900 FIND v(dout0_55) AT=955.025n

.meas tran vdout0_56ck1900 FIND v(dout0_56) AT=955.025n

.meas tran vdout0_57ck1900 FIND v(dout0_57) AT=955.025n

.meas tran vdout0_58ck1900 FIND v(dout0_58) AT=955.025n

.meas tran vdout0_59ck1900 FIND v(dout0_59) AT=955.025n

.meas tran vdout0_60ck1900 FIND v(dout0_60) AT=955.025n

.meas tran vdout0_61ck1900 FIND v(dout0_61) AT=955.025n

.meas tran vdout0_62ck1900 FIND v(dout0_62) AT=955.025n

.meas tran vdout0_63ck1900 FIND v(dout0_63) AT=955.025n

.meas tran vdout0_64ck1900 FIND v(dout0_64) AT=955.025n

.meas tran vdout0_65ck1900 FIND v(dout0_65) AT=955.025n

.meas tran vdout0_66ck1900 FIND v(dout0_66) AT=955.025n

.meas tran vdout0_67ck1900 FIND v(dout0_67) AT=955.025n

.meas tran vdout0_68ck1900 FIND v(dout0_68) AT=955.025n

.meas tran vdout0_69ck1900 FIND v(dout0_69) AT=955.025n

.meas tran vdout0_70ck1900 FIND v(dout0_70) AT=955.025n

.meas tran vdout0_71ck1900 FIND v(dout0_71) AT=955.025n

.meas tran vdout0_72ck1900 FIND v(dout0_72) AT=955.025n

.meas tran vdout0_73ck1900 FIND v(dout0_73) AT=955.025n

.meas tran vdout0_74ck1900 FIND v(dout0_74) AT=955.025n

.meas tran vdout0_75ck1900 FIND v(dout0_75) AT=955.025n

.meas tran vdout0_76ck1900 FIND v(dout0_76) AT=955.025n

.meas tran vdout0_77ck1900 FIND v(dout0_77) AT=955.025n

.meas tran vdout0_78ck1900 FIND v(dout0_78) AT=955.025n

.meas tran vdout0_79ck1900 FIND v(dout0_79) AT=955.025n

.meas tran vdout0_80ck1900 FIND v(dout0_80) AT=955.025n

.meas tran vdout0_81ck1900 FIND v(dout0_81) AT=955.025n

.meas tran vdout0_82ck1900 FIND v(dout0_82) AT=955.025n

.meas tran vdout0_83ck1900 FIND v(dout0_83) AT=955.025n

.meas tran vdout0_84ck1900 FIND v(dout0_84) AT=955.025n

.meas tran vdout0_85ck1900 FIND v(dout0_85) AT=955.025n

.meas tran vdout0_86ck1900 FIND v(dout0_86) AT=955.025n

.meas tran vdout0_87ck1900 FIND v(dout0_87) AT=955.025n

.meas tran vdout0_88ck1900 FIND v(dout0_88) AT=955.025n

.meas tran vdout0_89ck1900 FIND v(dout0_89) AT=955.025n

.meas tran vdout0_90ck1900 FIND v(dout0_90) AT=955.025n

.meas tran vdout0_91ck1900 FIND v(dout0_91) AT=955.025n

.meas tran vdout0_92ck1900 FIND v(dout0_92) AT=955.025n

.meas tran vdout0_93ck1900 FIND v(dout0_93) AT=955.025n

.meas tran vdout0_94ck1900 FIND v(dout0_94) AT=955.025n

.meas tran vdout0_95ck1900 FIND v(dout0_95) AT=955.025n

.meas tran vdout0_96ck1900 FIND v(dout0_96) AT=955.025n

.meas tran vdout0_97ck1900 FIND v(dout0_97) AT=955.025n

.meas tran vdout0_98ck1900 FIND v(dout0_98) AT=955.025n

.meas tran vdout0_99ck1900 FIND v(dout0_99) AT=955.025n

.meas tran vdout0_100ck1900 FIND v(dout0_100) AT=955.025n

.meas tran vdout0_101ck1900 FIND v(dout0_101) AT=955.025n

.meas tran vdout0_102ck1900 FIND v(dout0_102) AT=955.025n

.meas tran vdout0_103ck1900 FIND v(dout0_103) AT=955.025n

.meas tran vdout0_104ck1900 FIND v(dout0_104) AT=955.025n

.meas tran vdout0_105ck1900 FIND v(dout0_105) AT=955.025n

.meas tran vdout0_106ck1900 FIND v(dout0_106) AT=955.025n

.meas tran vdout0_107ck1900 FIND v(dout0_107) AT=955.025n

.meas tran vdout0_108ck1900 FIND v(dout0_108) AT=955.025n

.meas tran vdout0_109ck1900 FIND v(dout0_109) AT=955.025n

.meas tran vdout0_110ck1900 FIND v(dout0_110) AT=955.025n

.meas tran vdout0_111ck1900 FIND v(dout0_111) AT=955.025n

.meas tran vdout0_112ck1900 FIND v(dout0_112) AT=955.025n

.meas tran vdout0_113ck1900 FIND v(dout0_113) AT=955.025n

.meas tran vdout0_114ck1900 FIND v(dout0_114) AT=955.025n

.meas tran vdout0_115ck1900 FIND v(dout0_115) AT=955.025n

.meas tran vdout0_116ck1900 FIND v(dout0_116) AT=955.025n

.meas tran vdout0_117ck1900 FIND v(dout0_117) AT=955.025n

.meas tran vdout0_118ck1900 FIND v(dout0_118) AT=955.025n

.meas tran vdout0_119ck1900 FIND v(dout0_119) AT=955.025n

.meas tran vdout0_120ck1900 FIND v(dout0_120) AT=955.025n

.meas tran vdout0_121ck1900 FIND v(dout0_121) AT=955.025n

.meas tran vdout0_122ck1900 FIND v(dout0_122) AT=955.025n

.meas tran vdout0_123ck1900 FIND v(dout0_123) AT=955.025n

.meas tran vdout0_124ck1900 FIND v(dout0_124) AT=955.025n

.meas tran vdout0_125ck1900 FIND v(dout0_125) AT=955.025n

.meas tran vdout0_126ck1900 FIND v(dout0_126) AT=955.025n

.meas tran vdout0_127ck1900 FIND v(dout0_127) AT=955.025n

.meas tran vdout0_128ck1900 FIND v(dout0_128) AT=955.025n

.meas tran vdout0_129ck1900 FIND v(dout0_129) AT=955.025n

.meas tran vdout0_130ck1900 FIND v(dout0_130) AT=955.025n

.meas tran vdout0_131ck1900 FIND v(dout0_131) AT=955.025n

.meas tran vdout0_132ck1900 FIND v(dout0_132) AT=955.025n

.meas tran vdout0_133ck1900 FIND v(dout0_133) AT=955.025n

.meas tran vdout0_134ck1900 FIND v(dout0_134) AT=955.025n

.meas tran vdout0_135ck1900 FIND v(dout0_135) AT=955.025n

.meas tran vdout0_136ck1900 FIND v(dout0_136) AT=955.025n

.meas tran vdout0_137ck1900 FIND v(dout0_137) AT=955.025n

.meas tran vdout0_138ck1900 FIND v(dout0_138) AT=955.025n

.meas tran vdout0_139ck1900 FIND v(dout0_139) AT=955.025n

.meas tran vdout0_140ck1900 FIND v(dout0_140) AT=955.025n

.meas tran vdout0_141ck1900 FIND v(dout0_141) AT=955.025n

.meas tran vdout0_142ck1900 FIND v(dout0_142) AT=955.025n

.meas tran vdout0_143ck1900 FIND v(dout0_143) AT=955.025n

.meas tran vdout0_144ck1900 FIND v(dout0_144) AT=955.025n

.meas tran vdout0_145ck1900 FIND v(dout0_145) AT=955.025n

.meas tran vdout0_146ck1900 FIND v(dout0_146) AT=955.025n

.meas tran vdout0_147ck1900 FIND v(dout0_147) AT=955.025n

.meas tran vdout0_148ck1900 FIND v(dout0_148) AT=955.025n

.meas tran vdout0_149ck1900 FIND v(dout0_149) AT=955.025n

.meas tran vdout0_0ck1910 FIND v(dout0_0) AT=960.025n

.meas tran vdout0_1ck1910 FIND v(dout0_1) AT=960.025n

.meas tran vdout0_2ck1910 FIND v(dout0_2) AT=960.025n

.meas tran vdout0_3ck1910 FIND v(dout0_3) AT=960.025n

.meas tran vdout0_4ck1910 FIND v(dout0_4) AT=960.025n

.meas tran vdout0_5ck1910 FIND v(dout0_5) AT=960.025n

.meas tran vdout0_6ck1910 FIND v(dout0_6) AT=960.025n

.meas tran vdout0_7ck1910 FIND v(dout0_7) AT=960.025n

.meas tran vdout0_8ck1910 FIND v(dout0_8) AT=960.025n

.meas tran vdout0_9ck1910 FIND v(dout0_9) AT=960.025n

.meas tran vdout0_10ck1910 FIND v(dout0_10) AT=960.025n

.meas tran vdout0_11ck1910 FIND v(dout0_11) AT=960.025n

.meas tran vdout0_12ck1910 FIND v(dout0_12) AT=960.025n

.meas tran vdout0_13ck1910 FIND v(dout0_13) AT=960.025n

.meas tran vdout0_14ck1910 FIND v(dout0_14) AT=960.025n

.meas tran vdout0_15ck1910 FIND v(dout0_15) AT=960.025n

.meas tran vdout0_16ck1910 FIND v(dout0_16) AT=960.025n

.meas tran vdout0_17ck1910 FIND v(dout0_17) AT=960.025n

.meas tran vdout0_18ck1910 FIND v(dout0_18) AT=960.025n

.meas tran vdout0_19ck1910 FIND v(dout0_19) AT=960.025n

.meas tran vdout0_20ck1910 FIND v(dout0_20) AT=960.025n

.meas tran vdout0_21ck1910 FIND v(dout0_21) AT=960.025n

.meas tran vdout0_22ck1910 FIND v(dout0_22) AT=960.025n

.meas tran vdout0_23ck1910 FIND v(dout0_23) AT=960.025n

.meas tran vdout0_24ck1910 FIND v(dout0_24) AT=960.025n

.meas tran vdout0_25ck1910 FIND v(dout0_25) AT=960.025n

.meas tran vdout0_26ck1910 FIND v(dout0_26) AT=960.025n

.meas tran vdout0_27ck1910 FIND v(dout0_27) AT=960.025n

.meas tran vdout0_28ck1910 FIND v(dout0_28) AT=960.025n

.meas tran vdout0_29ck1910 FIND v(dout0_29) AT=960.025n

.meas tran vdout0_30ck1910 FIND v(dout0_30) AT=960.025n

.meas tran vdout0_31ck1910 FIND v(dout0_31) AT=960.025n

.meas tran vdout0_32ck1910 FIND v(dout0_32) AT=960.025n

.meas tran vdout0_33ck1910 FIND v(dout0_33) AT=960.025n

.meas tran vdout0_34ck1910 FIND v(dout0_34) AT=960.025n

.meas tran vdout0_35ck1910 FIND v(dout0_35) AT=960.025n

.meas tran vdout0_36ck1910 FIND v(dout0_36) AT=960.025n

.meas tran vdout0_37ck1910 FIND v(dout0_37) AT=960.025n

.meas tran vdout0_38ck1910 FIND v(dout0_38) AT=960.025n

.meas tran vdout0_39ck1910 FIND v(dout0_39) AT=960.025n

.meas tran vdout0_40ck1910 FIND v(dout0_40) AT=960.025n

.meas tran vdout0_41ck1910 FIND v(dout0_41) AT=960.025n

.meas tran vdout0_42ck1910 FIND v(dout0_42) AT=960.025n

.meas tran vdout0_43ck1910 FIND v(dout0_43) AT=960.025n

.meas tran vdout0_44ck1910 FIND v(dout0_44) AT=960.025n

.meas tran vdout0_45ck1910 FIND v(dout0_45) AT=960.025n

.meas tran vdout0_46ck1910 FIND v(dout0_46) AT=960.025n

.meas tran vdout0_47ck1910 FIND v(dout0_47) AT=960.025n

.meas tran vdout0_48ck1910 FIND v(dout0_48) AT=960.025n

.meas tran vdout0_49ck1910 FIND v(dout0_49) AT=960.025n

.meas tran vdout0_50ck1910 FIND v(dout0_50) AT=960.025n

.meas tran vdout0_51ck1910 FIND v(dout0_51) AT=960.025n

.meas tran vdout0_52ck1910 FIND v(dout0_52) AT=960.025n

.meas tran vdout0_53ck1910 FIND v(dout0_53) AT=960.025n

.meas tran vdout0_54ck1910 FIND v(dout0_54) AT=960.025n

.meas tran vdout0_55ck1910 FIND v(dout0_55) AT=960.025n

.meas tran vdout0_56ck1910 FIND v(dout0_56) AT=960.025n

.meas tran vdout0_57ck1910 FIND v(dout0_57) AT=960.025n

.meas tran vdout0_58ck1910 FIND v(dout0_58) AT=960.025n

.meas tran vdout0_59ck1910 FIND v(dout0_59) AT=960.025n

.meas tran vdout0_60ck1910 FIND v(dout0_60) AT=960.025n

.meas tran vdout0_61ck1910 FIND v(dout0_61) AT=960.025n

.meas tran vdout0_62ck1910 FIND v(dout0_62) AT=960.025n

.meas tran vdout0_63ck1910 FIND v(dout0_63) AT=960.025n

.meas tran vdout0_64ck1910 FIND v(dout0_64) AT=960.025n

.meas tran vdout0_65ck1910 FIND v(dout0_65) AT=960.025n

.meas tran vdout0_66ck1910 FIND v(dout0_66) AT=960.025n

.meas tran vdout0_67ck1910 FIND v(dout0_67) AT=960.025n

.meas tran vdout0_68ck1910 FIND v(dout0_68) AT=960.025n

.meas tran vdout0_69ck1910 FIND v(dout0_69) AT=960.025n

.meas tran vdout0_70ck1910 FIND v(dout0_70) AT=960.025n

.meas tran vdout0_71ck1910 FIND v(dout0_71) AT=960.025n

.meas tran vdout0_72ck1910 FIND v(dout0_72) AT=960.025n

.meas tran vdout0_73ck1910 FIND v(dout0_73) AT=960.025n

.meas tran vdout0_74ck1910 FIND v(dout0_74) AT=960.025n

.meas tran vdout0_75ck1910 FIND v(dout0_75) AT=960.025n

.meas tran vdout0_76ck1910 FIND v(dout0_76) AT=960.025n

.meas tran vdout0_77ck1910 FIND v(dout0_77) AT=960.025n

.meas tran vdout0_78ck1910 FIND v(dout0_78) AT=960.025n

.meas tran vdout0_79ck1910 FIND v(dout0_79) AT=960.025n

.meas tran vdout0_80ck1910 FIND v(dout0_80) AT=960.025n

.meas tran vdout0_81ck1910 FIND v(dout0_81) AT=960.025n

.meas tran vdout0_82ck1910 FIND v(dout0_82) AT=960.025n

.meas tran vdout0_83ck1910 FIND v(dout0_83) AT=960.025n

.meas tran vdout0_84ck1910 FIND v(dout0_84) AT=960.025n

.meas tran vdout0_85ck1910 FIND v(dout0_85) AT=960.025n

.meas tran vdout0_86ck1910 FIND v(dout0_86) AT=960.025n

.meas tran vdout0_87ck1910 FIND v(dout0_87) AT=960.025n

.meas tran vdout0_88ck1910 FIND v(dout0_88) AT=960.025n

.meas tran vdout0_89ck1910 FIND v(dout0_89) AT=960.025n

.meas tran vdout0_90ck1910 FIND v(dout0_90) AT=960.025n

.meas tran vdout0_91ck1910 FIND v(dout0_91) AT=960.025n

.meas tran vdout0_92ck1910 FIND v(dout0_92) AT=960.025n

.meas tran vdout0_93ck1910 FIND v(dout0_93) AT=960.025n

.meas tran vdout0_94ck1910 FIND v(dout0_94) AT=960.025n

.meas tran vdout0_95ck1910 FIND v(dout0_95) AT=960.025n

.meas tran vdout0_96ck1910 FIND v(dout0_96) AT=960.025n

.meas tran vdout0_97ck1910 FIND v(dout0_97) AT=960.025n

.meas tran vdout0_98ck1910 FIND v(dout0_98) AT=960.025n

.meas tran vdout0_99ck1910 FIND v(dout0_99) AT=960.025n

.meas tran vdout0_100ck1910 FIND v(dout0_100) AT=960.025n

.meas tran vdout0_101ck1910 FIND v(dout0_101) AT=960.025n

.meas tran vdout0_102ck1910 FIND v(dout0_102) AT=960.025n

.meas tran vdout0_103ck1910 FIND v(dout0_103) AT=960.025n

.meas tran vdout0_104ck1910 FIND v(dout0_104) AT=960.025n

.meas tran vdout0_105ck1910 FIND v(dout0_105) AT=960.025n

.meas tran vdout0_106ck1910 FIND v(dout0_106) AT=960.025n

.meas tran vdout0_107ck1910 FIND v(dout0_107) AT=960.025n

.meas tran vdout0_108ck1910 FIND v(dout0_108) AT=960.025n

.meas tran vdout0_109ck1910 FIND v(dout0_109) AT=960.025n

.meas tran vdout0_110ck1910 FIND v(dout0_110) AT=960.025n

.meas tran vdout0_111ck1910 FIND v(dout0_111) AT=960.025n

.meas tran vdout0_112ck1910 FIND v(dout0_112) AT=960.025n

.meas tran vdout0_113ck1910 FIND v(dout0_113) AT=960.025n

.meas tran vdout0_114ck1910 FIND v(dout0_114) AT=960.025n

.meas tran vdout0_115ck1910 FIND v(dout0_115) AT=960.025n

.meas tran vdout0_116ck1910 FIND v(dout0_116) AT=960.025n

.meas tran vdout0_117ck1910 FIND v(dout0_117) AT=960.025n

.meas tran vdout0_118ck1910 FIND v(dout0_118) AT=960.025n

.meas tran vdout0_119ck1910 FIND v(dout0_119) AT=960.025n

.meas tran vdout0_120ck1910 FIND v(dout0_120) AT=960.025n

.meas tran vdout0_121ck1910 FIND v(dout0_121) AT=960.025n

.meas tran vdout0_122ck1910 FIND v(dout0_122) AT=960.025n

.meas tran vdout0_123ck1910 FIND v(dout0_123) AT=960.025n

.meas tran vdout0_124ck1910 FIND v(dout0_124) AT=960.025n

.meas tran vdout0_125ck1910 FIND v(dout0_125) AT=960.025n

.meas tran vdout0_126ck1910 FIND v(dout0_126) AT=960.025n

.meas tran vdout0_127ck1910 FIND v(dout0_127) AT=960.025n

.meas tran vdout0_128ck1910 FIND v(dout0_128) AT=960.025n

.meas tran vdout0_129ck1910 FIND v(dout0_129) AT=960.025n

.meas tran vdout0_130ck1910 FIND v(dout0_130) AT=960.025n

.meas tran vdout0_131ck1910 FIND v(dout0_131) AT=960.025n

.meas tran vdout0_132ck1910 FIND v(dout0_132) AT=960.025n

.meas tran vdout0_133ck1910 FIND v(dout0_133) AT=960.025n

.meas tran vdout0_134ck1910 FIND v(dout0_134) AT=960.025n

.meas tran vdout0_135ck1910 FIND v(dout0_135) AT=960.025n

.meas tran vdout0_136ck1910 FIND v(dout0_136) AT=960.025n

.meas tran vdout0_137ck1910 FIND v(dout0_137) AT=960.025n

.meas tran vdout0_138ck1910 FIND v(dout0_138) AT=960.025n

.meas tran vdout0_139ck1910 FIND v(dout0_139) AT=960.025n

.meas tran vdout0_140ck1910 FIND v(dout0_140) AT=960.025n

.meas tran vdout0_141ck1910 FIND v(dout0_141) AT=960.025n

.meas tran vdout0_142ck1910 FIND v(dout0_142) AT=960.025n

.meas tran vdout0_143ck1910 FIND v(dout0_143) AT=960.025n

.meas tran vdout0_144ck1910 FIND v(dout0_144) AT=960.025n

.meas tran vdout0_145ck1910 FIND v(dout0_145) AT=960.025n

.meas tran vdout0_146ck1910 FIND v(dout0_146) AT=960.025n

.meas tran vdout0_147ck1910 FIND v(dout0_147) AT=960.025n

.meas tran vdout0_148ck1910 FIND v(dout0_148) AT=960.025n

.meas tran vdout0_149ck1910 FIND v(dout0_149) AT=960.025n

.meas tran vdout0_0ck1930 FIND v(dout0_0) AT=970.025n

.meas tran vdout0_1ck1930 FIND v(dout0_1) AT=970.025n

.meas tran vdout0_2ck1930 FIND v(dout0_2) AT=970.025n

.meas tran vdout0_3ck1930 FIND v(dout0_3) AT=970.025n

.meas tran vdout0_4ck1930 FIND v(dout0_4) AT=970.025n

.meas tran vdout0_5ck1930 FIND v(dout0_5) AT=970.025n

.meas tran vdout0_6ck1930 FIND v(dout0_6) AT=970.025n

.meas tran vdout0_7ck1930 FIND v(dout0_7) AT=970.025n

.meas tran vdout0_8ck1930 FIND v(dout0_8) AT=970.025n

.meas tran vdout0_9ck1930 FIND v(dout0_9) AT=970.025n

.meas tran vdout0_10ck1930 FIND v(dout0_10) AT=970.025n

.meas tran vdout0_11ck1930 FIND v(dout0_11) AT=970.025n

.meas tran vdout0_12ck1930 FIND v(dout0_12) AT=970.025n

.meas tran vdout0_13ck1930 FIND v(dout0_13) AT=970.025n

.meas tran vdout0_14ck1930 FIND v(dout0_14) AT=970.025n

.meas tran vdout0_15ck1930 FIND v(dout0_15) AT=970.025n

.meas tran vdout0_16ck1930 FIND v(dout0_16) AT=970.025n

.meas tran vdout0_17ck1930 FIND v(dout0_17) AT=970.025n

.meas tran vdout0_18ck1930 FIND v(dout0_18) AT=970.025n

.meas tran vdout0_19ck1930 FIND v(dout0_19) AT=970.025n

.meas tran vdout0_20ck1930 FIND v(dout0_20) AT=970.025n

.meas tran vdout0_21ck1930 FIND v(dout0_21) AT=970.025n

.meas tran vdout0_22ck1930 FIND v(dout0_22) AT=970.025n

.meas tran vdout0_23ck1930 FIND v(dout0_23) AT=970.025n

.meas tran vdout0_24ck1930 FIND v(dout0_24) AT=970.025n

.meas tran vdout0_25ck1930 FIND v(dout0_25) AT=970.025n

.meas tran vdout0_26ck1930 FIND v(dout0_26) AT=970.025n

.meas tran vdout0_27ck1930 FIND v(dout0_27) AT=970.025n

.meas tran vdout0_28ck1930 FIND v(dout0_28) AT=970.025n

.meas tran vdout0_29ck1930 FIND v(dout0_29) AT=970.025n

.meas tran vdout0_30ck1930 FIND v(dout0_30) AT=970.025n

.meas tran vdout0_31ck1930 FIND v(dout0_31) AT=970.025n

.meas tran vdout0_32ck1930 FIND v(dout0_32) AT=970.025n

.meas tran vdout0_33ck1930 FIND v(dout0_33) AT=970.025n

.meas tran vdout0_34ck1930 FIND v(dout0_34) AT=970.025n

.meas tran vdout0_35ck1930 FIND v(dout0_35) AT=970.025n

.meas tran vdout0_36ck1930 FIND v(dout0_36) AT=970.025n

.meas tran vdout0_37ck1930 FIND v(dout0_37) AT=970.025n

.meas tran vdout0_38ck1930 FIND v(dout0_38) AT=970.025n

.meas tran vdout0_39ck1930 FIND v(dout0_39) AT=970.025n

.meas tran vdout0_40ck1930 FIND v(dout0_40) AT=970.025n

.meas tran vdout0_41ck1930 FIND v(dout0_41) AT=970.025n

.meas tran vdout0_42ck1930 FIND v(dout0_42) AT=970.025n

.meas tran vdout0_43ck1930 FIND v(dout0_43) AT=970.025n

.meas tran vdout0_44ck1930 FIND v(dout0_44) AT=970.025n

.meas tran vdout0_45ck1930 FIND v(dout0_45) AT=970.025n

.meas tran vdout0_46ck1930 FIND v(dout0_46) AT=970.025n

.meas tran vdout0_47ck1930 FIND v(dout0_47) AT=970.025n

.meas tran vdout0_48ck1930 FIND v(dout0_48) AT=970.025n

.meas tran vdout0_49ck1930 FIND v(dout0_49) AT=970.025n

.meas tran vdout0_50ck1930 FIND v(dout0_50) AT=970.025n

.meas tran vdout0_51ck1930 FIND v(dout0_51) AT=970.025n

.meas tran vdout0_52ck1930 FIND v(dout0_52) AT=970.025n

.meas tran vdout0_53ck1930 FIND v(dout0_53) AT=970.025n

.meas tran vdout0_54ck1930 FIND v(dout0_54) AT=970.025n

.meas tran vdout0_55ck1930 FIND v(dout0_55) AT=970.025n

.meas tran vdout0_56ck1930 FIND v(dout0_56) AT=970.025n

.meas tran vdout0_57ck1930 FIND v(dout0_57) AT=970.025n

.meas tran vdout0_58ck1930 FIND v(dout0_58) AT=970.025n

.meas tran vdout0_59ck1930 FIND v(dout0_59) AT=970.025n

.meas tran vdout0_60ck1930 FIND v(dout0_60) AT=970.025n

.meas tran vdout0_61ck1930 FIND v(dout0_61) AT=970.025n

.meas tran vdout0_62ck1930 FIND v(dout0_62) AT=970.025n

.meas tran vdout0_63ck1930 FIND v(dout0_63) AT=970.025n

.meas tran vdout0_64ck1930 FIND v(dout0_64) AT=970.025n

.meas tran vdout0_65ck1930 FIND v(dout0_65) AT=970.025n

.meas tran vdout0_66ck1930 FIND v(dout0_66) AT=970.025n

.meas tran vdout0_67ck1930 FIND v(dout0_67) AT=970.025n

.meas tran vdout0_68ck1930 FIND v(dout0_68) AT=970.025n

.meas tran vdout0_69ck1930 FIND v(dout0_69) AT=970.025n

.meas tran vdout0_70ck1930 FIND v(dout0_70) AT=970.025n

.meas tran vdout0_71ck1930 FIND v(dout0_71) AT=970.025n

.meas tran vdout0_72ck1930 FIND v(dout0_72) AT=970.025n

.meas tran vdout0_73ck1930 FIND v(dout0_73) AT=970.025n

.meas tran vdout0_74ck1930 FIND v(dout0_74) AT=970.025n

.meas tran vdout0_75ck1930 FIND v(dout0_75) AT=970.025n

.meas tran vdout0_76ck1930 FIND v(dout0_76) AT=970.025n

.meas tran vdout0_77ck1930 FIND v(dout0_77) AT=970.025n

.meas tran vdout0_78ck1930 FIND v(dout0_78) AT=970.025n

.meas tran vdout0_79ck1930 FIND v(dout0_79) AT=970.025n

.meas tran vdout0_80ck1930 FIND v(dout0_80) AT=970.025n

.meas tran vdout0_81ck1930 FIND v(dout0_81) AT=970.025n

.meas tran vdout0_82ck1930 FIND v(dout0_82) AT=970.025n

.meas tran vdout0_83ck1930 FIND v(dout0_83) AT=970.025n

.meas tran vdout0_84ck1930 FIND v(dout0_84) AT=970.025n

.meas tran vdout0_85ck1930 FIND v(dout0_85) AT=970.025n

.meas tran vdout0_86ck1930 FIND v(dout0_86) AT=970.025n

.meas tran vdout0_87ck1930 FIND v(dout0_87) AT=970.025n

.meas tran vdout0_88ck1930 FIND v(dout0_88) AT=970.025n

.meas tran vdout0_89ck1930 FIND v(dout0_89) AT=970.025n

.meas tran vdout0_90ck1930 FIND v(dout0_90) AT=970.025n

.meas tran vdout0_91ck1930 FIND v(dout0_91) AT=970.025n

.meas tran vdout0_92ck1930 FIND v(dout0_92) AT=970.025n

.meas tran vdout0_93ck1930 FIND v(dout0_93) AT=970.025n

.meas tran vdout0_94ck1930 FIND v(dout0_94) AT=970.025n

.meas tran vdout0_95ck1930 FIND v(dout0_95) AT=970.025n

.meas tran vdout0_96ck1930 FIND v(dout0_96) AT=970.025n

.meas tran vdout0_97ck1930 FIND v(dout0_97) AT=970.025n

.meas tran vdout0_98ck1930 FIND v(dout0_98) AT=970.025n

.meas tran vdout0_99ck1930 FIND v(dout0_99) AT=970.025n

.meas tran vdout0_100ck1930 FIND v(dout0_100) AT=970.025n

.meas tran vdout0_101ck1930 FIND v(dout0_101) AT=970.025n

.meas tran vdout0_102ck1930 FIND v(dout0_102) AT=970.025n

.meas tran vdout0_103ck1930 FIND v(dout0_103) AT=970.025n

.meas tran vdout0_104ck1930 FIND v(dout0_104) AT=970.025n

.meas tran vdout0_105ck1930 FIND v(dout0_105) AT=970.025n

.meas tran vdout0_106ck1930 FIND v(dout0_106) AT=970.025n

.meas tran vdout0_107ck1930 FIND v(dout0_107) AT=970.025n

.meas tran vdout0_108ck1930 FIND v(dout0_108) AT=970.025n

.meas tran vdout0_109ck1930 FIND v(dout0_109) AT=970.025n

.meas tran vdout0_110ck1930 FIND v(dout0_110) AT=970.025n

.meas tran vdout0_111ck1930 FIND v(dout0_111) AT=970.025n

.meas tran vdout0_112ck1930 FIND v(dout0_112) AT=970.025n

.meas tran vdout0_113ck1930 FIND v(dout0_113) AT=970.025n

.meas tran vdout0_114ck1930 FIND v(dout0_114) AT=970.025n

.meas tran vdout0_115ck1930 FIND v(dout0_115) AT=970.025n

.meas tran vdout0_116ck1930 FIND v(dout0_116) AT=970.025n

.meas tran vdout0_117ck1930 FIND v(dout0_117) AT=970.025n

.meas tran vdout0_118ck1930 FIND v(dout0_118) AT=970.025n

.meas tran vdout0_119ck1930 FIND v(dout0_119) AT=970.025n

.meas tran vdout0_120ck1930 FIND v(dout0_120) AT=970.025n

.meas tran vdout0_121ck1930 FIND v(dout0_121) AT=970.025n

.meas tran vdout0_122ck1930 FIND v(dout0_122) AT=970.025n

.meas tran vdout0_123ck1930 FIND v(dout0_123) AT=970.025n

.meas tran vdout0_124ck1930 FIND v(dout0_124) AT=970.025n

.meas tran vdout0_125ck1930 FIND v(dout0_125) AT=970.025n

.meas tran vdout0_126ck1930 FIND v(dout0_126) AT=970.025n

.meas tran vdout0_127ck1930 FIND v(dout0_127) AT=970.025n

.meas tran vdout0_128ck1930 FIND v(dout0_128) AT=970.025n

.meas tran vdout0_129ck1930 FIND v(dout0_129) AT=970.025n

.meas tran vdout0_130ck1930 FIND v(dout0_130) AT=970.025n

.meas tran vdout0_131ck1930 FIND v(dout0_131) AT=970.025n

.meas tran vdout0_132ck1930 FIND v(dout0_132) AT=970.025n

.meas tran vdout0_133ck1930 FIND v(dout0_133) AT=970.025n

.meas tran vdout0_134ck1930 FIND v(dout0_134) AT=970.025n

.meas tran vdout0_135ck1930 FIND v(dout0_135) AT=970.025n

.meas tran vdout0_136ck1930 FIND v(dout0_136) AT=970.025n

.meas tran vdout0_137ck1930 FIND v(dout0_137) AT=970.025n

.meas tran vdout0_138ck1930 FIND v(dout0_138) AT=970.025n

.meas tran vdout0_139ck1930 FIND v(dout0_139) AT=970.025n

.meas tran vdout0_140ck1930 FIND v(dout0_140) AT=970.025n

.meas tran vdout0_141ck1930 FIND v(dout0_141) AT=970.025n

.meas tran vdout0_142ck1930 FIND v(dout0_142) AT=970.025n

.meas tran vdout0_143ck1930 FIND v(dout0_143) AT=970.025n

.meas tran vdout0_144ck1930 FIND v(dout0_144) AT=970.025n

.meas tran vdout0_145ck1930 FIND v(dout0_145) AT=970.025n

.meas tran vdout0_146ck1930 FIND v(dout0_146) AT=970.025n

.meas tran vdout0_147ck1930 FIND v(dout0_147) AT=970.025n

.meas tran vdout0_148ck1930 FIND v(dout0_148) AT=970.025n

.meas tran vdout0_149ck1930 FIND v(dout0_149) AT=970.025n

.meas tran vdout0_0ck1950 FIND v(dout0_0) AT=980.025n

.meas tran vdout0_1ck1950 FIND v(dout0_1) AT=980.025n

.meas tran vdout0_2ck1950 FIND v(dout0_2) AT=980.025n

.meas tran vdout0_3ck1950 FIND v(dout0_3) AT=980.025n

.meas tran vdout0_4ck1950 FIND v(dout0_4) AT=980.025n

.meas tran vdout0_5ck1950 FIND v(dout0_5) AT=980.025n

.meas tran vdout0_6ck1950 FIND v(dout0_6) AT=980.025n

.meas tran vdout0_7ck1950 FIND v(dout0_7) AT=980.025n

.meas tran vdout0_8ck1950 FIND v(dout0_8) AT=980.025n

.meas tran vdout0_9ck1950 FIND v(dout0_9) AT=980.025n

.meas tran vdout0_10ck1950 FIND v(dout0_10) AT=980.025n

.meas tran vdout0_11ck1950 FIND v(dout0_11) AT=980.025n

.meas tran vdout0_12ck1950 FIND v(dout0_12) AT=980.025n

.meas tran vdout0_13ck1950 FIND v(dout0_13) AT=980.025n

.meas tran vdout0_14ck1950 FIND v(dout0_14) AT=980.025n

.meas tran vdout0_15ck1950 FIND v(dout0_15) AT=980.025n

.meas tran vdout0_16ck1950 FIND v(dout0_16) AT=980.025n

.meas tran vdout0_17ck1950 FIND v(dout0_17) AT=980.025n

.meas tran vdout0_18ck1950 FIND v(dout0_18) AT=980.025n

.meas tran vdout0_19ck1950 FIND v(dout0_19) AT=980.025n

.meas tran vdout0_20ck1950 FIND v(dout0_20) AT=980.025n

.meas tran vdout0_21ck1950 FIND v(dout0_21) AT=980.025n

.meas tran vdout0_22ck1950 FIND v(dout0_22) AT=980.025n

.meas tran vdout0_23ck1950 FIND v(dout0_23) AT=980.025n

.meas tran vdout0_24ck1950 FIND v(dout0_24) AT=980.025n

.meas tran vdout0_25ck1950 FIND v(dout0_25) AT=980.025n

.meas tran vdout0_26ck1950 FIND v(dout0_26) AT=980.025n

.meas tran vdout0_27ck1950 FIND v(dout0_27) AT=980.025n

.meas tran vdout0_28ck1950 FIND v(dout0_28) AT=980.025n

.meas tran vdout0_29ck1950 FIND v(dout0_29) AT=980.025n

.meas tran vdout0_30ck1950 FIND v(dout0_30) AT=980.025n

.meas tran vdout0_31ck1950 FIND v(dout0_31) AT=980.025n

.meas tran vdout0_32ck1950 FIND v(dout0_32) AT=980.025n

.meas tran vdout0_33ck1950 FIND v(dout0_33) AT=980.025n

.meas tran vdout0_34ck1950 FIND v(dout0_34) AT=980.025n

.meas tran vdout0_35ck1950 FIND v(dout0_35) AT=980.025n

.meas tran vdout0_36ck1950 FIND v(dout0_36) AT=980.025n

.meas tran vdout0_37ck1950 FIND v(dout0_37) AT=980.025n

.meas tran vdout0_38ck1950 FIND v(dout0_38) AT=980.025n

.meas tran vdout0_39ck1950 FIND v(dout0_39) AT=980.025n

.meas tran vdout0_40ck1950 FIND v(dout0_40) AT=980.025n

.meas tran vdout0_41ck1950 FIND v(dout0_41) AT=980.025n

.meas tran vdout0_42ck1950 FIND v(dout0_42) AT=980.025n

.meas tran vdout0_43ck1950 FIND v(dout0_43) AT=980.025n

.meas tran vdout0_44ck1950 FIND v(dout0_44) AT=980.025n

.meas tran vdout0_45ck1950 FIND v(dout0_45) AT=980.025n

.meas tran vdout0_46ck1950 FIND v(dout0_46) AT=980.025n

.meas tran vdout0_47ck1950 FIND v(dout0_47) AT=980.025n

.meas tran vdout0_48ck1950 FIND v(dout0_48) AT=980.025n

.meas tran vdout0_49ck1950 FIND v(dout0_49) AT=980.025n

.meas tran vdout0_50ck1950 FIND v(dout0_50) AT=980.025n

.meas tran vdout0_51ck1950 FIND v(dout0_51) AT=980.025n

.meas tran vdout0_52ck1950 FIND v(dout0_52) AT=980.025n

.meas tran vdout0_53ck1950 FIND v(dout0_53) AT=980.025n

.meas tran vdout0_54ck1950 FIND v(dout0_54) AT=980.025n

.meas tran vdout0_55ck1950 FIND v(dout0_55) AT=980.025n

.meas tran vdout0_56ck1950 FIND v(dout0_56) AT=980.025n

.meas tran vdout0_57ck1950 FIND v(dout0_57) AT=980.025n

.meas tran vdout0_58ck1950 FIND v(dout0_58) AT=980.025n

.meas tran vdout0_59ck1950 FIND v(dout0_59) AT=980.025n

.meas tran vdout0_60ck1950 FIND v(dout0_60) AT=980.025n

.meas tran vdout0_61ck1950 FIND v(dout0_61) AT=980.025n

.meas tran vdout0_62ck1950 FIND v(dout0_62) AT=980.025n

.meas tran vdout0_63ck1950 FIND v(dout0_63) AT=980.025n

.meas tran vdout0_64ck1950 FIND v(dout0_64) AT=980.025n

.meas tran vdout0_65ck1950 FIND v(dout0_65) AT=980.025n

.meas tran vdout0_66ck1950 FIND v(dout0_66) AT=980.025n

.meas tran vdout0_67ck1950 FIND v(dout0_67) AT=980.025n

.meas tran vdout0_68ck1950 FIND v(dout0_68) AT=980.025n

.meas tran vdout0_69ck1950 FIND v(dout0_69) AT=980.025n

.meas tran vdout0_70ck1950 FIND v(dout0_70) AT=980.025n

.meas tran vdout0_71ck1950 FIND v(dout0_71) AT=980.025n

.meas tran vdout0_72ck1950 FIND v(dout0_72) AT=980.025n

.meas tran vdout0_73ck1950 FIND v(dout0_73) AT=980.025n

.meas tran vdout0_74ck1950 FIND v(dout0_74) AT=980.025n

.meas tran vdout0_75ck1950 FIND v(dout0_75) AT=980.025n

.meas tran vdout0_76ck1950 FIND v(dout0_76) AT=980.025n

.meas tran vdout0_77ck1950 FIND v(dout0_77) AT=980.025n

.meas tran vdout0_78ck1950 FIND v(dout0_78) AT=980.025n

.meas tran vdout0_79ck1950 FIND v(dout0_79) AT=980.025n

.meas tran vdout0_80ck1950 FIND v(dout0_80) AT=980.025n

.meas tran vdout0_81ck1950 FIND v(dout0_81) AT=980.025n

.meas tran vdout0_82ck1950 FIND v(dout0_82) AT=980.025n

.meas tran vdout0_83ck1950 FIND v(dout0_83) AT=980.025n

.meas tran vdout0_84ck1950 FIND v(dout0_84) AT=980.025n

.meas tran vdout0_85ck1950 FIND v(dout0_85) AT=980.025n

.meas tran vdout0_86ck1950 FIND v(dout0_86) AT=980.025n

.meas tran vdout0_87ck1950 FIND v(dout0_87) AT=980.025n

.meas tran vdout0_88ck1950 FIND v(dout0_88) AT=980.025n

.meas tran vdout0_89ck1950 FIND v(dout0_89) AT=980.025n

.meas tran vdout0_90ck1950 FIND v(dout0_90) AT=980.025n

.meas tran vdout0_91ck1950 FIND v(dout0_91) AT=980.025n

.meas tran vdout0_92ck1950 FIND v(dout0_92) AT=980.025n

.meas tran vdout0_93ck1950 FIND v(dout0_93) AT=980.025n

.meas tran vdout0_94ck1950 FIND v(dout0_94) AT=980.025n

.meas tran vdout0_95ck1950 FIND v(dout0_95) AT=980.025n

.meas tran vdout0_96ck1950 FIND v(dout0_96) AT=980.025n

.meas tran vdout0_97ck1950 FIND v(dout0_97) AT=980.025n

.meas tran vdout0_98ck1950 FIND v(dout0_98) AT=980.025n

.meas tran vdout0_99ck1950 FIND v(dout0_99) AT=980.025n

.meas tran vdout0_100ck1950 FIND v(dout0_100) AT=980.025n

.meas tran vdout0_101ck1950 FIND v(dout0_101) AT=980.025n

.meas tran vdout0_102ck1950 FIND v(dout0_102) AT=980.025n

.meas tran vdout0_103ck1950 FIND v(dout0_103) AT=980.025n

.meas tran vdout0_104ck1950 FIND v(dout0_104) AT=980.025n

.meas tran vdout0_105ck1950 FIND v(dout0_105) AT=980.025n

.meas tran vdout0_106ck1950 FIND v(dout0_106) AT=980.025n

.meas tran vdout0_107ck1950 FIND v(dout0_107) AT=980.025n

.meas tran vdout0_108ck1950 FIND v(dout0_108) AT=980.025n

.meas tran vdout0_109ck1950 FIND v(dout0_109) AT=980.025n

.meas tran vdout0_110ck1950 FIND v(dout0_110) AT=980.025n

.meas tran vdout0_111ck1950 FIND v(dout0_111) AT=980.025n

.meas tran vdout0_112ck1950 FIND v(dout0_112) AT=980.025n

.meas tran vdout0_113ck1950 FIND v(dout0_113) AT=980.025n

.meas tran vdout0_114ck1950 FIND v(dout0_114) AT=980.025n

.meas tran vdout0_115ck1950 FIND v(dout0_115) AT=980.025n

.meas tran vdout0_116ck1950 FIND v(dout0_116) AT=980.025n

.meas tran vdout0_117ck1950 FIND v(dout0_117) AT=980.025n

.meas tran vdout0_118ck1950 FIND v(dout0_118) AT=980.025n

.meas tran vdout0_119ck1950 FIND v(dout0_119) AT=980.025n

.meas tran vdout0_120ck1950 FIND v(dout0_120) AT=980.025n

.meas tran vdout0_121ck1950 FIND v(dout0_121) AT=980.025n

.meas tran vdout0_122ck1950 FIND v(dout0_122) AT=980.025n

.meas tran vdout0_123ck1950 FIND v(dout0_123) AT=980.025n

.meas tran vdout0_124ck1950 FIND v(dout0_124) AT=980.025n

.meas tran vdout0_125ck1950 FIND v(dout0_125) AT=980.025n

.meas tran vdout0_126ck1950 FIND v(dout0_126) AT=980.025n

.meas tran vdout0_127ck1950 FIND v(dout0_127) AT=980.025n

.meas tran vdout0_128ck1950 FIND v(dout0_128) AT=980.025n

.meas tran vdout0_129ck1950 FIND v(dout0_129) AT=980.025n

.meas tran vdout0_130ck1950 FIND v(dout0_130) AT=980.025n

.meas tran vdout0_131ck1950 FIND v(dout0_131) AT=980.025n

.meas tran vdout0_132ck1950 FIND v(dout0_132) AT=980.025n

.meas tran vdout0_133ck1950 FIND v(dout0_133) AT=980.025n

.meas tran vdout0_134ck1950 FIND v(dout0_134) AT=980.025n

.meas tran vdout0_135ck1950 FIND v(dout0_135) AT=980.025n

.meas tran vdout0_136ck1950 FIND v(dout0_136) AT=980.025n

.meas tran vdout0_137ck1950 FIND v(dout0_137) AT=980.025n

.meas tran vdout0_138ck1950 FIND v(dout0_138) AT=980.025n

.meas tran vdout0_139ck1950 FIND v(dout0_139) AT=980.025n

.meas tran vdout0_140ck1950 FIND v(dout0_140) AT=980.025n

.meas tran vdout0_141ck1950 FIND v(dout0_141) AT=980.025n

.meas tran vdout0_142ck1950 FIND v(dout0_142) AT=980.025n

.meas tran vdout0_143ck1950 FIND v(dout0_143) AT=980.025n

.meas tran vdout0_144ck1950 FIND v(dout0_144) AT=980.025n

.meas tran vdout0_145ck1950 FIND v(dout0_145) AT=980.025n

.meas tran vdout0_146ck1950 FIND v(dout0_146) AT=980.025n

.meas tran vdout0_147ck1950 FIND v(dout0_147) AT=980.025n

.meas tran vdout0_148ck1950 FIND v(dout0_148) AT=980.025n

.meas tran vdout0_149ck1950 FIND v(dout0_149) AT=980.025n

.meas tran vdout0_0ck1970 FIND v(dout0_0) AT=990.025n

.meas tran vdout0_1ck1970 FIND v(dout0_1) AT=990.025n

.meas tran vdout0_2ck1970 FIND v(dout0_2) AT=990.025n

.meas tran vdout0_3ck1970 FIND v(dout0_3) AT=990.025n

.meas tran vdout0_4ck1970 FIND v(dout0_4) AT=990.025n

.meas tran vdout0_5ck1970 FIND v(dout0_5) AT=990.025n

.meas tran vdout0_6ck1970 FIND v(dout0_6) AT=990.025n

.meas tran vdout0_7ck1970 FIND v(dout0_7) AT=990.025n

.meas tran vdout0_8ck1970 FIND v(dout0_8) AT=990.025n

.meas tran vdout0_9ck1970 FIND v(dout0_9) AT=990.025n

.meas tran vdout0_10ck1970 FIND v(dout0_10) AT=990.025n

.meas tran vdout0_11ck1970 FIND v(dout0_11) AT=990.025n

.meas tran vdout0_12ck1970 FIND v(dout0_12) AT=990.025n

.meas tran vdout0_13ck1970 FIND v(dout0_13) AT=990.025n

.meas tran vdout0_14ck1970 FIND v(dout0_14) AT=990.025n

.meas tran vdout0_15ck1970 FIND v(dout0_15) AT=990.025n

.meas tran vdout0_16ck1970 FIND v(dout0_16) AT=990.025n

.meas tran vdout0_17ck1970 FIND v(dout0_17) AT=990.025n

.meas tran vdout0_18ck1970 FIND v(dout0_18) AT=990.025n

.meas tran vdout0_19ck1970 FIND v(dout0_19) AT=990.025n

.meas tran vdout0_20ck1970 FIND v(dout0_20) AT=990.025n

.meas tran vdout0_21ck1970 FIND v(dout0_21) AT=990.025n

.meas tran vdout0_22ck1970 FIND v(dout0_22) AT=990.025n

.meas tran vdout0_23ck1970 FIND v(dout0_23) AT=990.025n

.meas tran vdout0_24ck1970 FIND v(dout0_24) AT=990.025n

.meas tran vdout0_25ck1970 FIND v(dout0_25) AT=990.025n

.meas tran vdout0_26ck1970 FIND v(dout0_26) AT=990.025n

.meas tran vdout0_27ck1970 FIND v(dout0_27) AT=990.025n

.meas tran vdout0_28ck1970 FIND v(dout0_28) AT=990.025n

.meas tran vdout0_29ck1970 FIND v(dout0_29) AT=990.025n

.meas tran vdout0_30ck1970 FIND v(dout0_30) AT=990.025n

.meas tran vdout0_31ck1970 FIND v(dout0_31) AT=990.025n

.meas tran vdout0_32ck1970 FIND v(dout0_32) AT=990.025n

.meas tran vdout0_33ck1970 FIND v(dout0_33) AT=990.025n

.meas tran vdout0_34ck1970 FIND v(dout0_34) AT=990.025n

.meas tran vdout0_35ck1970 FIND v(dout0_35) AT=990.025n

.meas tran vdout0_36ck1970 FIND v(dout0_36) AT=990.025n

.meas tran vdout0_37ck1970 FIND v(dout0_37) AT=990.025n

.meas tran vdout0_38ck1970 FIND v(dout0_38) AT=990.025n

.meas tran vdout0_39ck1970 FIND v(dout0_39) AT=990.025n

.meas tran vdout0_40ck1970 FIND v(dout0_40) AT=990.025n

.meas tran vdout0_41ck1970 FIND v(dout0_41) AT=990.025n

.meas tran vdout0_42ck1970 FIND v(dout0_42) AT=990.025n

.meas tran vdout0_43ck1970 FIND v(dout0_43) AT=990.025n

.meas tran vdout0_44ck1970 FIND v(dout0_44) AT=990.025n

.meas tran vdout0_45ck1970 FIND v(dout0_45) AT=990.025n

.meas tran vdout0_46ck1970 FIND v(dout0_46) AT=990.025n

.meas tran vdout0_47ck1970 FIND v(dout0_47) AT=990.025n

.meas tran vdout0_48ck1970 FIND v(dout0_48) AT=990.025n

.meas tran vdout0_49ck1970 FIND v(dout0_49) AT=990.025n

.meas tran vdout0_50ck1970 FIND v(dout0_50) AT=990.025n

.meas tran vdout0_51ck1970 FIND v(dout0_51) AT=990.025n

.meas tran vdout0_52ck1970 FIND v(dout0_52) AT=990.025n

.meas tran vdout0_53ck1970 FIND v(dout0_53) AT=990.025n

.meas tran vdout0_54ck1970 FIND v(dout0_54) AT=990.025n

.meas tran vdout0_55ck1970 FIND v(dout0_55) AT=990.025n

.meas tran vdout0_56ck1970 FIND v(dout0_56) AT=990.025n

.meas tran vdout0_57ck1970 FIND v(dout0_57) AT=990.025n

.meas tran vdout0_58ck1970 FIND v(dout0_58) AT=990.025n

.meas tran vdout0_59ck1970 FIND v(dout0_59) AT=990.025n

.meas tran vdout0_60ck1970 FIND v(dout0_60) AT=990.025n

.meas tran vdout0_61ck1970 FIND v(dout0_61) AT=990.025n

.meas tran vdout0_62ck1970 FIND v(dout0_62) AT=990.025n

.meas tran vdout0_63ck1970 FIND v(dout0_63) AT=990.025n

.meas tran vdout0_64ck1970 FIND v(dout0_64) AT=990.025n

.meas tran vdout0_65ck1970 FIND v(dout0_65) AT=990.025n

.meas tran vdout0_66ck1970 FIND v(dout0_66) AT=990.025n

.meas tran vdout0_67ck1970 FIND v(dout0_67) AT=990.025n

.meas tran vdout0_68ck1970 FIND v(dout0_68) AT=990.025n

.meas tran vdout0_69ck1970 FIND v(dout0_69) AT=990.025n

.meas tran vdout0_70ck1970 FIND v(dout0_70) AT=990.025n

.meas tran vdout0_71ck1970 FIND v(dout0_71) AT=990.025n

.meas tran vdout0_72ck1970 FIND v(dout0_72) AT=990.025n

.meas tran vdout0_73ck1970 FIND v(dout0_73) AT=990.025n

.meas tran vdout0_74ck1970 FIND v(dout0_74) AT=990.025n

.meas tran vdout0_75ck1970 FIND v(dout0_75) AT=990.025n

.meas tran vdout0_76ck1970 FIND v(dout0_76) AT=990.025n

.meas tran vdout0_77ck1970 FIND v(dout0_77) AT=990.025n

.meas tran vdout0_78ck1970 FIND v(dout0_78) AT=990.025n

.meas tran vdout0_79ck1970 FIND v(dout0_79) AT=990.025n

.meas tran vdout0_80ck1970 FIND v(dout0_80) AT=990.025n

.meas tran vdout0_81ck1970 FIND v(dout0_81) AT=990.025n

.meas tran vdout0_82ck1970 FIND v(dout0_82) AT=990.025n

.meas tran vdout0_83ck1970 FIND v(dout0_83) AT=990.025n

.meas tran vdout0_84ck1970 FIND v(dout0_84) AT=990.025n

.meas tran vdout0_85ck1970 FIND v(dout0_85) AT=990.025n

.meas tran vdout0_86ck1970 FIND v(dout0_86) AT=990.025n

.meas tran vdout0_87ck1970 FIND v(dout0_87) AT=990.025n

.meas tran vdout0_88ck1970 FIND v(dout0_88) AT=990.025n

.meas tran vdout0_89ck1970 FIND v(dout0_89) AT=990.025n

.meas tran vdout0_90ck1970 FIND v(dout0_90) AT=990.025n

.meas tran vdout0_91ck1970 FIND v(dout0_91) AT=990.025n

.meas tran vdout0_92ck1970 FIND v(dout0_92) AT=990.025n

.meas tran vdout0_93ck1970 FIND v(dout0_93) AT=990.025n

.meas tran vdout0_94ck1970 FIND v(dout0_94) AT=990.025n

.meas tran vdout0_95ck1970 FIND v(dout0_95) AT=990.025n

.meas tran vdout0_96ck1970 FIND v(dout0_96) AT=990.025n

.meas tran vdout0_97ck1970 FIND v(dout0_97) AT=990.025n

.meas tran vdout0_98ck1970 FIND v(dout0_98) AT=990.025n

.meas tran vdout0_99ck1970 FIND v(dout0_99) AT=990.025n

.meas tran vdout0_100ck1970 FIND v(dout0_100) AT=990.025n

.meas tran vdout0_101ck1970 FIND v(dout0_101) AT=990.025n

.meas tran vdout0_102ck1970 FIND v(dout0_102) AT=990.025n

.meas tran vdout0_103ck1970 FIND v(dout0_103) AT=990.025n

.meas tran vdout0_104ck1970 FIND v(dout0_104) AT=990.025n

.meas tran vdout0_105ck1970 FIND v(dout0_105) AT=990.025n

.meas tran vdout0_106ck1970 FIND v(dout0_106) AT=990.025n

.meas tran vdout0_107ck1970 FIND v(dout0_107) AT=990.025n

.meas tran vdout0_108ck1970 FIND v(dout0_108) AT=990.025n

.meas tran vdout0_109ck1970 FIND v(dout0_109) AT=990.025n

.meas tran vdout0_110ck1970 FIND v(dout0_110) AT=990.025n

.meas tran vdout0_111ck1970 FIND v(dout0_111) AT=990.025n

.meas tran vdout0_112ck1970 FIND v(dout0_112) AT=990.025n

.meas tran vdout0_113ck1970 FIND v(dout0_113) AT=990.025n

.meas tran vdout0_114ck1970 FIND v(dout0_114) AT=990.025n

.meas tran vdout0_115ck1970 FIND v(dout0_115) AT=990.025n

.meas tran vdout0_116ck1970 FIND v(dout0_116) AT=990.025n

.meas tran vdout0_117ck1970 FIND v(dout0_117) AT=990.025n

.meas tran vdout0_118ck1970 FIND v(dout0_118) AT=990.025n

.meas tran vdout0_119ck1970 FIND v(dout0_119) AT=990.025n

.meas tran vdout0_120ck1970 FIND v(dout0_120) AT=990.025n

.meas tran vdout0_121ck1970 FIND v(dout0_121) AT=990.025n

.meas tran vdout0_122ck1970 FIND v(dout0_122) AT=990.025n

.meas tran vdout0_123ck1970 FIND v(dout0_123) AT=990.025n

.meas tran vdout0_124ck1970 FIND v(dout0_124) AT=990.025n

.meas tran vdout0_125ck1970 FIND v(dout0_125) AT=990.025n

.meas tran vdout0_126ck1970 FIND v(dout0_126) AT=990.025n

.meas tran vdout0_127ck1970 FIND v(dout0_127) AT=990.025n

.meas tran vdout0_128ck1970 FIND v(dout0_128) AT=990.025n

.meas tran vdout0_129ck1970 FIND v(dout0_129) AT=990.025n

.meas tran vdout0_130ck1970 FIND v(dout0_130) AT=990.025n

.meas tran vdout0_131ck1970 FIND v(dout0_131) AT=990.025n

.meas tran vdout0_132ck1970 FIND v(dout0_132) AT=990.025n

.meas tran vdout0_133ck1970 FIND v(dout0_133) AT=990.025n

.meas tran vdout0_134ck1970 FIND v(dout0_134) AT=990.025n

.meas tran vdout0_135ck1970 FIND v(dout0_135) AT=990.025n

.meas tran vdout0_136ck1970 FIND v(dout0_136) AT=990.025n

.meas tran vdout0_137ck1970 FIND v(dout0_137) AT=990.025n

.meas tran vdout0_138ck1970 FIND v(dout0_138) AT=990.025n

.meas tran vdout0_139ck1970 FIND v(dout0_139) AT=990.025n

.meas tran vdout0_140ck1970 FIND v(dout0_140) AT=990.025n

.meas tran vdout0_141ck1970 FIND v(dout0_141) AT=990.025n

.meas tran vdout0_142ck1970 FIND v(dout0_142) AT=990.025n

.meas tran vdout0_143ck1970 FIND v(dout0_143) AT=990.025n

.meas tran vdout0_144ck1970 FIND v(dout0_144) AT=990.025n

.meas tran vdout0_145ck1970 FIND v(dout0_145) AT=990.025n

.meas tran vdout0_146ck1970 FIND v(dout0_146) AT=990.025n

.meas tran vdout0_147ck1970 FIND v(dout0_147) AT=990.025n

.meas tran vdout0_148ck1970 FIND v(dout0_148) AT=990.025n

.meas tran vdout0_149ck1970 FIND v(dout0_149) AT=990.025n

.meas tran vdout0_0ck1990 FIND v(dout0_0) AT=1000.025n

.meas tran vdout0_1ck1990 FIND v(dout0_1) AT=1000.025n

.meas tran vdout0_2ck1990 FIND v(dout0_2) AT=1000.025n

.meas tran vdout0_3ck1990 FIND v(dout0_3) AT=1000.025n

.meas tran vdout0_4ck1990 FIND v(dout0_4) AT=1000.025n

.meas tran vdout0_5ck1990 FIND v(dout0_5) AT=1000.025n

.meas tran vdout0_6ck1990 FIND v(dout0_6) AT=1000.025n

.meas tran vdout0_7ck1990 FIND v(dout0_7) AT=1000.025n

.meas tran vdout0_8ck1990 FIND v(dout0_8) AT=1000.025n

.meas tran vdout0_9ck1990 FIND v(dout0_9) AT=1000.025n

.meas tran vdout0_10ck1990 FIND v(dout0_10) AT=1000.025n

.meas tran vdout0_11ck1990 FIND v(dout0_11) AT=1000.025n

.meas tran vdout0_12ck1990 FIND v(dout0_12) AT=1000.025n

.meas tran vdout0_13ck1990 FIND v(dout0_13) AT=1000.025n

.meas tran vdout0_14ck1990 FIND v(dout0_14) AT=1000.025n

.meas tran vdout0_15ck1990 FIND v(dout0_15) AT=1000.025n

.meas tran vdout0_16ck1990 FIND v(dout0_16) AT=1000.025n

.meas tran vdout0_17ck1990 FIND v(dout0_17) AT=1000.025n

.meas tran vdout0_18ck1990 FIND v(dout0_18) AT=1000.025n

.meas tran vdout0_19ck1990 FIND v(dout0_19) AT=1000.025n

.meas tran vdout0_20ck1990 FIND v(dout0_20) AT=1000.025n

.meas tran vdout0_21ck1990 FIND v(dout0_21) AT=1000.025n

.meas tran vdout0_22ck1990 FIND v(dout0_22) AT=1000.025n

.meas tran vdout0_23ck1990 FIND v(dout0_23) AT=1000.025n

.meas tran vdout0_24ck1990 FIND v(dout0_24) AT=1000.025n

.meas tran vdout0_25ck1990 FIND v(dout0_25) AT=1000.025n

.meas tran vdout0_26ck1990 FIND v(dout0_26) AT=1000.025n

.meas tran vdout0_27ck1990 FIND v(dout0_27) AT=1000.025n

.meas tran vdout0_28ck1990 FIND v(dout0_28) AT=1000.025n

.meas tran vdout0_29ck1990 FIND v(dout0_29) AT=1000.025n

.meas tran vdout0_30ck1990 FIND v(dout0_30) AT=1000.025n

.meas tran vdout0_31ck1990 FIND v(dout0_31) AT=1000.025n

.meas tran vdout0_32ck1990 FIND v(dout0_32) AT=1000.025n

.meas tran vdout0_33ck1990 FIND v(dout0_33) AT=1000.025n

.meas tran vdout0_34ck1990 FIND v(dout0_34) AT=1000.025n

.meas tran vdout0_35ck1990 FIND v(dout0_35) AT=1000.025n

.meas tran vdout0_36ck1990 FIND v(dout0_36) AT=1000.025n

.meas tran vdout0_37ck1990 FIND v(dout0_37) AT=1000.025n

.meas tran vdout0_38ck1990 FIND v(dout0_38) AT=1000.025n

.meas tran vdout0_39ck1990 FIND v(dout0_39) AT=1000.025n

.meas tran vdout0_40ck1990 FIND v(dout0_40) AT=1000.025n

.meas tran vdout0_41ck1990 FIND v(dout0_41) AT=1000.025n

.meas tran vdout0_42ck1990 FIND v(dout0_42) AT=1000.025n

.meas tran vdout0_43ck1990 FIND v(dout0_43) AT=1000.025n

.meas tran vdout0_44ck1990 FIND v(dout0_44) AT=1000.025n

.meas tran vdout0_45ck1990 FIND v(dout0_45) AT=1000.025n

.meas tran vdout0_46ck1990 FIND v(dout0_46) AT=1000.025n

.meas tran vdout0_47ck1990 FIND v(dout0_47) AT=1000.025n

.meas tran vdout0_48ck1990 FIND v(dout0_48) AT=1000.025n

.meas tran vdout0_49ck1990 FIND v(dout0_49) AT=1000.025n

.meas tran vdout0_50ck1990 FIND v(dout0_50) AT=1000.025n

.meas tran vdout0_51ck1990 FIND v(dout0_51) AT=1000.025n

.meas tran vdout0_52ck1990 FIND v(dout0_52) AT=1000.025n

.meas tran vdout0_53ck1990 FIND v(dout0_53) AT=1000.025n

.meas tran vdout0_54ck1990 FIND v(dout0_54) AT=1000.025n

.meas tran vdout0_55ck1990 FIND v(dout0_55) AT=1000.025n

.meas tran vdout0_56ck1990 FIND v(dout0_56) AT=1000.025n

.meas tran vdout0_57ck1990 FIND v(dout0_57) AT=1000.025n

.meas tran vdout0_58ck1990 FIND v(dout0_58) AT=1000.025n

.meas tran vdout0_59ck1990 FIND v(dout0_59) AT=1000.025n

.meas tran vdout0_60ck1990 FIND v(dout0_60) AT=1000.025n

.meas tran vdout0_61ck1990 FIND v(dout0_61) AT=1000.025n

.meas tran vdout0_62ck1990 FIND v(dout0_62) AT=1000.025n

.meas tran vdout0_63ck1990 FIND v(dout0_63) AT=1000.025n

.meas tran vdout0_64ck1990 FIND v(dout0_64) AT=1000.025n

.meas tran vdout0_65ck1990 FIND v(dout0_65) AT=1000.025n

.meas tran vdout0_66ck1990 FIND v(dout0_66) AT=1000.025n

.meas tran vdout0_67ck1990 FIND v(dout0_67) AT=1000.025n

.meas tran vdout0_68ck1990 FIND v(dout0_68) AT=1000.025n

.meas tran vdout0_69ck1990 FIND v(dout0_69) AT=1000.025n

.meas tran vdout0_70ck1990 FIND v(dout0_70) AT=1000.025n

.meas tran vdout0_71ck1990 FIND v(dout0_71) AT=1000.025n

.meas tran vdout0_72ck1990 FIND v(dout0_72) AT=1000.025n

.meas tran vdout0_73ck1990 FIND v(dout0_73) AT=1000.025n

.meas tran vdout0_74ck1990 FIND v(dout0_74) AT=1000.025n

.meas tran vdout0_75ck1990 FIND v(dout0_75) AT=1000.025n

.meas tran vdout0_76ck1990 FIND v(dout0_76) AT=1000.025n

.meas tran vdout0_77ck1990 FIND v(dout0_77) AT=1000.025n

.meas tran vdout0_78ck1990 FIND v(dout0_78) AT=1000.025n

.meas tran vdout0_79ck1990 FIND v(dout0_79) AT=1000.025n

.meas tran vdout0_80ck1990 FIND v(dout0_80) AT=1000.025n

.meas tran vdout0_81ck1990 FIND v(dout0_81) AT=1000.025n

.meas tran vdout0_82ck1990 FIND v(dout0_82) AT=1000.025n

.meas tran vdout0_83ck1990 FIND v(dout0_83) AT=1000.025n

.meas tran vdout0_84ck1990 FIND v(dout0_84) AT=1000.025n

.meas tran vdout0_85ck1990 FIND v(dout0_85) AT=1000.025n

.meas tran vdout0_86ck1990 FIND v(dout0_86) AT=1000.025n

.meas tran vdout0_87ck1990 FIND v(dout0_87) AT=1000.025n

.meas tran vdout0_88ck1990 FIND v(dout0_88) AT=1000.025n

.meas tran vdout0_89ck1990 FIND v(dout0_89) AT=1000.025n

.meas tran vdout0_90ck1990 FIND v(dout0_90) AT=1000.025n

.meas tran vdout0_91ck1990 FIND v(dout0_91) AT=1000.025n

.meas tran vdout0_92ck1990 FIND v(dout0_92) AT=1000.025n

.meas tran vdout0_93ck1990 FIND v(dout0_93) AT=1000.025n

.meas tran vdout0_94ck1990 FIND v(dout0_94) AT=1000.025n

.meas tran vdout0_95ck1990 FIND v(dout0_95) AT=1000.025n

.meas tran vdout0_96ck1990 FIND v(dout0_96) AT=1000.025n

.meas tran vdout0_97ck1990 FIND v(dout0_97) AT=1000.025n

.meas tran vdout0_98ck1990 FIND v(dout0_98) AT=1000.025n

.meas tran vdout0_99ck1990 FIND v(dout0_99) AT=1000.025n

.meas tran vdout0_100ck1990 FIND v(dout0_100) AT=1000.025n

.meas tran vdout0_101ck1990 FIND v(dout0_101) AT=1000.025n

.meas tran vdout0_102ck1990 FIND v(dout0_102) AT=1000.025n

.meas tran vdout0_103ck1990 FIND v(dout0_103) AT=1000.025n

.meas tran vdout0_104ck1990 FIND v(dout0_104) AT=1000.025n

.meas tran vdout0_105ck1990 FIND v(dout0_105) AT=1000.025n

.meas tran vdout0_106ck1990 FIND v(dout0_106) AT=1000.025n

.meas tran vdout0_107ck1990 FIND v(dout0_107) AT=1000.025n

.meas tran vdout0_108ck1990 FIND v(dout0_108) AT=1000.025n

.meas tran vdout0_109ck1990 FIND v(dout0_109) AT=1000.025n

.meas tran vdout0_110ck1990 FIND v(dout0_110) AT=1000.025n

.meas tran vdout0_111ck1990 FIND v(dout0_111) AT=1000.025n

.meas tran vdout0_112ck1990 FIND v(dout0_112) AT=1000.025n

.meas tran vdout0_113ck1990 FIND v(dout0_113) AT=1000.025n

.meas tran vdout0_114ck1990 FIND v(dout0_114) AT=1000.025n

.meas tran vdout0_115ck1990 FIND v(dout0_115) AT=1000.025n

.meas tran vdout0_116ck1990 FIND v(dout0_116) AT=1000.025n

.meas tran vdout0_117ck1990 FIND v(dout0_117) AT=1000.025n

.meas tran vdout0_118ck1990 FIND v(dout0_118) AT=1000.025n

.meas tran vdout0_119ck1990 FIND v(dout0_119) AT=1000.025n

.meas tran vdout0_120ck1990 FIND v(dout0_120) AT=1000.025n

.meas tran vdout0_121ck1990 FIND v(dout0_121) AT=1000.025n

.meas tran vdout0_122ck1990 FIND v(dout0_122) AT=1000.025n

.meas tran vdout0_123ck1990 FIND v(dout0_123) AT=1000.025n

.meas tran vdout0_124ck1990 FIND v(dout0_124) AT=1000.025n

.meas tran vdout0_125ck1990 FIND v(dout0_125) AT=1000.025n

.meas tran vdout0_126ck1990 FIND v(dout0_126) AT=1000.025n

.meas tran vdout0_127ck1990 FIND v(dout0_127) AT=1000.025n

.meas tran vdout0_128ck1990 FIND v(dout0_128) AT=1000.025n

.meas tran vdout0_129ck1990 FIND v(dout0_129) AT=1000.025n

.meas tran vdout0_130ck1990 FIND v(dout0_130) AT=1000.025n

.meas tran vdout0_131ck1990 FIND v(dout0_131) AT=1000.025n

.meas tran vdout0_132ck1990 FIND v(dout0_132) AT=1000.025n

.meas tran vdout0_133ck1990 FIND v(dout0_133) AT=1000.025n

.meas tran vdout0_134ck1990 FIND v(dout0_134) AT=1000.025n

.meas tran vdout0_135ck1990 FIND v(dout0_135) AT=1000.025n

.meas tran vdout0_136ck1990 FIND v(dout0_136) AT=1000.025n

.meas tran vdout0_137ck1990 FIND v(dout0_137) AT=1000.025n

.meas tran vdout0_138ck1990 FIND v(dout0_138) AT=1000.025n

.meas tran vdout0_139ck1990 FIND v(dout0_139) AT=1000.025n

.meas tran vdout0_140ck1990 FIND v(dout0_140) AT=1000.025n

.meas tran vdout0_141ck1990 FIND v(dout0_141) AT=1000.025n

.meas tran vdout0_142ck1990 FIND v(dout0_142) AT=1000.025n

.meas tran vdout0_143ck1990 FIND v(dout0_143) AT=1000.025n

.meas tran vdout0_144ck1990 FIND v(dout0_144) AT=1000.025n

.meas tran vdout0_145ck1990 FIND v(dout0_145) AT=1000.025n

.meas tran vdout0_146ck1990 FIND v(dout0_146) AT=1000.025n

.meas tran vdout0_147ck1990 FIND v(dout0_147) AT=1000.025n

.meas tran vdout0_148ck1990 FIND v(dout0_148) AT=1000.025n

.meas tran vdout0_149ck1990 FIND v(dout0_149) AT=1000.025n
